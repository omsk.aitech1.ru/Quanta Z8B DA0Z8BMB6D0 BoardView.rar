# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CFG9: length 11.7
  BOTTOM w0.102: 92.51,101.41 92.98,101.88 92.98,103.76 93.9,104.69 U27.AT23
  BOTTOM w0.127: 92.51,101.41 90.3,99.21 90.3,98.85 90.5,98.65 90.5,96.87 v3(90.28,96.64) 89.3,95.66 R550.2
CFG10: length 17.6
  BOTTOM w0.102: 92.51,99.33 94.31,101.14 96.85,101.14 U27.AN20
  BOTTOM w0.127: R587.2 90.15,89.46 v3(90.2,89.5) 92.36,91.66 92.36,99.18 92.51,99.33
CFG11: length 11.1
  BOTTOM w0.102: U27.AP24 96,105.29 93.83,105.29 92.57,104.02 92.57,102.19 92.51,102.13
  BOTTOM w0.127: R539.2 89.29,99.51 v3(89.77,99.99) 90.37,99.99 92.51,102.13
CFG12: length 8.1
  BOTTOM w0.102: U27.AP26 96.02,108.07 93.85,108.07 92.77,106.98 92.51,106.98
  BOTTOM w0.127: R504.2 89.55,106.98 90.38,106.98 90.66,106.7 92.23,106.7 92.51,106.98
CFG13: length 8.7
  TOP w0.127: R103.2 89.34,108.17 92.34,108.17 v2(92.87,107.64) 92.99,107.51 96.57,107.51 v3(96.93,107.15)
  BOTTOM w0.127: v3(96.93,107.15) U27.AN25
CFG14: length 11.5
  BOTTOM w0.102: U27.AN26 96.81,108.27 93.75,108.27 92.71,107.23 92.51,107.23
  BOTTOM w0.127: 92.51,107.23 92.18,107.23 91.9,106.95 90.76,106.95 90.48,107.23 90.07,107.23 89.34,107.97 87.16,107.97 R502.2
CFG15: length 7.6
  BOTTOM w0.102: 92.51,105.83 92.69,105.83 93.16,106.3 96.01,106.3 U27.AP25
  BOTTOM w0.127: R511.2 89.42,106.04 v3(90.86,106.04) 91.57,106.04 91.77,105.83 92.51,105.83
CFG16: length 19.7
  IN2 w0.133: v3(84.33,99.89) 84.33,99.89 85.27,100.83 92.02,100.83 v5(93.79,102.6)
  BOTTOM w0.102: v5(93.79,102.6) 94.12,102.27 94.98,102.27 U27.AR21
  BOTTOM w0.127: v3(84.33,99.89) 84.33,99.56 83.24,98.47 83.24,97.86 83.72,97.38 85.32,97.38 85.9,97.96 R544.2 R546.2
CFG17: length 12
  BOTTOM w0.102: U27.AR23 95.02,105.07 93.9,105.07 92.77,103.94 92.77,102.04 92.51,101.77
  BOTTOM w0.127: 92.51,101.77 90,99.26 v3(90,98.49) 89.43,97.93 R545.2 89.31,96.73 R547.2
CFG18: length 18.6
  TOP w0.127: v3(96.89,102.2) 96.21,101.52 93.98,101.52 v2(91.6,99.13) 91.47,99 v3(90.78,99)
  BOTTOM w0.102: U27.AP21 v3(96.89,102.2)
  BOTTOM w0.127: v3(90.78,99) 90.78,96.16 89.49,94.86 85.48,94.86 85.26,94.64 R553.2 85.26,94.31 R558.2
CFG19: length 16.2
  BOTTOM w0.102: 92.51,101.05 93.18,101.73 93.18,103.58 93.87,104.27 95.98,104.27 U27.AP23
  BOTTOM w0.127: 92.51,101.05 91.24,99.79 91.24,95.5 v3(90.28,94.53) 90.06,94.32 R552.2 R557.2
CFG_RCOMP: length 8.2
  BOTTOM w0.381: 89.09,111.63 89.46,112 91.49,112 92.18,112.69 U27.AT31
  BOTTOM w0.508: 89.09,111.63 v3(89.01,111.63) 87.92,111.63 R490.1
CL_CLK: length 7.5
  TOP w0.089: 159.13,94.71 160.39,95.97 160.74,95.97 160.99,96.22 160.99,96.68 160.84,96.83 160.84,97.69 160.83,97.7 160.83,98.23 160.9,98.3 160.9,98.73 v3(160.43,99.2)
  TOP w0.127: TP52.1 158.68,94.26 159.13,94.71
  BOTTOM w0.102: U24.AF11 160.69,99.46 v3(160.43,99.2)
CL_CLK1_WLAN: length 4.4
  BOTTOM w0.127: R684.1 165.91,48.17 165.91,48.43 166.29,48.8 166.85,48.8 167.23,49.18 167.23,49.59 167.5,49.86 CN10.45
CL_DAT: length 1.3
  TOP w0.089: TP50.1 159.76,98.56 v3(160.5,98.56)
  BOTTOM w0.102: U24.AF10 160.81,98.86 v3(160.5,98.56)
CL_DATA1_WLAN: length 4.4
  BOTTOM w0.127: R683.1 165.66,48.22 165.66,48.53 166.18,49.06 166.74,49.06 166.97,49.29 166.97,49.59 166.7,49.86 CN10.47
CL_RST1#_WLAN: length 2.3
  BOTTOM w0.127: CN10.49 165.9,49.76 TP163.1
CL_RST#: length 2.2
  TOP w0.089: TP45.1 159.93,96.8 159.93,97.38 v3(160.43,97.88)
  BOTTOM w0.102: v3(160.43,97.88) 160.65,97.67 U24.AF7
CLK_BUF_CKSSCDN: length 8.6
  BOTTOM w0.102: U24.BE6 152.65,97.52 151.5,96.37 151.44,96.37 151.42,96.35
  BOTTOM w0.127: 151.42,96.35 151.22,96.16 151.22,95.69 150.44,94.91 150.44,92.97 149.15,91.69 149.15,91.17 R566.2
CLK_BUF_CKSSCDP: length 9.2
  BOTTOM w0.102: U24.BC6 153.45,97.2 152.62,97.2 151.64,96.23 151.64,96.16 151.62,96.14
  BOTTOM w0.127: 151.62,96.14 151.52,96.04 151.52,95.57 150.73,94.79 150.73,92.85 149.45,91.57 149.45,91.25 R565.2
CLK_BUF_CPYCKN: length 18.2
  IN2 w0.089: v3(157.61,105.24) 157.2,105.66 157.06,105.66 156.89,105.83 155.91,105.83 155.3,106.44 153.01,106.44 152.95,106.49 152.91,106.49
  IN2 w0.133: v3(144.45,110.69) 144.71,110.94 144.71,111.3 145.02,111.61 145.87,111.61 147.18,110.31 148.97,110.31 152.78,106.49 152.91,106.49
  BOTTOM w0.102: v3(157.61,105.24) 157.21,104.84 U24.AR24
  BOTTOM w0.127: R496.2 144.32,109.9 144.7,110.28 144.7,110.44 v3(144.45,110.69)
CLK_BUF_CPYCKP: length 17.1
  IN2 w0.089: 152.91,106.2 152.95,106.2 153.01,106.26 155.23,106.26 155.84,105.65 156.82,105.65 156.96,105.5 v3(156.96,105.24)
  IN2 w0.133: 152.91,106.2 152.66,106.2 148.85,110.01 147.06,110.01 145.75,111.32 145.14,111.32 145,111.17 145,110.9 v3(145.21,110.69)
  BOTTOM w0.102: v3(156.96,105.24) 156.62,104.9 U24.AT24
  BOTTOM w0.127: v3(145.21,110.69) 144.99,110.46 144.99,110.28 R497.2
CLK_BUF_DOT96N: length 4.7
  TOP w0.102: v3(168.56,109.15) 168.98,109.58 169.41,109.58 170.08,110.25 170.62,110.25 171.33,110.97 R93.2
  BOTTOM w0.102: U24.H33 168.39,108.98 v3(168.56,109.15)
CLK_BUF_DOT96P: length 1.9
  TOP w0.102: R96.2 169.95,109.77 169.33,109.15 v3(169.21,109.15)
  BOTTOM w0.102: v3(169.21,109.15) 168.99,108.93 U24.G33
CLK_BUF_EXPN: length 17.3
  IN2 w0.089: 153.36,105.36 153.38,105.36 153.44,105.3 154.51,105.3 154.79,105.02 154.93,105.02 155.01,105.11 v3(155.01,105.24)
  IN2 w0.133: v3(142.88,110.86) 142.65,110.64 142.65,110.18 143.38,109.44 148.64,109.44 152.73,105.36 153.36,105.36
  BOTTOM w0.102: v3(155.01,105.24) 154.82,105.06 U24.AY24
  BOTTOM w0.127: R495.2 142.64,110.27 142.64,110.63 v3(142.88,110.86)
CLK_BUF_EXPP: length 18.5
  IN2 w0.089: v3(155.66,105.24) 155.26,104.84 154.72,104.84 154.44,105.12 153.44,105.12 153.38,105.07
  IN2 w0.133: v3(142.11,110.86) 142.36,110.62 142.36,110.06 143.26,109.15 148.52,109.15 152.6,105.07 153.38,105.07
  BOTTOM w0.102: v3(155.66,105.24) 155.42,105 U24.AW24
  BOTTOM w0.127: v3(142.11,110.86) 142.35,110.63 142.35,110.27 142.14,110.06 R494.2
CLK_BUF_REF14: length 5.3
  BOTTOM w0.089: 170.72,116.02 170.28,115.58 170.28,115.49 169.13,114.34 U24.F45
  BOTTOM w0.381: 170.72,116.02 171.07,116.02 171.89,116.83 171.89,117.36 R476.2
CLK_CPU_BCLKN: length 38.2
  IN2 w0.102: 156.86,114.59 156.87,114.58 156.94,114.58 157.91,113.61 158.47,113.61 159.92,112.16 159.92,111.53 v3(160.45,111)
  IN2 w0.133: 156.86,114.59 155.68,115.77 155.04,115.77 151.79,119.02 151.79,119.6 150.72,120.68 146.66,120.68 144.11,123.24 143.49,123.24 v3(143.35,123.1)
  BOTTOM w0.102: v3(160.45,111) 160.69,111.23 U24.AF39
  BOTTOM w0.127: R738.1 135.91,112.95 136.55,112.95 138.5,114.9 138.5,116.43 141.24,119.18 141.24,121.67 142.86,123.29 143.15,123.29 v3(143.35,123.1)
CLK_CPU_BCLKN_R: length 13.8
  IN2 w0.102: v3(126.93,108.15) 126.64,108.15 126.53,108.26 126.53,108.46 126.65,108.58 127.18,108.58 127.28,108.68 127.54,108.68 127.59,108.64 127.61,108.64
  IN2 w0.133: v4(132.99,113.45) 132.81,113.63 132.41,113.63 132.27,113.5 132.27,111.73 130.81,110.27 129.97,110.27 129.15,109.45 128.34,108.64 127.61,108.64
  BOTTOM w0.114: U27.D26 126.4,108.1 126.6,108.3 126.79,108.3 v3(126.93,108.15)
  BOTTOM w0.127: v4(132.99,113.45) 133.23,113.69 133.41,113.69 134.15,112.95 134.41,112.95 R738.2
CLK_CPU_BCLKP: length 38.2
  IN2 w0.102: v3(160.45,111.64) 160.12,111.97 160.12,112.24 158.56,113.81 157.99,113.81 157.08,114.72 157.08,114.78 157.06,114.8
  IN2 w0.133: 157.06,114.8 155.8,116.06 155.16,116.06 152.08,119.14 152.08,119.73 150.84,120.97 146.79,120.97 144.23,123.53 143.68,123.53 v4(143.35,123.86)
  BOTTOM w0.102: v3(160.45,111.64) 160.45,111.82 160.6,111.97 160.78,111.97 U24.AF40
  BOTTOM w0.127: v4(143.35,123.86) 143.07,123.59 142.74,123.59 140.95,121.79 140.95,119.3 138.21,116.56 138.21,115.02 136.43,113.25 135.91,113.25 R739.1
CLK_CPU_BCLKP_R: length 13.8
  IN2 w0.102: 127.61,108.93 127.59,108.93 127.54,108.88 127.2,108.88 127.1,108.78 126.56,108.78 126.33,108.55 126.33,108.29 126.2,108.15 v3(125.93,108.15)
  IN2 w0.133: v3(132.99,114.22) 132.7,113.92 132.28,113.92 131.98,113.62 131.98,111.85 130.69,110.56 129.85,110.56 128.21,108.93 127.61,108.93
  BOTTOM w0.114: U27.E26 125.46,107.69 v3(125.93,108.15)
  BOTTOM w0.127: v3(132.99,114.22) 133.23,113.98 133.53,113.98 134.27,113.25 134.41,113.25 R739.2
CLK_DPLL_NSCLKN: length 44.8
  IN2 w0.102: 161.41,112 161.41,111.98 161.37,111.93 161.37,111.39 161.07,111.09 161.07,109.82 161.05,109.8 161.05,109.64 v3(160.46,109.05)
  IN2 w0.133: 161.41,112 161.41,113 160.38,114.04 160.38,114.66 159.76,115.27 159.09,115.27 157.07,117.29 155.29,117.29 153.7,118.89 153.7,120.55 152.15,122.09 147.28,122.09 143.29,126.08 v3(143.29,126.3)
  BOTTOM w0.102: U24.AF35 160.85,109.44 v3(160.46,109.05)
  BOTTOM w0.127: v3(143.29,126.3) 143.29,126 143.49,125.81 143.49,125.31 142.83,124.64 140.66,124.64 139.25,123.23 139.25,119.5 136.76,117.02 135.91,117.02 R734.1
CLK_DPLL_NSCLKN_R: length 16.5
  IN2 w0.102: 125.42,110.87 125.4,110.87 125.35,110.91 125.02,110.91 124.69,110.58 123.61,110.58 123.47,110.45 123.47,110.23 123.53,110.17 v5(123.89,110.17)
  IN2 w0.133: v3(132.24,117.16) 132.06,117.33 131.84,117.33 130.89,116.38 130.89,116.04 129.6,114.75 128.39,113.54 128.07,113.23 128.07,113.18 125.76,110.87 125.42,110.87
  BOTTOM w0.102: U27.G28 123.4,109.93 123.65,110.17 v5(123.89,110.17)
  BOTTOM w0.127: v3(132.24,117.16) 132.24,117.29 132.38,117.43 133.59,117.43 133.97,117.05 134.37,117.05 R734.2
CLK_DPLL_NSCLKP: length 44.8
  IN2 w0.102: v3(160.47,109.7) 160.61,109.57 160.68,109.57 160.85,109.73 160.85,109.88 160.87,109.91 160.87,111.18 161.16,111.47 161.16,111.93 161.12,111.98 161.12,112
  IN2 w0.133: 161.12,112 161.12,112.88 160.09,113.92 160.09,114.53 159.64,114.98 158.97,114.98 156.95,117 155.17,117 153.41,118.77 153.41,120.43 152.03,121.8 147.16,121.8 143.06,125.9 142.89,125.9 v4(142.66,125.67)
  BOTTOM w0.102: v3(160.47,109.7) 160.33,109.7 160.25,109.78 160.25,110.2 160.33,110.29 160.67,110.29 U24.AF36
  BOTTOM w0.127: R735.1 135.91,117.31 136.64,117.31 138.96,119.62 138.96,123.35 140.54,124.94 142.7,124.94 143.2,125.43 143.2,125.69 143.04,125.85 142.84,125.85 v4(142.66,125.67)
CLK_DPLL_NSCLKP_R: length 16.5
  IN2 w0.102: 125.42,111.16 125.4,111.16 125.35,111.12 124.94,111.12 124.61,110.79 123.52,110.79 123.27,110.53 123.27,110.28 123.16,110.17 v3(122.89,110.17)
  IN2 w0.133: 125.42,111.16 125.64,111.16 126.54,112.06 127.78,113.3 127.78,113.35 130.6,116.16 130.6,116.5 131.72,117.63 131.94,117.63 v3(132.24,117.92)
  BOTTOM w0.102: U27.H28 v3(122.89,110.17)
  BOTTOM w0.127: v3(132.24,117.92) 132.43,117.72 133.71,117.72 134.09,117.34 134.44,117.34 R735.2
CLK_DPLL_SSCLKN: length 36.6
  IN2 w0.102: v3(159.45,111.64) 159.31,111.5 158.71,111.5 158.17,112.04 158.17,112.47 156.25,114.39 156.25,114.45 156.23,114.47
  IN2 w0.133: 156.23,114.47 155.51,115.19 154.82,115.19 150.07,119.93 145.17,119.93 142.32,122.79 142.32,123.34 141.71,123.95 v3(141.71,124.09)
  BOTTOM w0.102: v3(159.45,111.64) 159.76,111.64 U24.AJ40
  BOTTOM w0.127: v3(141.71,124.09) 140.98,124.09 140.15,123.26 140.15,119.67 138.75,118.27 137.35,116.87 136.12,115.65 136.12,115.33 136.05,115.26 135.93,115.26 R736.1
CLK_DPLL_SSCLKN_R: length 16
  TOP w0.127: R65.1 133.84,115.65 133.44,115.65 v3(133.17,115.92)
  IN2 w0.102: v3(124.9,109.19) 125.26,109.55 125.26,109.84 125.57,110.15 125.93,110.15 126.12,110.34 126.12,110.4 126.14,110.42
  IN2 w0.133: 126.14,110.42 127.09,111.37 128.93,111.37 129.01,111.45 130.67,113.11 130.67,114.13 132.19,115.66 132.91,115.66 v3(133.17,115.92)
  BOTTOM w0.102: U27.F27 v3(124.9,109.19)
  BOTTOM w0.127: v3(133.17,115.92) 133.17,115.82 133.38,115.61 133.86,115.61 134.22,115.26 134.39,115.26 R736.2
CLK_DPLL_SSCLKP: length 36.5
  IN2 w0.102: v3(159.45,110.99) 159.45,111.08 159.24,111.29 158.63,111.29 157.96,111.96 157.96,112.39 156.11,114.24 156.05,114.24 156.03,114.26
  IN2 w0.133: 156.03,114.26 155.39,114.9 154.69,114.9 149.95,119.64 145.05,119.64 142.03,122.67 142.03,123.22 141.69,123.56 v4(141.17,123.56)
  BOTTOM w0.102: v3(159.45,110.99) 159.6,110.85 159.72,110.85 159.94,111.07 U24.AJ39
  BOTTOM w0.127: R737.1 135.89,114.97 136.17,114.97 136.41,115.21 136.41,115.52 138.96,118.07 140.44,119.55 140.44,123.14 140.86,123.56 v4(141.17,123.56)
CLK_DPLL_SSCLKP_R: length 16
  TOP w0.127: v4(133.17,115.16) 133.38,115.36 133.77,115.36 R68.1
  IN2 w0.102: v3(125.9,109.19) 125.58,109.19 125.46,109.31 125.46,109.76 125.66,109.95 126.02,109.95 126.26,110.19 126.33,110.19 126.34,110.21
  IN2 w0.133: 126.34,110.21 127.21,111.08 129.05,111.08 130.96,112.99 130.96,114.01 132.31,115.36 132.97,115.36 v4(133.17,115.16)
  BOTTOM w0.102: v3(125.9,109.19) 125.45,109.19 125.26,109 125.26,108.82 U27.E27
  BOTTOM w0.127: R737.2 134.42,114.97 134.1,114.97 133.74,115.32 133.34,115.32 v4(133.17,115.16)
CLK_FLEX0: length 5.8
  TOP w0.114: TP19.1 172.22,115.02 172.22,113.54 v3(172.45,113.31)
  BOTTOM w0.102: U24.C40 171.05,111.36 171.41,111.72 171.75,111.72 172.57,112.55 172.57,113.19 v3(172.45,113.31)
CLK_FLEX1: length 9.2
  BOTTOM w0.079: U24.F38 168.67,111.53 168.25,111.53 168.02,111.76 168.02,112.02 168.2,112.21 168.2,112.54 167.98,112.75 167.98,112.97 168.1,113.08
  BOTTOM w0.089: 168.05,114.17 167.93,114.05 167.93,113.68 168.18,113.42 168.18,113.16 168.1,113.08
  BOTTOM w0.102: 168.05,114.17 169.65,115.77 169.65,117.06 TP87.1
CLK_FLEX2: length 1.3
  TOP w0.102: v3(169.33,110.1) 169.33,110.73 TP25.1
  BOTTOM w0.102: U24.F36 169.58,109.85 v3(169.33,110.1)
CLK_PCH_PCI0: length 1.6
  TOP w0.102: v3(170.53,112.77) 170.72,112.97 TP21.1
  BOTTOM w0.102: v3(170.53,112.77) 170.2,113.1 U24.D44
CLK_PCH_PCI1: length 8.3
  BOTTOM w0.114: U24.E44 169.46,113.31 169.46,114.17 170.39,115.11
  BOTTOM w0.127: R467.2 173.1,118.75 172.9,118.56 172.9,116.77 171.24,115.11 170.39,115.11
CLK_PCH_PCI2: length 2.9
  TOP w0.102: v3(170.95,111.84) 171.39,112.29 172.96,112.29 R86.2
  BOTTOM w0.102: U24.B42 170.95,112.3 v3(170.95,111.84)
CLK_PCH_PCI3: length 7.5
  BOTTOM w0.089: 169.05,113.3 169.05,113.28 169.42,112.91
  BOTTOM w0.102: U24.F41 169.42,112.5 169.42,112.91 ; 170.34,116.71 169.9,116.27 169.9,115.52 168.74,114.35 168.74,113.7 169.05,113.4 169.05,113.3
  BOTTOM w0.127: 170.34,116.71 170.79,117.16 170.79,117.24 171.12,117.57 R474.2
CLK_PCH_PCI4: length 3.8
  TOP w0.114: R69.2 172.88,113.88 v3(172.95,113.8)
  BOTTOM w0.102: U24.A40 171.66,111.52 171.9,111.52 172.28,111.9
  BOTTOM w0.114: 172.28,111.9 172.95,112.57 v3(172.95,113.8)
CLK_PCI_EC: length 116.8
  TOP w0.102: R69.1 C116.2 174.32,116.61 174.73,117.02 175.64,117.02 175.67,116.99 175.7,116.99
  TOP w0.127: R303.2 162.41,55.18 163.41,56.18 164.8,56.18 164.93,56.05 166.29,56.05 166.57,56.33 U13.13 168.38,56.33 168.55,56.16 168.55,55.09 169.04,54.6 169.42,54.6 169.91,54.11 174.16,54.11 175.21,55.16 177.04,55.16 179.37,57.49 179.37,57.8 181.94,60.37 181.94,61.11 182.98,62.14 188.83,62.14 v4(189.06,62.37) ; v3(176.08,116.6) 175.7,116.99
  IN2 w0.133: v4(189.06,62.37) 188.8,62.63 188.8,63.09 187.63,64.26 187.63,70.63 182.76,75.49 182.76,81.53 186.4,85.18 188.15,85.18 193.91,90.94 193.91,92.23 194.26,92.58 194.26,94.68 195.08,95.5 195.08,110.25 189.35,115.98 186.34,115.98 185.82,115.46 185.44,115.46 184.87,116.03 180.63,116.03 179.72,116.94 176.41,116.94 v3(176.08,116.6)
CLK_PCI_FB: length 35.8
  TOP w0.102: 174.01,114.69 174.78,115.46
  TOP w0.114: 174.01,114.69 174.01,113.64 173.56,113.18 R86.1
  TOP w0.127: 174.78,115.46 175.19,115.87 v2(175.26,115.87) 175.67,115.87 175.84,115.7 176.21,115.7 176.41,115.91 179.11,115.91 179.24,115.78 180.15,115.78 180.55,115.39 180.55,114.88 180.73,114.7 182.1,114.7 182.5,114.29 182.5,113.25 182.02,112.77 179.71,112.77 179.6,112.66 179.6,112.18 179.3,111.88 177.75,111.88 177.52,111.65 177.52,106.47 177.73,106.26 v3(177.73,105.5)
  BOTTOM w0.102: U24.D17 170.65,102.01 170.96,101.71 171.17,101.71 171.37,101.91 171.37,101.91 171.39,101.91 171.39,101.91 171.91,101.91 172.02,101.8 174.74,101.8 174.84,101.9 175.35,101.9 175.65,102.2 175.65,102.36 176.03,102.74 176.03,102.74 176.91,103.62 176.91,104.5 177.05,104.64 177.47,104.64 177.73,104.89 v3(177.73,105.5)
CLK_PCI_LPC: length 136.5
  IN2 w0.133: v4(180.88,119.78) 181.76,118.9 185.36,118.9 186.89,117.36 189.47,117.36 196.14,110.69 196.14,91.68 188.62,84.15 186.83,84.15 184.08,81.4 184.08,76.34 188.72,71.7 188.72,67.46 189.13,67.05 189.13,66.41 188.65,65.93 188.65,63.98 189.34,63.28 189.34,63.17 191.08,61.43 191.08,60.04 v3(191.72,59.4)
  BOTTOM w0.127: v3(191.72,59.4) 192.04,59.08 192.04,56.64 192.5,56.18 192.5,49.87 190.79,48.16 190.79,45.62 188.2,43.03 185.02,43.03 184.3,43.74 182.08,43.74 179.18,46.65 172.18,46.65 170.67,45.14 167.07,45.14 166.58,45.64 166.58,46.73 R684.2 ; v4(180.88,119.78) 180.37,120.29 179.1,120.29 178.79,119.98 178.79,119.45 178.39,119.04 176.08,119.04 174.83,120.29 171.14,120.29 C409.2 R474.1
CLK_PCIE_LAN_REQ#: length 282.3
  TOP w0.127: v3(32.95,105.04) Q18.3 33.79,106.62 35.21,105.2 v2(35.21,105.02) 35.49,104.75 R130.2
  IN2 w0.133: v3(154.94,70.55) 155.42,70.08 155.42,66.31 154.93,65.82 154.93,64.95 155.24,64.64 155.24,52.03 155.6,51.67 155.6,48.38 148.06,40.84 148.06,30.09 143.06,25.09 70.74,25.09 67.74,22.09 51.35,22.09 44.12,29.32 44.12,29.58 38.82,34.88 38.82,36.54 36,39.36 31.47,39.36 30.66,38.54 22.34,38.54 18.33,42.55 18.33,55.99 24.74,62.4 24.74,67.41 27.79,70.45 27.79,72.83 28.51,73.56 30.09,73.56 31.67,75.13 31.67,90.59 30.35,91.91 30.35,97 30.05,97.3 30.05,102.14 v3(32.95,105.04)
  BOTTOM w0.127: R638.1 167.08,81.45 167.08,79.09 158.55,70.55 v3(154.94,70.55)
CLK_PCIE_LANN: length 159.7
  TOP w0.127: v4(31.86,100.46) 31.57,100.17 31.29,100.17 30.81,99.69 30.77,99.69 30.71,99.74 U7.16
  IN2 w0.133: v4(31.86,100.46) 31.86,100.3 31.72,100.16 31.49,100.16 31.32,100.32 31.32,101.14 35.01,104.82 46.29,104.82 46.76,105.29 53.9,105.29 56,103.19 70.27,103.19 84.14,117.06 85.31,117.06 89.53,121.28 90.34,121.28 95.78,126.71 96.73,126.71 98.83,128.81 101.53,128.81 104.07,131.35 111.26,131.35 114.87,127.74 119.98,127.74 121.16,128.92 121.16,128.95 121.64,129.43 126.45,129.43 127.03,128.85 135.88,128.85 137.32,127.41 143.27,127.41 148.07,122.61 152.37,122.61 154.57,120.41 154.57,119.65 156.26,117.97 157.39,117.97 159.22,116.13 159.78,116.13 159.86,116.06 v3(159.86,115.83)
  BOTTOM w0.102: 160.85,115.62 160.85,115.61 160.89,115.57 160.89,114.33 161.34,113.88 161.34,113.77 161.8,113.31 U24.AD43
  BOTTOM w0.127: 160.85,115.62 160.85,115.71 160.42,116.13 159.96,116.13 159.86,116.03 v3(159.86,115.83)
CLK_PCIE_LANP: length 159.7
  TOP w0.127: v3(31.86,99.7) 31.67,99.88 31.41,99.88 30.93,99.4 30.77,99.4 30.71,99.34 U7.15
  IN2 w0.133: v3(31.86,99.7) 31.69,99.87 31.37,99.87 31.03,100.2 31.03,101.26 34.88,105.11 46.17,105.11 46.64,105.58 54.02,105.58 56.12,103.49 70.15,103.49 84.01,117.35 85.19,117.35 89.4,121.57 90.22,121.57 95.66,127.01 96.61,127.01 98.71,129.1 101.41,129.1 103.95,131.64 111.38,131.64 114.99,128.03 119.86,128.03 120.87,129.04 120.87,129.07 121.52,129.72 126.57,129.72 127.15,129.14 136,129.14 137.44,127.7 143.39,127.7 148.19,122.9 152.49,122.9 154.86,120.53 154.86,119.77 156.38,118.26 157.51,118.26 159.34,116.43 159.69,116.43 v3(159.86,116.59)
  BOTTOM w0.102: U24.AD45 161.64,113.76 161.55,113.85 161.55,113.96 161.1,114.41 161.1,115.55 161.14,115.6 161.14,115.62
  BOTTOM w0.127: 161.14,115.62 161.14,115.83 160.55,116.43 160.02,116.43 v3(159.86,116.59)
CLK_PCIE_REQ0#: length 9
  BOTTOM w0.102: U24.AB1 163.11,94.63 163.11,93.31 162.87,93.07 162.87,91.61 163.11,91.37 163.11,90.75 163.58,90.28 163.58,87.33 163.73,87.18
  BOTTOM w0.127: 163.73,87.18 R590.2
CLK_PCIE_REQ1#: length 13.4
  BOTTOM w0.089: U24.AF1 161.07,95.05 161.07,93.85 160.82,93.6 160.82,92.23 160.54,91.94 160.54,90.5 161.13,89.91 161.13,88.23 R600.2 160.68,87.67 160.94,87.41
  BOTTOM w0.127: R632.1 159.6,83.48 160.69,84.57 160.69,85.76 161.02,86.09 161.02,87.33 160.94,87.41
CLK_PCIE_REQ2#: length 15.6
  BOTTOM w0.089: U24.AF3 160.89,95.94 160.89,95.48 160.68,95.27 160.68,95.27 160.68,95.01 160.68,95.01 160.68,94.94 160.87,94.76 160.87,93.93 160.64,93.7 160.64,92.59 160.31,92.26 160.31,90.44 160.78,89.97 160.78,88.64 160.1,87.96 160.1,87.46
  BOTTOM w0.127: R630.1 R631.2 158.58,83.79 158.59,83.79 159.1,84.3 159.31,84.3 159.55,84.54 159.55,85.29 159.84,85.59 R611.2 160.15,85.88 160.1,85.93 160.1,87.46
CLK_PCIE_REQ3#: length 16.6
  BOTTOM w0.102: U24.T3 165.05,95.57 165.35,95.27 165.35,95.27 165.35,95.26 165.35,94.79 165.66,94.48 165.66,93.2 167.32,91.55 v3(167.32,91.18) 167.42,91.08 R578.2 168.03,89.59 168.03,88.83 167.56,88.36 167.56,87.39
  BOTTOM w0.127: R638.2 167.01,82.4 167.52,82.9 167.52,83.81 168,84.29 168.38,84.29 168.58,84.5 168.58,85.83 168.09,86.32 167.81,86.32 167.56,86.57 167.56,87.39
CLK_PCIE_REQ4#: length 11.7
  BOTTOM w0.102: U24.V3 164.13,95.94 164.13,95.48 163.93,95.28 163.93,94.84 163.93,94.84 163.93,93.45 165.64,91.74 165.64,88.03 165.69,87.99 165.69,87.67
  BOTTOM w0.127: R614.2 166.12,85.53 165.58,86.08 165.58,87.56 165.69,87.67
CLK_PCIE_REQ5#: length 5.9
  BOTTOM w0.102: U24.AA2 163.04,95.09 163.32,94.81 163.32,93.06 163.3,93.04 163.3,91.97 v3(163.45,91.81) 163.32,91.68 163.32,90.88 R575.2
CLK_PCIE_REQ6#: length 6.8
  BOTTOM w0.079: 161.5,95.26 161.72,95.48 161.72,95.71 161.39,96.03 U24.AE4
  BOTTOM w0.089: 161.5,95.26 161.5,94.68 161.45,94.63 161.45,93.7 161.19,93.44 161.19,91.76 161.65,91.3 161.65,90.26 R573.2
CLK_PCIE_REQ7#: length 6.5
  BOTTOM w0.102: R576.2 164.61,90.73 v3(164.61,91.18) 164.61,92.18 163.72,93.07 163.72,94.93 163.73,94.93 163.73,95.26 163.42,95.57 U24.Y3
CLK_PCIE_VGA: length 54.7
  IN2 w0.102: v3(162.99,110.27) 162.99,110.16 163.15,110 163.32,110 164.46,111.14 164.46,111.7 164.36,111.79 164.36,112.68 164.32,112.72 164.32,112.75
  IN2 w0.133: v3(152.07,149.65) 152.07,149.85 152.22,150 152.94,150 155.21,147.73 155.21,145.98 157.75,143.44 157.75,138.96 159.41,137.31 162.32,137.31 165.19,134.43 165.19,131.1 167.78,128.51 167.78,124.88 168.19,124.47 168.19,123.6 165.63,121.04 164.75,121.04 163.74,120.03 163.74,119.01 163.43,118.7 163.38,118.65 163.38,113.98 164.32,113.04 164.32,112.75
  BOTTOM w0.102: U24.AB36 162.51,110.21 162.67,110.38 162.88,110.38 v3(162.99,110.27)
  BOTTOM w0.127: U19.AE8 151.77,149.12 151.9,149.12 152.07,149.29 v3(152.07,149.65)
CLK_PCIE_VGA#: length 54.7
  IN2 w0.102: 164.61,112.75 164.61,112.72 164.56,112.68 164.56,111.88 164.66,111.78 164.66,111.06 163.4,109.8 163.17,109.8 v3(162.99,109.62)
  IN2 w0.133: 164.61,112.75 164.61,113.16 163.67,114.1 163.67,118.52 164.03,118.89 164.03,119.91 164.87,120.74 165.75,120.74 168.48,123.48 168.48,124.59 168.07,125 168.07,128.63 165.48,131.22 165.48,134.55 162.44,137.6 159.53,137.6 158.04,139.08 158.04,143.56 155.5,146.11 155.5,147.85 153.06,150.29 152.22,150.29 v3(152.07,150.44)
  BOTTOM w0.102: v3(162.99,109.62) 162.82,109.44 U24.AB35
  BOTTOM w0.127: v3(152.07,150.44) 151.68,150.04 U19.AD8
CLK_PCIE_WLAN#_C: length 5.4
  BOTTOM w0.127: R687.2 181.66,47.82 181.66,48.05 182.45,48.84 183.49,48.84 184.02,49.37 184.02,49.68 184.3,49.95 CN10.11
CLK_PCIE_WLAN_C: length 5.5
  BOTTOM w0.127: R686.2 181.37,47.93 181.37,48.17 182.33,49.13 183.37,49.13 183.73,49.49 183.73,49.68 183.53,49.88 183.52,49.88 183.5,49.9 CN10.13
CLK_PCIE_WLANN: length 140.8
  IN2 w0.133: v3(177.4,120.47) 177.56,120.31 177.8,120.31 178.24,120.76 181.25,120.76 182.18,119.83 185.74,119.83 186.95,118.63 189.02,118.63 189.23,118.42 189.77,118.42 197.08,111.1 197.08,90.9 194.86,88.68 194.65,88.68 188.97,83 187,83 185.02,81.01 185.02,76.73 186.19,75.56 186.19,75.55 186.92,74.82 187.36,74.38 189.7,72.05 189.7,67.84 190.07,67.46 190.07,64.89 189.72,64.53 189.38,64.53 v4(189.16,64.31)
  BOTTOM w0.102: 162.94,115.33 162.96,115.31 163.02,115.31 163.22,115.12 163.22,114.61 162.7,114.09 162.47,114.09 162.31,113.92 162.31,113.63 162.61,113.32 U24.AB43
  BOTTOM w0.127: v3(177.4,120.47) 176.93,120 176.46,120 173.92,122.55 171.96,122.55 170.48,124.02 168.91,124.02 167.48,125.46 166.57,125.46 164.61,123.5 163.28,123.5 162.17,122.4 162.17,120.69 161.27,119.78 161.27,118.58 162.48,117.37 162.48,115.8 162.94,115.33 ; v4(189.16,64.31) 189.35,64.5 189.62,64.5 189.76,64.36 189.76,61.5 190.37,60.88 190.37,54.46 189.45,53.53 189.45,49.83 189.87,49.41 189.87,46.03 187.79,43.96 185.4,43.96 184.69,44.67 182.48,44.67 181.84,45.31 181.84,46.47 R687.1
CLK_PCIE_WLANP: length 140.4
  IN2 w0.133: v3(189.16,65.07) 189.4,64.83 189.6,64.83 189.78,65.01 189.78,67.34 189.41,67.71 189.41,71.92 187.16,74.18 187.16,74.17 185.98,75.35 184.72,76.61 184.72,81.14 186.88,83.29 188.85,83.29 194.53,88.97 194.74,88.97 196.79,91.02 196.79,110.98 189.64,118.12 189.11,118.12 188.9,118.33 186.83,118.33 185.62,119.54 182.06,119.54 181.13,120.47 178.36,120.47 177.92,120.02 177.49,120.02 177.4,119.93 v3(177.4,119.71)
  BOTTOM w0.102: 163.15,115.54 163.17,115.52 163.17,115.46 163.42,115.2 163.42,114.52 162.95,114.05 162.95,113.65 162.9,113.6 162.77,113.6 U24.AB45
  BOTTOM w0.127: v3(177.4,119.71) 176.34,119.71 173.8,122.26 171.84,122.26 170.36,123.73 168.79,123.73 167.36,125.16 166.69,125.16 164.73,123.21 163.4,123.21 162.46,122.27 162.46,120.57 161.56,119.66 161.56,118.7 162.77,117.49 162.77,115.92 163.15,115.54 ; v3(189.16,65.07) 189.16,65.05 189.42,64.79 189.74,64.79 190.05,64.48 190.05,61.62 190.67,61 190.67,54.34 189.74,53.41 189.74,49.95 190.16,49.54 190.16,45.91 187.91,43.66 185.28,43.66 184.57,44.38 182.36,44.38 181.54,45.19 181.54,46.53 181.41,46.67 R686.1
CLK_PCIE_XDPN: length 56.6
  BOTTOM w0.102: U24.AH43 160.17,113.33 160.5,113.66 160.5,114.78 160.28,115 159.89,115 159.68,115.21 159.68,115.27 159.67,115.29
  BOTTOM w0.127: 159.67,115.29 158.66,116.3 158.66,116.94 158.82,117.11 159.97,117.11 160.69,117.83 160.69,119.99 161.24,120.54 161.24,122.35 162.95,124.06 164.45,124.06 164.83,124.44 164.83,125.03 164.4,125.45 162.22,125.45 161.39,126.29 160.89,126.29 159.82,125.22 159.82,124.8 160.19,124.42 161.26,124.42 161.34,124.34 161.34,124.1 160.15,122.91 159.27,122.91 159.14,123.04 159.14,124.37 158.81,124.69 158.35,124.69 158.02,124.37 158.02,123.04 157.9,122.91 157.62,122.91 157.49,123.04 157.49,124.37 157.16,124.69 156.7,124.69 156.37,124.37 156.37,123.06 156.17,122.86 155.89,122.86 155.69,123.06 155.69,124.37 155.37,124.69 154.92,124.69 154.6,124.37 154.6,123.18 154.44,123.02 154.21,123.02 154.05,123.18 154.05,124.37 153.73,124.69 153.28,124.69 152.96,124.37 152.96,123.81 152.81,123.66 152.6,123.66 152.45,123.81 152.45,124.32 152.12,124.65 151.1,124.65 150.8,124.35 150.8,122.31 150.67,122.18 150.39,122.18 150.27,122.31 150.27,124.35 149.97,124.65 148.91,124.65 148.57,124.31 148.57,123.43 148.4,123.26
CLK_PCIE_XDPN_R: length 3.3
  BOTTOM w0.127: TP86.1 147.66,120.37 147.88,120.59 147.88,121.15 148.17,121.44 148.17,121.44 148.63,121.44 148.76,121.57 148.76,121.85 148.4,122.21 R745.2
CLK_PCIE_XDPP: length 56.5
  BOTTOM w0.102: 159.46,115.09 159.48,115.07 159.54,115.07 159.81,114.8 160.19,114.8 160.3,114.69 160.3,114.62 160.23,114.55 160,114.55 159.95,114.49 159.95,114.39 160.01,114.33 160.24,114.33 160.3,114.27 160.3,114.14 160.24,114.07 159.87,114.07 159.69,113.9 159.69,113.79 159.95,113.54 160.05,113.54 160.17,113.66 U24.AH45
  BOTTOM w0.127: 149.41,123.26 148.87,123.8 148.87,124.2 149.03,124.35 149.85,124.35 149.97,124.23 149.97,122.18 150.27,121.89 150.79,121.89 151.09,122.18 151.09,124.23 151.22,124.35 152,124.35 152.16,124.2 152.16,123.69 152.47,123.37 152.93,123.37 153.25,123.69 153.25,124.25 153.4,124.4 153.61,124.4 153.76,124.25 153.76,123.06 154.09,122.73 154.56,122.73 154.89,123.06 154.89,124.25 155.04,124.4 155.25,124.4 155.4,124.25 155.4,122.94 155.77,122.57 156.29,122.57 156.66,122.94 156.66,124.25 156.82,124.4 157.04,124.4 157.2,124.25 157.2,122.91 157.49,122.62 158.02,122.62 158.31,122.91 158.31,124.25 158.47,124.4 158.69,124.4 158.85,124.25 158.85,122.91 159.15,122.62 160.27,122.62 161.63,123.98 161.63,124.46 161.38,124.71 160.31,124.71 160.11,124.92 160.11,125.09 161.01,126 161.27,126 162.1,125.16 164.28,125.16 164.54,124.9 164.54,124.56 164.33,124.35 162.83,124.35 160.95,122.48 160.95,120.66 160.4,120.11 160.4,117.95 159.85,117.4 158.7,117.4 158.37,117.06 158.37,116.18 159.46,115.09
CLK_PCIE_XDPP_R: length 3.2
  BOTTOM w0.127: R744.2 149.41,122.2 149.05,121.84 149.05,121.45 148.75,121.15 148.3,121.15 148.17,121.02 148.17,120.57 148.3,120.44 TP85.1
CLK_PEGA_REQ#: length 105.4
  TOP w0.089: 159,94.98 160.16,96.14 160.16,96.68 160.43,96.95 v3(160.43,97.23)
  TOP w0.127: 159,94.98 157.51,93.49 157.51,90.96 R215.2 R215.1 158.27,88.69 157.52,87.93 R220.2 ; v3(167.36,150.36) 166.52,151.2 v2(165.11,151.2) 164.92,151.39 R39.2 163.2,153.2 Q10.3
  IN1 w0.133: v3(160.43,97.23) 159.97,97.69 159.97,100.03 160.54,100.6 160.54,101.22 160.85,101.54 166.23,101.54 166.55,101.21 169.57,101.21 170.08,101.72 171.67,101.72 171.78,101.82 177.41,101.82 177.88,102.29 177.88,103.16 177.16,103.88 176.38,103.88 175.53,104.73 175.53,105.56 177.83,107.86 181.35,107.86 182.63,109.14 182.63,109.8 182.5,109.92 182.5,110.38 181.49,111.4 181.49,112.77 180.65,113.61 180.65,116.01 179.7,116.96 178,116.96 177.63,117.34 175.54,117.34 174.6,118.28 174.6,120.68 174.18,121.11 174.18,124.74 172.14,126.77 172.14,128.05 170.33,129.85 169.09,129.85 167.8,131.14 166.36,132.58 166.36,143.38 166.36,143.39 166.36,149.26 167.29,150.19 167.29,150.29 v3(167.36,150.36)
  BOTTOM w0.102: U24.AF6 160.59,97.07 v3(160.43,97.23)
CLK_PEGB_REQ#: length 8.5
  TOP w0.089: v3(165.17,96.58) 164.98,96.39 164.98,94.92 165.54,94.37 165.54,94.2
  TOP w0.127: 165.54,94.2 165.54,93.82 165.81,93.55 165.81,90.28 R214.2
  BOTTOM w0.102: v3(165.17,96.58) 165.07,96.47 U24.U4
CLKRUN#: length 82
  TOP w0.127: R271.2 175.48,69.88 v3(175.9,70.3) 175.47,70.73 172.73,70.73 172.56,70.56 170.31,70.56 168.03,72.84 157.27,72.84 v3(157.18,72.75) ; R176.1 155.24,94.19 TP48.1 156.52,95.47 156.52,96.61 157,97.09 157,97.4 v3(157.5,97.91) ; v3(175.84,54.18) 175.85,54.17 177.53,54.17 180.11,56.75 180.11,57.64 182.4,59.93 U13.93
  IN1 w0.133: v3(175.9,70.3) 175.82,70.22 175.82,67.99 176.45,67.36 176.77,67.36 177.4,66.73 177.4,63.93 176.73,63.26 176.73,56.84 176.99,56.58 176.99,55.32 v3(175.84,54.18) ; v3(157.5,97.91) 158.02,97.39 158.02,92.84 156.93,91.75 156.93,90.36 156.53,89.95 156.53,88.27 155.42,87.17 155.42,82.43 157.38,80.48 157.38,72.94 157.18,72.75 v3(157.18,72.75)
  BOTTOM w0.102: U24.AN7 157.74,97.67 v3(157.5,97.91)
CODEC_JDREF: length 2.2
  TOP w0.127: U15.15 26.32,30.43 26.22,30.52 25.61,30.52 25.25,30.17 R353.1
CODEC_VREF: length 3.7
  TOP w0.127: C330.2 29.87,23.26 28.81,24.33 v3(28.66,24.33) 28.63,24.35 28.63,25.03 29,25.4 U15.28
CON_BAT-V:
  vias: v2(175.29,192.12)
CPU_DRAMRST#: length 21.3
  TOP w0.114: Q38.1 87.79,68.89 R266.2 R260.2 88.17,72.18 88.92,72.18 v3(89.18,72.45) 89.39,72.66 90.6,72.66 93.35,75.4 93.35,77.51 97.4,81.56 97.4,83.69 v3(96.93,84.16)
  BOTTOM w0.102: U27.AN3 97.4,84.62 v3(96.93,84.16)
CPU_HOOK0: length 1.4
  TOP w0.127: TP13.1 97.38,124.01 R51.1
CPU_HOOK1: length 1.8
  BOTTOM w0.127: TP104.1 38.87,101.57 38.76,101.67 38.07,101.67 R532.2
CPU_HOOK2: length 5.1
  TOP w0.127: R87.2 135.53,111 131.45,111 TP27.1
CPU_HOOK3: length 1.3
  TOP w0.127: R277.1 TP68.1
CPU_HOOK6: length 2.2
  BOTTOM w0.127: TP109.1 84.43,98.19 84.79,98.54 85.02,98.54 R540.1
CPU_HOOK7: length 1
  BOTTOM w0.127: TP91.1 85.31,111.84 R486.2
CPU_PLTRST#: length 286
  TOP w0.114: R123.1 87.87,104.03 86.12,104.03 85.65,103.57 85.65,101.62 85.17,101.14 84.74,101.14 83.93,100.33 v3(82.27,100.33)
  IN1 w0.127: v3(148.39,53.77) 148.78,53.77 151.21,56.2 151.21,56.2 155.89,60.88 155.89,64.3 156.54,64.95 156.54,66.32 156.07,66.79 156.07,68.85 156.44,69.22 156.44,71.38 155.69,72.13 155.69,73.54 156.07,73.93 156.07,79.77 154.35,81.5 154.35,85.11 154.64,85.4 154.64,88.63 155.45,89.45 155.45,92.89 v3(155.86,93.29)
  IN2 w0.127: v3(148.39,53.77) 147.23,52.6 147.23,48.92 142.37,44.07 142.37,41.78 139.06,38.46 139.06,37.49 137.71,36.14 134.96,36.14 134.33,36.77 122.78,36.77 118.07,32.06 113.99,32.06 113.49,31.57 83.77,31.57 80.6,34.73 77.29,34.73 74.33,37.69 74.17,37.69 65.86,46 65.86,55.91 65.43,56.34 65.43,56.52 65.85,56.94 65.85,57.16 65.7,57.31 65.47,57.31 65.1,56.94 64.88,56.94 64.72,57.09 64.72,57.32 65.59,58.19 65.59,58.41 65.44,58.56 65.22,58.56 64.34,57.69 64.12,57.69 63.97,57.85 63.97,58.07 64.76,58.86 64.76,59.09 64.61,59.24 64.39,59.24 63.58,58.43 63.36,58.43 63.2,58.59 63.2,58.81 63.87,59.48 63.87,59.7 63.71,59.86 63.49,59.86 62.79,59.16 62.61,59.16 62.42,59.35 62.42,64 63.02,64.6 63.02,64.89 62.44,65.48 62.44,65.75 62.63,65.95 62.91,65.95 64.22,64.63 64.47,64.63 64.64,64.81 64.64,65.05 62.43,67.26 62.43,67.49 62.59,67.66 62.82,67.66 65.4,65.08 65.65,65.08 65.82,65.25 65.82,65.5 62.45,68.86 62.45,69.12 62.64,69.3 62.9,69.3 66.59,65.61 66.81,65.61 66.97,65.77 66.97,65.99 63.25,69.7 63.25,69.92 63.41,70.08 63.63,70.08 66.67,67.03 66.89,67.03 67.05,67.19 67.05,67.41 64.01,70.46 64.01,70.68 64.16,70.83 64.38,70.83 66.68,68.54 66.9,68.54 67.06,68.7 67.06,68.92 64.76,71.21 64.76,71.43 64.92,71.59 65.14,71.59 66.67,70.06 66.89,70.06 67.05,70.21 67.05,70.43 65.54,71.94 65.54,72.16 65.7,72.32 65.92,72.32 66.68,71.56 66.9,71.56 67.05,71.72 67.05,71.94 66.38,72.61 66.38,73.06 68.36,75.04 68.36,84.91 82.27,98.83 v3(82.27,100.33)
  BOTTOM w0.102: U24.AU4 156.51,96 156.26,95.75 156.26,95.75 156.23,95.72 156.23,95.46 156.26,95.43 156.26,95.43 156.41,95.28 156.41,94.91 155.86,94.36 v3(155.86,93.29) 155.38,92.81 TP125.1
  BOTTOM w0.114: R540.2 84.84,100.23 84.51,100.55 82.5,100.55 v3(82.27,100.33)
CPU_PLTRST#_Q: length 4.2
  TOP w0.127: R112.1 R113.2 87.11,105.38 R124.1 85.93,104.56 85.55,104.17 U5.4
CPU_RST#_R: length 16
  TOP w0.114: v3(92.51,106.35) 92.27,106.59 91.99,106.59 91.8,106.39 91.8,106.11 92.54,105.37 92.54,105.18 92.4,105.04 92.21,105.04 90.94,106.31 90.73,106.31 90.58,106.17 90.58,105.96 91.62,104.92 91.62,104.64 91.44,104.46 90.5,104.46 90.28,104.69 90.28,105.27 90.14,105.4 89.95,105.4 89.82,105.27 89.82,104.87 89.64,104.69 R123.2 89.31,105 89.11,105.2 87.71,105.2 R124.2
  BOTTOM w0.102: v3(92.51,106.35) 92.54,106.35 93.87,107.69 U27.AT26
CPUFAN#: length 261.3
  TOP w0.127: U13.81 182.04,55.13 181.32,54.41 181.32,53.92 178.65,51.25 177.51,51.25 176.13,49.87 175.45,49.87 175.18,49.6 v3(175.18,49.46)
  IN1 w0.133: v3(38.1,86.25) 36.74,87.62 36.74,93.88 38.33,95.47 38.33,97.56 42.17,101.4 52.78,101.4 v3(54.11,100.07) ; v3(175.18,49.46) 174.2,50.44 167.29,50.44 164.96,48.11 163.92,48.11 163.33,47.52 163.33,47.39 162.87,46.93 161.26,46.93 160.89,47.3 155.42,47.3 154.04,45.91 151.31,45.91 145.59,40.2 145.59,37.27 137.23,28.91 84.01,28.91 76.15,21.05 52.18,21.05 48.85,24.37 48.85,28.91 48.16,29.6 48.16,30.07 47.55,30.68 47.55,31.65 45.57,33.63 44.61,33.63 42.04,36.2 42.04,37.05 38.71,40.38 38.71,41.01 39.18,41.49 39.18,50.59 38.71,51.06 38.71,53.23 39.32,53.84 39.32,57.18 38.36,58.14 38.36,61.77 38.87,62.27 38.87,69.16 v3(39.2,69.49)
  BOTTOM w0.127: v3(38.1,86.25) 40.47,83.89 40.47,82.66 38.94,81.14 38.94,69.74 v3(39.2,69.49) ; v3(54.11,100.07) 54.79,99.38 58.78,99.38 59.36,99.97 U26.4
CRT_11: length 1.5
  TOP w0.127: CN5.11 8.04,100.49 TP38.1
CRT_B1: length 13.2
  TOP w0.127: U6.5 U6.6 9.06,101.93 8.92,102.08 8.92,103.19 7.57,104.54 7.16,104.95 6.58,104.95 5.61,105.92 CN5.3
  BOTTOM w0.127: L25.2 C445.2 9.3,103.55 8.59,104.26 v2(8.59,104.69) 8.21,105.07 6.73,105.07 5.71,106.1 CN5.3
CRT_BLU: length 187.5
  IN2 w0.133: v3(164.95,122.42) 163.78,123.59 161.49,123.59 160.34,124.73 155.2,124.73 153.35,126.59 150.58,126.59 145.37,131.79 138.02,131.79 137.46,132.36 136.15,132.36 134.43,134.08 132.54,134.08 131.8,133.34 120.6,133.34 119.97,132.7 115.11,132.7 112.87,134.94 102.72,134.94 100.08,132.31 97.36,132.31 95.26,130.21 93.37,130.21 83.74,120.58 82.63,120.58 69.41,107.35 59.86,107.35 59.14,108.08 56.97,108.08 55.62,109.43 45.05,109.43 44.67,109.05 22.57,109.05 15.72,102.2 13.9,102.2 v4(13.49,101.79)
  BOTTOM w0.114: v3(164.95,122.42) 165.43,122.42 166.4,121.45 166.4,120.93 165.76,120.29 R466.2 166.15,119.78
  BOTTOM w0.127: 166.15,119.78 166.15,118.77 C415.2 ; L25.1 10.15,102.4 C447.2 R526.1 v4(13.49,101.79)
  BOTTOM w0.203: C415.2 165.15,117.77 165.15,116.35 165.06,116.26 165.06,115.4 165.05,115.39 U24.T45
CRT_DDCCLK_CON: length 28.5
  TOP w0.127: R730.1 21.82,110.24 v3(21.82,110.71) 21.62,110.91 21.62,113.35 21.89,113.62 Q58.3
  BOTTOM w0.127: CN5.15 9.42,108.27 10.25,108.27 C426.2 11.04,109.07 11.04,109.69 11.79,110.43 v2(12.22,110.43) 20.38,110.43 20.53,110.58 20.53,110.71 20.38,110.86 17.67,110.86 17.56,110.98 17.56,111.15 17.67,111.27 21.67,111.27 21.82,111.12 v3(21.82,110.71)
CRT_DDCDATA_CON: length 28
  TOP w0.102: U6.4 U6.7
  TOP w0.127: Q58.6 21.25,112.32 21.37,112.21 21.37,110.91 v3(21.16,110.71) 21.16,110.71 21.16,110.24 R731.1 ; CN5.12 8.45,102.37 8.45,101.73 8.75,101.43 U6.7
  IN2 w0.133: v3(8.49,107.84) 9.2,107.13 9.2,105.89 8.56,105.25 8.56,104.41 7.96,103.81 CN5.12
  BOTTOM w0.127: v3(8.49,107.84) 8.61,107.72 U23.5 U23.6 11.26,107.72 C430.1 12.93,109.17 12.93,109.72 13.39,110.18 20.63,110.18 v3(21.16,110.71)
CRT_G1: length 13.6
  TOP w0.127: CN5.2 6.79,102.63 7.24,102.63 7.98,101.9 7.98,101.32 8.86,100.43 U6.9 U6.2
  BOTTOM w0.127: CN5.2 5.66,103.81 6.81,102.66 8.39,102.66 8.59,102.46 8.59,102.2 8.41,102.02 8.23,102.02 8.11,101.9 8.11,101.47 8.29,101.29 L26.2 C462.2
CRT_GRE: length 187.5
  IN2 w0.133: v4(14.3,99.99) 14.13,100.17 14.13,100.78 14.25,100.91 15.55,100.91 23.02,108.37 44.9,108.37 45.31,108.79 55.35,108.79 56.7,107.44 58.87,107.44 59.6,106.71 69.73,106.71 82.95,119.94 84,119.94 93.64,129.57 95.54,129.57 97.64,131.67 100.35,131.67 102.96,134.28 112.62,134.28 115.48,131.42 119.59,131.42 120.85,132.68 127.26,132.68 128.22,131.72 137.19,131.72 137.76,131.15 144.04,131.15 147.71,127.47 148.78,127.47 150.33,125.93 153.1,125.93 154.94,124.09 160.08,124.09 161.24,122.93 163.48,122.93 v3(163.99,122.42)
  BOTTOM w0.114: v3(163.99,122.42) 164.32,122.42 164.95,121.79 164.95,120.62 164.62,120.29 R465.2 165.01,119.78 165.01,118.64 C414.2
  BOTTOM w0.127: L26.1 11.72,101.29 C458.2 R535.1 13.7,100.32 13.97,100.32 v4(14.3,99.99)
  BOTTOM w0.203: U24.U44 164.62,116.46 164.68,116.51 164.68,117.95 C414.2
CRT_HSYNC_R: length 7.1
  BOTTOM w0.102: U24.N42 166.27,112.89 166.57,113.2 166.57,113.43 166.37,113.63 166.37,113.64 166.37,114.37 166.92,114.93 166.92,115.98
  BOTTOM w0.114: 166.92,115.98 166.92,116.12 168.93,118.13 R473.2
CRT_R1: length 12.4
  TOP w0.127: U6.1 U6.10 7.2,99.93 CN5.1
  BOTTOM w0.127: C474.2 L27.2 9.31,99.06 8.79,99.59 8.51,99.59 7.9,98.98 6.96,98.98 6.67,99.27 6.67,100.46 CN5.1
CRT_RED: length 187.5
  IN2 w0.133: v3(163.22,122.27) 160.99,122.27 159.81,123.45 154.67,123.45 152.85,125.27 150.08,125.27 148.52,126.83 147.44,126.83 144.61,129.67 138.25,129.67 136.85,131.06 127.95,131.06 127.36,131.65 120.73,131.65 119.86,130.78 114.99,130.78 112.14,133.62 103.21,133.62 100.62,131.03 97.91,131.03 95.81,128.93 93.91,128.93 84.28,119.29 83.22,119.29 70,106.07 62.32,106.07 62,105.76 61.14,105.76 60.83,106.07 59.33,106.07 58.6,106.8 56.43,106.8 55.08,108.15 45.58,108.15 45.15,107.71 23.27,107.71 14.53,98.98 13.95,98.98 13.75,98.77 13.75,97.94 13.95,97.73 v4(14.33,97.73)
  BOTTOM w0.114: R464.2 163.65,120.29 163.86,120.5 163.86,121.63 163.26,122.23
  BOTTOM w0.127: R464.2 163.86,119.79 163.86,118.63 163.68,118.46 C413.2 ; v3(163.22,122.27) 163.26,122.23 ; v4(14.33,97.73) 13.08,98.99 C470.2 R543.2 11.85,98.98 L27.1
  BOTTOM w0.203: C413.2 163.36,116.23 164.24,115.35 U24.V45
CRT_VSYNC_R: length 7.1
  BOTTOM w0.102: 166.45,116.22 166.27,116.04 166.27,115.79 166.35,115.71 166.55,115.71 166.65,115.6 166.65,115.45 166.55,115.34 166.41,115.34 166.3,115.23 166.3,114.83 166.17,114.7 166.17,113.39 U24.N44
  BOTTOM w0.114: 166.45,116.22 166.45,116.46 167.54,117.55 167.54,117.9 167.36,118.08 167.36,118.3 167.51,118.45 167.73,118.45 R472.2
CRTHSYNC: length 9.4
  BOTTOM w0.127: U25.4 14.11,105.01 14,105.12 13.82,105.12 13.39,104.69 v2(12.3,104.69) C436.2 10.86,105.1 11.05,105.29 11.05,105.56 10.88,105.72 U23.10 U23.1 7.39,105.72 CN5.13
CRTVDD5: length 5
  IN2 w0.762: CN5.9 7.48,107.24 v3(8.38,106.34)
  BOTTOM w0.203: U23.9 U23.2 8.5,106.22 v3(8.38,106.34)
  vias: v2(11.28,105.3)
CRTVSYNC: length 9.5
  BOTTOM w0.127: U22.4 13.73,107.75 13.31,107.33 13.31,107.03 12.98,106.7 12.01,106.7 C432.2 11.58,106.74 11.09,107.22 U23.7 U23.4 8.58,107.22 v3(8.49,107.13) 8.27,107.13 CN5.14
CS_BST1: length 5.4
  TOP w0.191: PC84.1 50.75,87.02 v2(50.73,87.04)
  TOP w0.203: PC84.1 50.62,85.92 v1(49.71,85.92)
  BOTTOM w0.191: v1(49.71,85.92) 50.15,85.48 50.54,85.48 51.41,84.61 PU6.7
CS_BST2: length 4.9
  TOP w0.127: v1(52.66,94) 52.43,94.22 v2(52.43,94.76)
  TOP w0.203: v1(52.66,94) 53.39,94.73 PC141.1
  BOTTOM w0.191: PU12.7 54.55,93.45
  BOTTOM w0.203: 54.55,93.45 53.21,93.45 v1(52.66,94)
CS_BSTR1: length 4.9
  TOP w0.127: v2(49.05,85.08) 49.28,85.08 v1(49.71,84.65)
  TOP w0.203: PR105.2 50.67,84.65 v1(49.71,84.65)
  BOTTOM w0.191: v1(49.71,84.65) 50.15,84.21 PU6.6
CS_BSTR2: length 4.4
  TOP w0.127: v1(52.66,93.24) 52.1,92.68 v2(52.1,92.68)
  TOP w0.203: v1(52.66,93.24) 53.37,93.24 PR126.2
  BOTTOM w0.191: PU12.6 54.57,93.05
  BOTTOM w0.203: v1(52.66,93.24) 52.85,93.05 54.57,93.05
CS_SW1: length 1.4
  BOTTOM w0.127: v3(58.12,86.1) 58.83,85.39 58.83,84.98
  vias: v3(55.92,80.31)
CS_SW2: length 2.2
  BOTTOM w0.127: v3(60.76,95.95) 61.14,95.57 61.14,93.87
D/C#: length 122.5
  TOP w0.127: PR7.2 197.69,170.14 v3(196.87,169.33) ; U13.107 177.63,63.75 178.41,64.53 178.82,64.53 180.22,65.93 v3(180.91,65.93)
  IN1 w0.133: v3(180.91,65.93) 182.2,67.22 182.2,73.17 183.18,74.15 183.18,80.24 186.91,83.97 188.66,83.97 189.35,84.67 193.38,88.69 195.08,88.69 196,89.62 196,111.08 191.57,115.5 191.57,119.77 191.57,119.77 191.57,120.95 195.07,124.45 195.07,127.17 195.97,128.07 195.97,139.48 197.04,140.55 197.04,169.16 v3(196.87,169.33)
DAC_IREF: length 2.3
  TOP w0.254: v3(164.98,112.04) 164.96,112.06 164.96,112.84 165.44,113.31 R81.2
  BOTTOM w0.203: U24.U40 164.78,111.83 164.98,112.03 v3(164.98,112.04)
DDCCLK: length 183.9
  TOP w0.127: R729.1 19.41,113.75 19.54,113.62 Q58.4 21.83,114.98 27.21,114.98 v3(28.2,113.99)
  IN2 w0.133: v3(167.27,124.13) 167.03,124.13 164.95,126.21 162.5,126.21 161.38,127.33 160.31,127.33 158.36,129.29 151.79,129.29 146.71,134.36 139.27,134.36 136.9,136.73 131.45,136.73 130.67,135.94 115.92,135.94 114.32,137.53 101.68,137.53 99.02,134.88 96.26,134.88 94.16,132.78 92.26,132.78 82.63,123.14 81.57,123.14 68.37,109.94 60.94,109.94 60.64,110.24 60.24,110.65 58.96,110.65 58.96,110.65 58.5,110.65 55.98,113.16 41.97,113.16 41.44,113.16 39.99,111.71 31.14,111.71 28.86,113.99 v3(28.2,113.99)
  BOTTOM w0.102: 167.64,115.73 167.63,115.73 167.63,114.93 166.98,114.28 166.98,113.61 166.97,113.61 166.78,113.42 166.78,112.96 U24.M43
  BOTTOM w0.114: 167.64,115.73 169.8,117.9 169.8,120.85 168.46,122.19 168.46,122.75
  BOTTOM w0.127: 168.46,122.75 168.46,122.8 167.27,123.99 v3(167.27,124.13)
DDCDAT: length 183.1
  TOP w0.127: Q58.1 24.18,112.32 R728.1 24.57,112.51 29.54,112.51 29.7,112.66 29.7,113.25 29.51,113.45 28.31,113.45 v3(28.2,113.34)
  IN2 w0.133: v3(166.68,123.59) 166.66,123.59 164.68,125.57 162.23,125.57 161.11,126.69 160.05,126.69 158.09,128.64 151.52,128.64 146.45,133.72 139,133.72 136.63,136.08 131.72,136.08 130.93,135.3 115.65,135.3 114.06,136.89 101.94,136.89 99.29,134.24 96.53,134.24 94.43,132.14 92.53,132.14 82.89,122.5 81.83,122.5 68.64,109.3 60.67,109.3 60.14,109.84 60.14,109.84 59.97,110.01 58.23,110.01 57.86,110.38 57.86,110.38 55.72,112.52 41.7,112.52 40.79,111.61 40.25,111.07 30.81,111.07 30.17,111.71 29.8,111.71 29.17,111.07 28.88,111.07 28.53,111.42 28.53,111.71 29.17,112.34 29.17,112.71 28.53,113.35 28.21,113.35 v3(28.2,113.34)
  BOTTOM w0.102: 167.44,115.83 167.44,115 166.79,114.36 166.79,113.88 U24.M45
  BOTTOM w0.114: 167.44,115.83 169.58,117.97 169.58,120.76 168.8,121.54 168.49,121.85 167.82,122.52
  BOTTOM w0.127: v3(166.68,123.59) 166.75,123.59 167.82,122.52
DDR3_DRAMRST#: length 35.7
  TOP w0.114: v3(82.73,40.85) 82.75,40.88 v3(82.75,49.98) 79.98,52.76 79.98,58.4 78.85,59.54 78.85,65.19 79.94,66.28 83.55,66.28 R279.2
  BOTTOM w0.114: v3(82.73,40.85) 82.75,40.83 JDIM2.30 ; v3(82.75,49.98) JDIM1.30
DDR3_DRAMRST#_R: length 7.9
  TOP w0.114: R266.1 87.01,69.63 86.72,69.33 86.72,68.83 Q38.3 85.42,67.86 v3(84.28,69) 84.23,69 84.1,68.88 R279.1 R278.2
DDR_THERMDA: length 7.9
  TOP w0.127: v2(176,177.03) 175.72,177.03 Q2.2 173.64,176.98 Q2.3 172.25,177.35 C2.1 170.9,177.42 U1.2
DDR_THERMDC: length 6.9
  TOP w0.127: v2(174.88,179.19) 174.65,178.96 Q2.1 171.86,178 171.72,178.13 C2.2 170.47,178.13 170.41,178.07 U1.3
DDR_VTTREF: length 155.7
  TOP w0.508: v3(48.65,29.79) 49.33,29.1 PC59.1 49.57,28.38 49.25,28.06 49.25,25.88 50.78,24.35 54.55,24.35 56.43,26.23 62.12,26.23 63.27,25.09 74.35,25.09 77.35,28.09 77.35,31.31 v3(78.24,32.2) 78.46,32.2 80.54,30.11 81.61,30.11 83.9,32.4 86.02,32.4 90.81,37.19 R337.2 ; v3(69.19,52.34) 70.59,50.95 R313.1 68.58,50.89 67.01,49.32 67.01,46.04 73.13,39.92 v3(73.13,37.25) ; v3(71.61,68.55) v2(72.8,67.35) 73.74,66.42 R285.1 ; Q32.3 96.42,71.29 R263.1 97.11,71.06 v3(97.7,71.66)
  IN2 w0.508: v3(71.61,68.55) 70.29,67.23 70.29,59.25 69.19,58.16 v3(69.19,52.34)
  BOTTOM w0.508: 52.33,28.9 49.53,28.9 v3(48.65,29.79) ; v3(73.13,37.25) 73.16,37.25 78.21,32.2 v3(78.24,32.2) ; v3(71.61,68.55) 71.25,68.55 70.67,69.13 70.67,78.25 72.95,80.54 76.64,80.54 82.05,75.12 93.95,75.12 97.41,71.66 v3(97.7,71.66)
DEVSLP0: length 5.2
  BOTTOM w0.102: U24.B17 171.14,102.11 171.99,102.11 172.1,102 174.65,102 174.75,102.1 175.13,102.1 175.39,102.36 175.39,102.77 R523.1
DGPU_D: length 20
  TOP w0.508: v3(165.13,145.99) 165.1,145.97 159.49,145.97 v2(159.39,145.87) 159.24,145.87 158.08,144.71 158.08,143.21 156.8,141.93 PQ50.3 155.98,138.25 PC147.2 PR205.2
  BOTTOM w0.508: PQ47.2 167.13,144.11 165.25,145.99 v3(165.13,145.99)
DGPU_D1: length 19.5
  TOP w0.508: 126.13,135.84 127.66,134.31 128.1,134.31 128.47,133.94 PR199.2 ; 126.13,135.84 126.8,136.52 129.14,136.52 v2(129.52,136.9) 130.76,138.14 131.47,138.14 131.89,137.73 PC145.2 131.92,137.53 133.61,137.53 134.19,138.12 135.34,138.12 136.29,137.17 PQ43.4 ; 126.13,135.84 125.61,135.32 PQ46.3
DGPU_EDIDCLK: length 8.3
  BOTTOM w0.127: R396.1 155.93,174.39 155.33,173.78 155.33,173.78 154.72,173.17 154.13,173.17 151.73,170.77 151.73,170.41 150.81,169.48 U19.A9
DGPU_EDIDDATA: length 15.1
  BOTTOM w0.102: U19.B9 150.82,168.24 151.49,168.91 151.49,169.16
  BOTTOM w0.127: v3(156.98,178.86) 157.04,178.8 R389.1 157.51,177.41 157.51,173.22 156.95,172.66 154.41,172.66 152.24,170.49 152.24,170.17 151.49,169.42 151.49,169.16
DGPU_EVENT#: length 70.2
  IN1 w0.133: v3(168.38,147.31) 166.93,145.87 166.93,132.78 167.94,131.77 169.32,130.4 170.56,130.4 172.7,128.26 172.7,126.99 174.72,124.96 174.72,121.34 175.15,120.91 175.15,119.61 176.88,117.88 177.85,117.88 178.23,117.51 179.93,117.51 181.21,116.23 181.21,113.82 182.04,112.99 182.04,111.62 183.06,110.6 183.06,110.2 183.17,110.09 183.17,108.87 181.62,107.32 178.06,107.32 176.08,105.34 176.08,104.96 176.52,104.51 177.45,104.51 178.43,103.54 178.43,102.06 177.49,101.13 172.77,101.13 172.5,100.86 v3(172.5,100.6)
  BOTTOM w0.102: 172.44,100.66 172.31,100.79 U24.A14
  BOTTOM w0.127: v3(168.38,147.31) 169.13,147.31 R445.2 ; 172.44,100.66 v3(172.5,100.6)
DGPU_HOLD_RST#: length 87.3
  IN1 w0.133: v3(173.89,99.66) 173.51,100.04 172.34,100.04 172.04,100.35 172.04,100.96 172.63,101.55 177.52,101.55 178.15,102.18 178.15,103.4 177.4,104.16 176.49,104.16 175.8,104.84 175.8,105.45 177.94,107.59 181.46,107.59 182.9,109.02 182.9,109.96 182.78,110.08 182.78,110.49 181.76,111.51 181.76,112.88 180.93,113.71 180.93,116.12 179.81,117.23 178.12,117.23 177.74,117.61 176.75,117.61 174.88,119.48 174.88,120.8 174.45,121.23 174.45,124.85 172.42,126.88 172.42,128.15 170.45,130.13 169.2,130.13 168,131.33 166.65,132.67 166.65,146.14 167.54,147.03 167.57,147.03 167.57,149.52 v3(167.77,149.73)
  BOTTOM w0.102: U24.A12 171.8,99.98 172.01,99.78 173.78,99.78 v3(173.89,99.66) 174.02,99.54 174.54,99.54
  BOTTOM w0.127: 174.54,99.54 177.68,99.54 177.83,99.38 180.06,99.38 180.59,98.86 181.36,98.86 181.66,99.16 RP7.9 ; U20.1 169.36,151.32 v3(167.77,149.73)
DGPU_OPP#: length 174.9
  TOP w0.127: v3(169.15,53.97) 168.78,53.97 168.42,54.33 U13.18 166.72,54.33 166.67,54.27 166.67,53.52 165.89,52.74 165.02,52.74 v2(164.82,52.55) 164.46,52.18 162.43,52.18 162.17,52.44 R308.1
  IN1 w0.133: v3(187.18,122.67) 187.18,122.48 186.25,121.55 186.25,119.3 187,118.55 187,117.1 188.13,115.97 188.13,115.7 188.13,114.07 191.1,111.1 191.1,110.75 191.11,110.74 191.11,107.53 190.12,106.54 190.12,97.93 189.57,97.38 189.57,90.37 186.38,87.17 184.66,87.17 177.02,79.53 177.02,78.36 177.02,78.36 177.02,78.36 177.02,75.89 173.86,72.73 173.86,69.74 173.64,69.52 173.03,69.52 172.6,69.08 172.6,64.7 170.86,62.96 170.86,60.48 168.33,57.95 168.33,54.79 v3(169.15,53.97)
  IN2 w0.133: v3(171.53,176.8) 172.16,176.8 173.19,175.77 177.87,175.77 178.28,175.36 180.06,175.36 183.68,171.73 190.17,171.73 194.17,167.73 194.17,164.1 194.77,163.51 194.77,123.7 191.99,120.93 191.99,120.53 191.52,120.06 190.78,120.06 190.6,120.24 187.77,120.24 186.74,121.27 186.74,122.23 v3(187.18,122.67)
  BOTTOM w0.127: v3(171.53,176.8) 171.4,176.93 Q45.3
DGPU_OTP#: length 185.8
  TOP w0.127: U13.76 181.88,53.13 v3(180.26,51.51) ; R732.1 160.56,179.27 v3(160.13,178.84) 159.64,178.35 Q1.3
  IN1 w0.133: v3(180.26,51.51) 179.48,51.51 178.05,52.93 178.05,55.67 179.61,57.22 179.61,65.85 177.79,67.66 176.55,67.66 176.09,68.12 176.09,69.63 176.38,69.91 176.38,70.98 179.54,74.14 179.54,80.35 181.63,82.44 182.39,82.44 184.8,84.84 184.8,84.85 186.03,86.08 187.79,86.08 191.34,89.64 191.34,89.64 192.61,90.91 192.61,95.1 193.73,96.22 193.73,97.95 192.9,98.78 192.9,100.54 193.53,101.16 193.53,102.11 192.15,103.48 192.15,106.02 193.6,107.47 193.6,109.37 192.77,110.19 192.77,111.56 192.76,111.57 192.76,111.72 189.74,114.74 189.74,117.98 189.11,118.61 188.49,118.61 188.07,119.03 188.07,121.27 188.65,121.86 189.98,121.86 190.43,122.3 190.72,122.3 193.48,125.07 193.48,127.92 194.3,128.73 194.3,140.07 195.41,141.18 195.41,164.03 194.33,165.11 194.33,171.39 193.45,172.27 193.45,173 187.96,178.49 168.29,178.49 167.19,179.6 166.04,179.6 165.25,178.81 160.16,178.81 v3(160.13,178.84)
DGPU_PGOK-1: length 7.7
  TOP w0.127: R35.1 167.75,157.02 v2(167.67,157.09)
  TOP w0.508: Q7.3 166.32,161.41 168.03,161.41 168.56,160.89 168.56,160.32 168.86,160.02 Q6.2 168.73,159.42 C49.1 R35.1
