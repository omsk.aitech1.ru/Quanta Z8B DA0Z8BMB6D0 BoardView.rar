# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD12: length 68.8
  TOP w0.127: VRAM2.M2 123.2,151.19 122.14,151.19 121.69,151.65 121.37,151.65 121.35,151.66 120.48,151.66 120.29,151.47 v3(120.11,151.47) ; v3(120.36,165.45) 120.48,165.32 120.48,165.15 120.31,164.97 120.14,164.97 119.96,165.15 118.55,165.15 118.42,165.02 118.27,165.02 118.16,165.12 118.16,165.27 118.43,165.54 VRAM1.M2
  IN1 w0.133: v3(120.36,165.45) 117.83,162.92 117.83,157.57 v3(117.73,157.47) 117.83,157.37 117.83,154.1 118.12,153.81 118.12,153.63 117.9,153.41 117.9,153.23 118.03,153.1 118.21,153.1 118.43,153.32 118.61,153.32 118.74,153.19 118.74,153.01 118.52,152.79 118.52,152.61 118.65,152.48 118.83,152.48 119.05,152.7 119.23,152.7 119.36,152.57 119.36,152.39 119.17,152.2 119.17,152 119.3,151.86 119.71,151.86 v3(120.11,151.47)
  BOTTOM w0.127: v3(120.11,151.47) 120.3,151.28 120.3,151.07 120.15,150.93 119.95,150.93 119.69,151.19 119.31,151.19 119.12,151.01 119.12,150.62 118.9,150.39 118.49,150.39 118.35,150.53 118.35,150.72 118.49,150.85 VRAM4.M2 ; v3(120.36,165.45) 120.64,165.73 121.21,165.73 121.52,165.41 122.11,165.41 122.43,165.09 123.09,165.09 VRAM3.M2
  BOTTOM w0.152: v3(117.73,157.47) 118.26,158.01 119.13,158.01 119.18,158.06 120.61,158.06 120.94,158.39 121.95,158.39 122.07,158.26 122.69,158.26 123.07,158.64 123.62,158.64 124.06,159.07 124.06,159.61 125.27,160.83 126.72,160.83 130.28,164.39 130.28,171.9 130.54,172.16 v3(131.55,172.16) 133.53,172.16 133.76,171.93 133.76,166.35 135.17,164.94 U19.F27
FBA_CMD13: length 64.5
  TOP w0.127: VRAM1.L3 119.64,166.34 120.01,166.72 120.77,166.72 120.78,166.71 121.26,166.71 121.5,166.95 v3(121.71,166.95) ; v3(121.81,149.28) 121.66,149.42 121.66,149.58 121.84,149.76 121.94,149.76 122.13,149.56 122.25,149.56 122.39,149.71 122.39,149.92 122.52,150.05 VRAM2.L3
  IN1 w0.133: v3(121.71,166.95) 122.2,166.95 123.04,166.11 123.27,166.11 123.9,166.74 124.09,166.74 124.21,166.61 124.21,166.43 123.56,165.77 123.56,165.59 123.68,165.46 123.87,165.46 124.56,166.16 124.74,166.16 124.87,166.03 124.87,165.85 124.24,165.21 124.24,164.91 124.46,164.69 125.76,164.69 126.27,164.17 126.27,164.05 127.12,163.2 127.67,163.2 128.15,162.72 128.15,160.17 v3(128.2,160.11) 128.2,152.95 125.31,150.06 123.11,150.06 122.34,149.28 v3(121.81,149.28)
  BOTTOM w0.127: v3(121.81,149.28) 121.44,149.65 120.83,149.65 120.8,149.62 120.04,149.62 119.61,150.05 VRAM4.L3 ; v3(121.71,166.95) 121.71,167.06 121.8,167.15 121.93,167.15 122.16,166.92 122.16,166.81 122.08,166.72 122.08,166.6 122.15,166.53 122.35,166.53 122.4,166.47 122.4,166.27 122.49,166.18 122.58,166.18 VRAM3.L3
  BOTTOM w0.152: v3(128.2,160.11) 128.53,160.11 128.68,159.96 128.68,158.99 128.85,158.82 129.1,158.82 129.27,158.99 129.27,160.79 129.59,161.11 133.14,161.11 133.3,161.27 133.3,161.5 133.14,161.66 130.74,161.66 130.57,161.84 130.57,162.09 130.74,162.26 135.22,162.26 135.38,162.43 135.38,162.66 135.22,162.83 133.06,162.83 132.87,163.02 132.87,163.28 133.06,163.47 135.44,163.47 135.79,163.11 136.01,163.11 136.64,163.74 137.45,163.74 137.59,163.89 U19.G25
FBA_CMD14: length 60.8
  TOP w0.127: VRAM1.M7 121.26,165.54 121.05,165.34 v3(121.05,165.29) ; VRAM2.M7 119.7,150.7 120.88,150.7 121.12,150.94 121.25,150.94 121.53,151.22 v3(121.53,151.22)
  IN1 w0.133: v3(121.05,165.29) 120.88,165.29 120.78,165.39 120.78,165.67 120.89,165.79 121.24,165.79 121.57,165.47 122.36,165.47 123.25,164.58 123.25,164.4 123.12,164.26 123.12,164.08 123.24,163.95 123.43,163.95 123.56,164.09 123.74,164.09 123.87,163.96 123.87,163.78 123.74,163.64 123.74,163.46 124.11,163.09 125.11,163.09 125.13,163.11 125.81,163.11 126.09,162.83 126.09,162.58 126.67,162 126.67,159.53 v3(126.78,159.42) 126.95,159.25 126.95,154.28 125.86,153.19 124.13,153.19 122.16,151.22 v3(121.53,151.22)
  BOTTOM w0.127: VRAM4.M7 122.14,150.85 121.87,150.58 121.71,150.58 121.59,150.7 121.32,150.7 121.23,150.79 121.23,150.91 v3(121.53,151.22) ; VRAM3.M7 119.62,165.54 120.14,165.03 120.55,165.03 120.82,165.29 v3(121.05,165.29)
  BOTTOM w0.152: U19.G27 134.67,164.14 132.85,165.97 132.85,171.08 132.68,171.24 132.45,171.24 132.29,171.08 132.29,168.98 132.13,168.83 131.91,168.83 131.75,168.98 131.75,171.08 131.59,171.24 131.36,171.24 131.2,171.08 131.2,164.01 126.78,159.59 v3(126.78,159.42)
FBA_CMD15: length 65.5
  TOP w0.127: VRAM2.K3 122.75,149.06 122.28,148.6 121.47,148.6 121.21,148.34 v3(121.02,148.34) ; VRAM1.K3 119.75,167.14 119.97,167.36 119.97,167.48 119.89,167.56 119.89,167.7 120.45,168.27 120.71,168.27 v3(120.92,168.07)
  IN1 w0.133: v3(121.02,148.34) 121.36,148.68 122.16,148.68 123.14,149.66 125.61,149.66 128.68,152.73 v3(128.68,160.57) 128.5,160.75 128.5,160.95 128.62,161.07 129.32,161.07 129.45,161.2 129.45,161.38 129.32,161.51 128.55,161.51 128.43,161.63 128.43,161.82 128.55,161.94 129.26,161.94 129.39,162.07 129.39,162.25 129.26,162.38 128.57,162.38 128.43,162.53 128.43,162.8 127.79,163.44 127.22,163.44 126.51,164.15 126.51,164.27 125.98,164.79 125.98,165.32 125.21,166.09 125.21,166.27 125.39,166.45 125.39,166.63 125.26,166.76 125.08,166.76 124.9,166.58 124.72,166.58 124.18,167.12 123.49,167.12 123.36,166.99 123.36,166.68 123.23,166.55 123.04,166.55 122.91,166.68 122.91,167.18 122.62,167.47 121.51,167.47 v3(120.92,168.07)
  BOTTOM w0.127: v3(120.92,168.07) 121.35,167.63 122.26,167.63 VRAM3.K3 ; v3(121.02,148.34) 120.8,148.13 120.32,148.13 120.04,148.41 120.04,148.61 119.62,149.02 119.62,149.17 VRAM4.K3
  BOTTOM w0.152: v3(128.68,160.57) 128.68,160.84 130.85,163.01 131.22,163.01 131.5,162.73 132.24,162.73 132.41,162.91 132.41,163.16 132.24,163.34 131.91,163.34 131.65,163.59 v3(131.65,164.64) 131.65,168.18 131.84,168.37 132.1,168.37 132.29,168.18 132.29,164.03 132.47,163.84 132.74,163.84 132.92,164.03 132.92,164.61 133.11,164.8 133.37,164.8 133.56,164.61 133.56,164.1 133.89,163.77 136.18,163.77 136.55,164.14 U19.G26
FBA_CMD16: length 51.9
  TOP w0.127: VRAM2.L2 123.38,149.88 123.21,149.88 123.11,149.98 123.11,150.12 123.3,150.3 123.3,150.42 123.21,150.51 122.59,150.51 122.39,150.71 121.98,150.71 121.54,150.27 v3(121.43,150.27)
  IN2 w0.165: v3(138.79,160.4) 139.01,160.4 139.39,160.02 139.8,160.02 140.09,160.31 140.69,160.31 140.86,160.48 140.86,160.73 140.69,160.9 140.38,160.9 140.21,161.07 140.21,161.31 140.38,161.49 140.64,161.49 140.88,161.72 140.88,162.36 139.5,163.75 139.5,163.97 138.98,164.48 138.61,164.48 138.2,164.89 136.99,164.89 136.57,165.32 135.38,165.32 134.65,166.05 130.01,166.05 129.26,165.29 129.26,159.43 126.29,156.47 126.29,154.83 125.14,153.68 122.84,153.68 122.13,152.97 121.98,152.97 121.64,152.63 120.63,152.63 120.43,152.83 118.2,152.83 118.01,152.64 118.01,152.38 118.2,152.19 119.46,152.19 119.67,151.99 119.67,151.12 120.04,150.74 120.95,150.74 v3(121.43,150.27)
  BOTTOM w0.127: VRAM4.L2 119.06,150.05 119.42,150.41 119.67,150.41 120.23,149.85 120.71,149.85 120.85,149.99 121.15,149.99 v3(121.43,150.27)
  BOTTOM w0.152: v3(138.79,160.4) 138.39,160 U19.M24
FBA_CMD17: length 1.4
  TOP w0.152: v3(139.61,159.56) 139.65,159.52 TP10.1
  BOTTOM w0.152: v3(139.61,159.56) 139.61,159.56 U19.M23
FBA_CMD18: length 62.7
  TOP w0.127: VRAM2.K1 123.94,149.66 122.67,149.66 122.35,149.34 122.35,149.21 121.98,148.84 121.37,148.84 121.33,148.8 120.75,148.8 v3(120.51,149.03)
  IN2 w0.165: v3(115.72,150.06) 115.8,149.98 117.31,149.98 117.79,150.46 119,150.46 120.43,149.03 v3(120.51,149.03) 120.75,148.79 121.33,148.79 121.52,148.61 122.1,148.61 122.38,148.89 122.38,149.22 123.32,150.16 123.32,151.35 122.96,151.71 122.96,152.72 123.16,152.92 123.45,152.92 123.65,152.72 123.65,152.12 123.85,151.92 124.14,151.92 124.34,152.12 124.34,152.77 124.52,152.94 125.56,152.94 127.02,154.4 127.02,156.16 130.6,159.74 130.6,163.17 131.4,163.97 134.58,163.97 134.75,163.8 134.75,162.15 134.91,161.99 135.15,161.99 135.31,162.15 135.31,163.8 135.49,163.97 137.37,163.97 137.55,163.79 137.55,163.54 137.37,163.36 136.12,163.36 135.91,163.16 135.91,162.61 136.12,162.41 136.6,162.41 136.76,162.25 136.76,162.03 136.6,161.87 135.82,161.87 135.66,161.71 135.66,161.49 135.82,161.33 136.44,161.33 136.89,160.88 137.4,160.88 137.57,161.05 137.57,161.61 137.75,161.8 137.75,162.27 137.93,162.44 138.59,162.44 138.79,162.25 v3(138.79,161.24)
  BOTTOM w0.127: v3(120.51,149.03) 120.39,148.91 120.09,148.91 119.94,149.06 119.94,149.37 119.65,149.66 117.48,149.66 117.36,149.54 117.36,149.37 117.48,149.25 VRAM4.K1
  BOTTOM w0.152: R438.1 114.32,150.06 114.78,149.6 115.27,149.6 v3(115.72,150.06) ; v3(138.79,161.24) 138.39,161.64 U19.K24
FBA_CMD19: length 63.6
  TOP w0.127: v3(121.14,149.23) 121.14,149.25 120.92,149.48 120,149.48 119.83,149.66 119.38,149.66 119.38,149.66 118.91,149.66 118.91,149.66 117.95,149.66 117.82,149.53 117.82,149.38 VRAM2.K9
  TOP w0.152: R42.1 v3(115.04,150.06)
  IN2 w0.165: v3(139.61,161.24) 139.61,161.28 139.17,161.71 139.17,162.43 139.23,162.48 139.23,163.86 138.95,164.14 138.29,164.14 138.08,164.34 136.31,164.34 136.15,164.51 136.15,164.75 135.95,164.95 135.68,164.95 135.49,164.75 135.49,164.51 135.32,164.34 135.03,164.34 134.86,164.51 134.86,165.31 134.67,165.5 134.39,165.5 134.2,165.31 134.2,164.53 134.01,164.34 133.73,164.34 133.54,164.53 133.54,165.48 133.35,165.68 133.07,165.68 132.88,165.48 132.88,164.53 132.69,164.34 132.41,164.34 132.22,164.53 132.22,165.48 132.03,165.68 131.75,165.68 131.56,165.48 131.56,164.52 131.38,164.34 131.12,164.34 130.94,164.52 130.94,165.47 130.74,165.68 130.43,165.68 130.23,165.47 130.23,164.64 130.07,164.47 129.82,164.47 129.62,164.28 129.62,164 129.82,163.81 130.06,163.81 130.27,163.61 130.27,163.33 130.06,163.12 129.82,163.12 129.62,162.93 129.62,162.66 129.82,162.46 130.07,162.46 130.23,162.3 130.23,161.97 130.07,161.8 129.82,161.8 129.62,161.61 129.62,161.34 129.82,161.14 130.07,161.14 130.23,160.98 130.23,159.89 126.66,156.31 126.66,154.68 125.29,153.31 122.99,153.31 122.33,152.65 122.19,152.65 121.99,152.45 121.99,152.16 122.19,151.96 122.45,151.96 122.62,151.79 122.62,151.55 122.45,151.38 122.17,151.38 122,151.22 122,150.89 122.17,150.72 122.68,150.72 122.84,150.56 122.84,150.31 122.25,149.72 121.41,149.72 121.14,149.45 v3(121.14,149.23) 121.02,149.23 120.63,149.62 120.4,149.62 118.85,151.17 116.97,151.17 116.42,150.63 115.61,150.63 v3(115.04,150.06)
  BOTTOM w0.127: v3(121.14,149.23) 121.53,148.84 121.97,148.84 121.98,148.86 122.23,149.1 122.23,149.22 122.62,149.61 123.75,149.61 124.1,149.25 VRAM4.K9
  BOTTOM w0.152: U19.K23 v3(139.61,161.24)
FBA_CMD20: length 60.1
  TOP w0.127: v3(119.89,161.08) 119.99,160.98 120.17,160.98 120.3,161.1 120.3,161.27 119.94,161.62 119.78,161.62 119.45,161.29 119.31,161.29 119.13,161.47 119.13,161.8 119.24,161.91 119.58,161.91 119.67,162 119.67,162.22 VRAM1.T3 ; v3(120.52,155.15) 120.8,154.86 121.93,154.86 VRAM2.T3
  IN1 w0.133: v3(120.52,155.15) 120.25,155.42 120.25,155.64 120.35,155.75 120.55,155.75 121.09,155.21 121.29,155.21 121.44,155.36 121.44,155.91 121.53,156 v3(121.53,157.63) 121.14,158.02 121.14,160.34 120.83,160.65 120.6,160.65 120.17,161.08 v3(119.89,161.08)
  BOTTOM w0.127: v3(120.52,155.15) 120.11,154.74 119.53,154.74 119.44,154.65 119.44,154.52 119.53,154.42 119.91,154.42 119.99,154.35 119.99,154.23 119.8,154.05 VRAM4.T3 ; VRAM3.T3 122.75,162.12 121.86,161.23 121.54,161.23 121.07,160.76 120.2,160.76 v3(119.89,161.08)
  BOTTOM w0.152: U19.M27 135.8,159.98 135.54,160.24 135.13,160.24 133.99,159.1 133.99,158.41 133.18,157.6 133.18,156.77 132.85,156.44 132.85,155.11 131.71,153.98 131.71,153.74 131.86,153.59 131.86,153.33 131.69,153.15 131.43,153.15 131.28,153.31 131.07,153.31 130.85,153.09 130.85,152.88 131.02,152.71 131.02,152.49 130.8,152.28 130.55,152.28 130.26,152.57 129.97,152.57 129.77,152.37 129.77,152.09 130.1,151.76 130.1,151.57 129.77,151.24 129.77,150.72 129.58,150.52 129.31,150.52 129.11,150.72 129.11,152.42 128.96,152.57 128.73,152.57 128.58,152.42 128.58,150.01 128.4,149.83 128.15,149.83 127.97,150.01 v3(127.97,151.35) 127.97,152.42 127.82,152.57 127.51,152.57 127.36,152.42 127.36,150.01 127.18,149.83 126.93,149.83 126.75,150.01 126.75,152.85 125.79,153.81 125.79,154.29 125.07,155 125.07,156.48 124.74,156.81 124.31,156.81 123.88,157.24 123.2,157.24 122.79,157.65 121.56,157.65 v3(121.53,157.63)
FBA_CMD21: length 66.3
  TOP w0.127: VRAM1.T8 123.55,160.79 v3(122.54,159.78) 122.15,159.39 120.22,159.39 v3(119.83,159.78) ; VRAM2.T8 118.75,155.35 119.62,156.22 120.06,156.22 120.48,155.8 121.01,155.8 121.1,155.88 v3(121.1,156.21)
  IN1 w0.133: v3(121.1,156.21) 121.09,156.21 120.92,156.04 120.64,156.04 119.79,156.89 v3(119.79,157.5) 119.79,158.06 119.76,158.08 119.76,159.72 v3(119.83,159.78)
  BOTTOM w0.127: VRAM4.T8 123.55,154.58 122.91,155.21 122.91,156.31 122.74,156.49 121.38,156.49 v3(121.1,156.21) ; v3(119.83,159.78) 118.75,160.86 117.95,160.86 117.81,161 117.81,161.2 117.95,161.33 118.96,161.33 119.1,161.47 119.1,161.68 118.96,161.82 118.45,161.82 118.29,161.97 118.29,162.19 118.45,162.34 VRAM3.T8
  BOTTOM w0.152: U19.M26 136.4,160.37 135.91,160.37 135.79,160.49 134.85,160.49 133.66,159.3 133.66,158.62 132.77,157.73 132.77,157.01 132.39,156.63 132.39,155.3 130.11,153.03 127.22,153.03 126.04,154.21 126.04,156.02 124.79,157.27 124.4,157.27 123.56,158.11 123.18,158.11 123.03,157.96 121.87,157.96 121.77,158.06 121.11,158.06 118.9,155.85 117.92,155.85 116.31,157.46 116.31,159.98 116.47,160.14 116.7,160.14 116.86,159.98 116.86,157.63 118.06,156.43 118.72,156.43 118.93,156.64 118.93,156.85 118.71,157.07 118.71,157.32 118.89,157.5 119.14,157.5 119.36,157.28 119.57,157.28 v3(119.79,157.5)
FBA_CMD22: length 67.7
  TOP w0.127: v3(121.73,159.96) 121.59,159.96 121.46,160.09 121.46,160.27 121.59,160.39 122.07,160.39 122.3,160.62 122.3,161.32 123.14,162.15 123.14,162.59 123.26,162.71 123.9,162.71 124.03,162.84 124.03,163.02 123.9,163.14 VRAM1.R8 ; v3(119.79,155.8) 119.79,155.8 ; 119.79,155.8 118.98,154.98 118.98,154.31 119.09,154.19 119.09,153.91 118.75,153.56 VRAM2.R8 ; 119.79,155.8 119.99,155.8 120.22,155.57 121.92,155.57 v3(121.93,155.55)
  IN1 w0.133: v3(121.73,159.96) 121.73,158.19 122.12,157.79 v3(122.12,157.22) 121.9,157.22 121.77,157.09 121.77,156.9 121.9,156.76 122.23,156.76 122.35,156.64 122.35,156.47 122.23,156.36 121.9,156.36 121.77,156.22 121.77,155.72 v3(121.93,155.55)
  BOTTOM w0.127: v3(121.93,155.55) 121.93,155.54 123.13,154.35 123.13,153.92 123.25,153.8 123.25,153.49 123.13,153.37 123.13,152.99 123.27,152.86 123.65,152.86 123.87,152.63 124.04,152.63 124.16,152.75 124.16,152.95 123.86,153.25 VRAM4.R8 ; v3(121.73,159.96) 121.24,159.96 121.02,159.75 120.5,159.75 119.95,160.29 119.88,160.29 119.47,160.7 119.47,161.71 119.13,162.04 119.13,162.45 118.75,162.83 VRAM3.R8
  BOTTOM w0.152: v3(122.12,157.22) 122.1,157.19 121.35,157.19 121.06,157.49 120.9,157.49 120.79,157.38 120.79,157.22 121.28,156.73 122.5,156.73 122.72,156.95 123.41,156.95 123.54,156.82 123.54,156.6 123.35,156.41 123.35,155.41 123.52,155.24 123.76,155.24 123.93,155.41 123.93,156.23 124.16,156.46 124.62,156.46 124.82,156.26 124.82,154.89 125.43,154.28 125.43,154.03 125.13,153.74 125.13,153.52 125.28,153.37 125.58,153.37 126.17,152.79 126.17,152.2 125.99,152.03 125.73,152.03 125.61,151.9 125.61,151.66 125.73,151.53 125.99,151.53 126.17,151.35 126.17,150.64 125.86,150.34 124.8,150.34 124.7,150.23 124.7,149.98 124.88,149.8 126.17,149.8 126.6,149.37 128.59,149.37 129.28,150.07 129.77,150.07 130.25,150.55 130.25,151.08 132.32,153.14 132.32,153.94 133.23,154.85 133.23,156.18 133.63,156.59 133.63,157.6 133.96,157.93 134.17,157.93 134.36,157.73 134.58,157.73 134.73,157.89 134.73,158.1 134.38,158.46 134.38,159.01 135.2,159.84 135.49,159.84 135.75,159.58 137.89,159.58 138.01,159.7 138.01,159.86 137.89,159.98 U19.M25
FBA_CMD23: length 62.7
  TOP w0.127: v3(120.36,162.12) 120.8,162.57 121.49,162.57 121.6,162.45 122,162.45 122.69,163.14 VRAM1.R7 ; v3(120.47,154.46) 120.47,154.26 120.83,153.91 120.83,153.74 120.71,153.63 120.54,153.63 120.38,153.79 120.21,153.79 120.04,153.63 119.18,153.63 119.07,153.52 119.07,153.36 119.18,153.25 VRAM2.R7
  TOP w0.152: v3(123.38,157.68) 122.96,157.68 122.58,158.05 122.58,158.18 122.96,158.56 123.15,158.56 124.03,157.68 125.79,157.68 125.98,157.87 126.21,157.87 126.38,157.71 126.38,157.49 126.22,157.33 126.22,157.18 127.21,156.18 127.46,156.18 127.63,156.35 127.63,156.59 126.98,157.24 126.98,157.5 127.16,157.68 127.41,157.68 128.17,156.92 128.41,156.92 128.58,157.09 128.58,157.33 128.3,157.61 128.3,157.86 128.48,158.04 128.73,158.04 129,157.77 129.25,157.77 129.43,157.95 129.43,158.2 129.16,158.47 129.16,158.72 129.34,158.9 129.59,158.9 129.88,158.61 130.1,158.61 130.36,158.87 130.36,159.25 130.15,159.45 129.8,159.45 129.62,159.64 129.62,159.9 129.8,160.08 130.52,160.08 131.75,161.31 132.34,161.31 132.52,161.48 132.52,161.77 131.08,163.2 131.08,163.44 131.25,163.61 131.49,163.61 133.18,161.92 133.43,161.92 133.6,162.09 133.6,162.34 132.06,163.89 132.06,164.12 132.22,164.28 132.45,164.28 134.53,162.2 135.59,162.2 135.74,162.04 v3(137.2,162.04)
  IN1 w0.133: v3(120.36,162.12) 120.79,161.69 120.89,161.69 121.34,161.25 122.05,161.25 122.84,160.45 122.84,159.12 122.98,158.98 122.98,158.38 123.38,157.98 v3(123.38,157.68) 123.32,157.61 122.98,157.61 122.85,157.48 122.85,157.32 122.97,157.2 123.18,157.2 123.29,157.09 123.29,156.86 122.91,156.48 122.91,155.76 122.71,155.55 122.52,155.55 122.34,155.38 122.34,155.12 122.02,154.8 121.49,154.8 121.32,154.97 120.94,154.97 120.69,154.73 120.53,154.73 120.47,154.67 v3(120.47,154.46)
  BOTTOM w0.127: VRAM4.R7 122.75,153.54 122.24,154.05 122.24,154.54 121.98,154.8 121.57,154.8 121.43,154.66 120.67,154.66 v3(120.47,154.46) ; v3(120.36,162.12) 120.23,161.99 120.08,161.99 119.92,162.15 119.92,162.61 119.8,162.73 119.17,162.73 119.09,162.81 119.09,163.21 119.19,163.31 119.38,163.31 VRAM3.R7
  BOTTOM w0.152: U19.K26 136.44,161.66 136.35,161.75 136.35,161.91 136.48,162.04 v3(137.2,162.04)
FBA_CMD24: length 67.9
  TOP w0.127: VRAM2.P2 123.2,152.79 122.7,152.79 122.35,153.14 122.35,153.58 122.1,153.83 121.47,153.83 121.11,154.19 v3(121.11,154.22) ; v3(120.39,163.06) 120.69,163.06 120.82,163.19 120.82,163.36 120.69,163.49 119.36,163.49 119.29,163.56 119.29,163.7 119.2,163.79 119.08,163.79 119,163.7 119,163.56 118.93,163.49 118.44,163.49 118.33,163.59 118.33,163.75 118.44,163.85 118.66,163.85 VRAM1.P2
  TOP w0.152: v3(139.61,162.06) 139.22,161.67 137.69,161.67 137.61,161.59 136.71,161.59 136.71,161.59 136.38,161.59 135.63,160.85 131.94,160.85 130.83,159.74 130.83,158.7 127.85,155.72 127.03,155.72 125.53,157.22 122.77,157.22 121.58,158.41 120.91,158.41 120.76,158.26 120.76,157.87 120.56,157.68 120.29,157.68 120.1,157.87 120.1,158.26 119.89,158.46 119.51,158.46 119.31,158.26 119.31,157.56 119.12,157.37 118.86,157.37 118.67,157.56 118.67,157.73 118.47,157.93 116.62,157.93 116.41,158.13 116.41,159.87 116.6,160.06 116.87,160.06 117.06,159.87 117.06,158.62 117.21,158.46 117.52,158.46 117.67,158.62 117.67,160.59 117.86,160.77 118.13,160.77 118.32,160.59 118.32,158.82 v3(118.68,158.46)
  IN1 w0.133: v3(120.39,163.06) 120.04,162.71 119.86,162.71 119.63,162.94 119.45,162.94 119.32,162.81 119.32,162.63 119.55,162.4 119.55,162.22 118.68,161.35 v3(118.68,158.46) 118.68,155.56 120.37,153.87 120.76,153.87 v3(121.11,154.22)
  BOTTOM w0.127: VRAM3.P2 123.11,163.5 122.6,163.5 122.23,163.13 122.23,162.69 121.97,162.44 121.61,162.44 121.45,162.6 120.95,162.6 120.49,163.06 v3(120.39,163.06) ; VRAM4.P2 119.15,152.85 119.15,153.44 119.35,153.65 119.72,153.65 120.02,153.95 120.69,153.95 120.96,154.22 v3(121.11,154.22)
  BOTTOM w0.152: U19.K22 140.01,161.66 v3(139.61,162.06)
FBA_CMD25: length 66.3
  TOP w0.127: VRAM1.N2 118.54,164.74 118.16,164.36 118.16,164.22 118.26,164.12 118.4,164.12 118.68,164.4 118.85,164.4 119.09,164.15 119.24,164.15 119.44,164.35 119.74,164.35 119.86,164.47 120.23,164.47 v3(120.4,164.3) ; v3(120.18,152.35) 120.42,152.35 120.65,152.58 121.34,152.58 121.39,152.63 121.91,152.63 122.49,152.04 123.15,152.04 VRAM2.N2
  TOP w0.152: v3(118.25,157.07) 117.98,156.79 117.71,156.79 117.07,157.42 116.47,157.42 116.31,157.26 116.31,157.03 116.47,156.86 116.92,156.86 117.49,156.29 117.49,154.6 117.64,154.45 117.86,154.45 118.01,154.6 118.01,156.05 118.85,156.89 120.12,156.89 120.45,157.22 121.19,157.22 121.64,156.76 125.34,156.76 126.94,155.16 127.94,155.16 131.29,158.51 131.29,159.55 132.13,160.39 136.44,160.39 137.29,161.24 v3(138.04,161.24)
  IN1 w0.133: v3(120.4,164.3) 119.84,164.3 118.25,162.71 v3(118.25,157.07) 118.25,155.25 118.52,154.99 118.52,154.73 118.29,154.51 118.29,154.3 118.44,154.15 118.64,154.15 119.04,154.55 119.21,154.55 119.34,154.42 119.34,154.23 118.91,153.8 118.91,153.62 119.04,153.49 119.22,153.49 119.64,153.91 119.82,153.91 119.95,153.79 119.95,153.6 119.55,153.21 119.55,152.98 v3(120.18,152.35)
  BOTTOM w0.127: v3(120.4,164.3) 120.7,164.3 121.02,163.97 121.4,163.97 121.74,164.31 122.47,164.31 122.49,164.33 123.13,164.33 VRAM3.N2 ; VRAM4.N2 118.47,151.65 118.12,151.3 118.12,151.16 118.22,151.06 118.36,151.06 118.49,151.19 118.98,151.19 119.19,151.4 119.19,151.84 119.34,151.99 119.68,151.99 119.8,152.12 120.09,152.12 120.18,152.2 v3(120.18,152.35)
  BOTTOM w0.152: U19.J23 138.77,162.04 138.24,162.04 137.98,161.79 137.98,161.3 v3(138.04,161.24)
FBA_CMD26: length 66.1
  TOP w0.127: VRAM1.M3 119.86,165.54 120.18,165.86 120.63,165.86 120.7,165.79 121.14,165.79 121.31,165.97 v3(121.79,165.97) ; VRAM2.M3 122.59,150.85 122.49,150.95 121.88,150.95 121.63,150.7 121.22,150.7 120.79,150.27 v3(120.49,150.27)
  TOP w0.152: v3(137.99,162.88) 137.85,162.88 137.28,163.45 v3(136.71,163.45) 136.31,163.45 136,163.14 134.89,163.14 134.39,163.63 134.39,163.85 134.54,163.99 134.54,164.24 134.36,164.42 134.11,164.42 133.96,164.28 133.75,164.28 133.53,164.49 133.53,164.71 133.72,164.9 133.72,165.15 133.54,165.33 133.02,165.33 132.9,165.45 132.9,166.1 132.74,166.25 132.52,166.25 132.36,166.1 132.36,165.35 132.2,165.19 131.98,165.19 131.82,165.35 131.82,170.22 131.66,170.38 131.43,170.38 131.27,170.22 131.27,164.91 128.21,161.85 128.21,161 127.43,160.23 v3(127.43,159.54)
  IN1 w0.133: v3(121.79,165.97) 121.79,165.97 122.19,165.97 124.24,163.92 124.24,163.75 124.11,163.61 124.11,163.45 124.22,163.33 124.39,163.33 124.57,163.51 124.72,163.51 124.89,163.35 126.24,163.35 126.45,163.14 126.45,162.73 126.65,162.52 127.41,162.52 127.55,162.38 127.55,162.19 127.41,162.05 127.03,162.05 126.91,161.93 126.91,161.76 127.03,161.63 127.48,161.63 127.61,161.5 127.61,161.31 127.48,161.18 127.03,161.18 126.91,161.05 126.91,160.87 127.03,160.74 127.41,160.74 127.54,160.61 127.54,160.43 127.41,160.3 127.02,160.3 126.91,160.19 126.91,160.03 127.02,159.91 127.23,159.91 127.43,159.71 v3(127.43,159.54) 127.43,159.14 127.26,158.97 127.26,154.09 126.09,152.93 124.39,152.93 122.21,150.75 121.76,150.75 121.75,150.74 120.96,150.74 v3(120.49,150.27)
  BOTTOM w0.127: v3(121.79,165.97) 121.68,165.86 121.68,165.75 121.79,165.64 122.06,165.64 122.18,165.77 122.26,165.77 122.37,165.65 122.37,165.47 122.48,165.36 122.56,165.36 VRAM3.M3 ; VRAM4.M3 119.56,150.85 119.92,150.49 120.09,150.49 120.35,150.75 120.85,150.75 121.03,150.56 121.03,150.39 120.91,150.27 v3(120.49,150.27)
  BOTTOM w0.152: v3(137.99,162.88) 137.59,162.48 U19.J25
FBA_CMD27: length 66.2
  TOP w0.127: VRAM2.N8 118.51,151.65 118.39,151.53 118.39,151.37 118.51,151.26 119.7,151.26 120.01,150.94 120.67,150.94 120.74,151.01 v3(120.74,151.23) ; VRAM1.N8 123.55,164.44 123.68,164.32 123.86,164.32 123.99,164.44 123.99,165.04 123.87,165.17 122.11,165.17 v3(121.93,164.99)
  TOP w0.152: v3(126.49,158.23) 126.49,158.81 126.65,158.96 126.91,158.96 127.04,158.84 127.04,158.28 127.18,158.13 127.93,158.13 128.33,158.53 128.33,158.77 127.88,159.21 127.88,159.45 128.05,159.63 128.29,159.63 128.73,159.19 128.98,159.19 129.16,159.37 129.16,159.62 128.88,159.91 128.88,160.12 129.14,160.38 129.14,160.88 128.66,161.35 128.66,161.63 128.87,161.83 129.15,161.83 130.26,160.72 130.52,160.72 130.7,160.91 130.7,161.17 129.56,162.3 129.56,162.56 129.75,162.75 130.01,162.75 131.15,161.61 131.41,161.61 131.59,161.79 131.59,162.05 130.56,163.08 130.56,163.56 131.74,164.74 132.64,164.74 134.72,162.65 v3(135.36,162.65) 135.84,162.65 136.05,162.45 136.57,162.45 136.59,162.47 137.42,162.47 137.82,162.07 138,162.07 138.33,162.4 138.59,162.4 138.92,162.07 139.06,162.07 139.21,162.22 139.21,162.73 139.05,162.88 v3(138.79,162.88)
  IN1 w0.133: v3(120.74,151.23) 121.2,151.69 122.22,151.69 123.99,153.46 125.56,153.46 126.35,154.26 126.35,157.49 126.49,157.63 v3(126.49,158.23) 126.25,158.47 126.25,158.63 126.33,158.7 126.62,158.7 126.72,158.8 126.72,158.93 126.62,159.03 126.36,159.03 126.24,159.15 126.24,159.55 126.42,159.74 126.42,161.91 126.18,162.16 124.7,162.16 122.68,164.18 122.68,164.36 122.81,164.49 122.81,164.67 122.68,164.8 122.5,164.8 122.37,164.67 122.26,164.67 v3(121.93,164.99)
  BOTTOM w0.127: v3(121.93,164.99) 121.37,164.99 121.22,164.84 120.72,164.84 120.61,164.73 120.09,164.73 119.7,165.12 119.12,165.12 VRAM3.N8 ; VRAM4.N8 123.55,151.6 123.2,151.26 122.29,151.26 121.9,151.65 121.31,151.65 120.89,151.23 v3(120.74,151.23)
  BOTTOM w0.152: v3(138.79,162.88) 138.39,162.48 U19.J24
FBA_CMD28: length 62.6
  TOP w0.127: v3(120.82,152.15) 120.69,152.02 120.46,152.02 120.34,151.9 120.02,151.9 119.88,152.04 119.24,152.04 119.14,151.94 119.14,151.74 119.23,151.65 VRAM2.N7 ; v3(121.99,163.87) 121.73,163.62 121.53,163.62 121.38,163.77 121.38,163.97 121.98,164.57 122.23,164.57 122.45,164.35 122.63,164.35 122.75,164.47 VRAM1.N7
  IN1 w0.133: v3(120.82,152.15) 121.27,152.59 121.32,152.59 121.37,152.64 122.2,152.64 123.66,154.1 124.29,154.1 124.52,154.33 124.52,154.33 125.08,154.89 125.08,156.12 125.45,156.5 v3(125.45,158.79) 125.69,159.03 125.69,159.22 125.57,159.33 125.35,159.33 125.23,159.45 125.23,159.71 125.12,159.82 124.89,159.82 124.78,159.94 124.78,160.11 124.89,160.22 125.39,160.22 125.51,160.34 125.51,160.5 125.39,160.62 124.94,160.62 124.82,160.75 124.82,160.92 124.94,161.04 125.33,161.04 125.46,161.17 125.46,161.35 125.33,161.48 124.38,161.48 v3(121.99,163.87)
  BOTTOM w0.127: v3(120.82,152.15) 121.3,152.63 121.67,152.63 122.65,151.65 VRAM4.N7 ; v3(121.99,163.87) 121.65,163.87 121.53,163.74 120.84,163.74 120.73,163.86 120.24,163.86 119.93,164.17 119.93,164.36 119.55,164.74 VRAM3.N7
  BOTTOM w0.152: v3(125.45,158.79) 125.96,159.3 126.25,159.3 126.55,159.01 126.55,158.8 126.7,158.64 127.14,158.64 127.62,159.12 127.66,159.12 127.84,159.3 128.1,159.3 128.22,159.18 128.22,158.52 128.38,158.36 129.1,158.36 129.27,158.18 129.27,157.93 129.1,157.75 128.38,157.75 128.22,157.59 128.22,154.12 128.4,153.94 128.65,153.94 128.83,154.12 128.83,157.02 129,157.19 129.25,157.19 129.42,157.02 129.42,154.28 129.61,154.09 129.88,154.09 130.08,154.28 130.08,156.82 130.26,157 130.51,157 130.69,156.82 130.69,155.55 130.88,155.36 131.15,155.36 131.35,155.55 131.35,156.89 132,157.54 132,158.76 132.19,158.96 132.71,158.96 133.05,159.3 133.05,159.66 134.39,161 135.33,161 U19.K27
FBA_CMD29: length 65.6
  TOP w0.127: v3(122.16,150.28) 122.03,150.28 121.6,149.85 120.22,149.85 120.02,150.05 VRAM2.L7 ; v3(120.94,166.21) 121.15,166.21 121.4,166.46 122.32,166.46 122.44,166.34 VRAM1.L7
  IN1 w0.133: v3(122.16,150.28) 122.35,150.28 124.03,151.96 124.72,151.96 124.88,151.8 124.88,151.57 125.01,151.44 125.19,151.44 125.32,151.57 125.32,151.83 125.45,151.96 126.12,151.96 126.51,152.35 126.51,152.84 127.65,153.97 127.65,158.5 v3(127.76,158.62) 127.85,158.71 127.85,159.81 127.78,159.88 127.78,160.29 127.85,160.36 127.85,162.52 127.4,162.97 127.03,162.97 126.04,163.95 126.04,164.07 125.79,164.32 124.32,164.32 122.18,166.46 121.2,166.46 v3(120.94,166.21)
  BOTTOM w0.127: VRAM3.L7 119.55,165.95 119.61,165.88 120.41,165.88 120.74,166.21 v3(120.94,166.21) ; VRAM4.L7 122.96,149.83 123.12,149.83 123.2,149.92 123.2,150.2 123.37,150.37 123.37,150.54 123.24,150.67 123.07,150.67 122.87,150.47 122.61,150.47 122.51,150.57 122.28,150.57 122.16,150.44 v3(122.16,150.28)
  BOTTOM w0.152: U19.K25 137.21,161.28 136,161.28 135.46,160.75 134.63,160.75 133.35,159.47 133.35,158.96 132.41,158.02 132.41,157.31 131.93,156.82 131.93,155.49 v3(130.92,154.48) 129.93,153.49 127.41,153.49 126.54,154.35 126.54,156.51 126.72,156.69 126.98,156.69 127.15,156.51 127.15,154.53 127.33,154.35 127.59,154.35 127.76,154.53 127.76,156.99 127.59,157.17 126.37,157.17 126.07,156.86 125.78,156.86 125.59,157.06 125.59,157.34 126.02,157.78 126.68,157.78 126.94,158.03 127.13,158.03 127.39,157.78 127.59,157.78 127.76,157.95 v3(127.76,158.62)
FBA_CMD30: length 67.2
  TOP w0.127: VRAM2.J3 121.78,147.48 121.58,147.48 121.39,147.67 121.39,147.91 v3(121.65,148.17) ; VRAM1.J3 119.81,167.94 120.36,168.5 121.09,168.5 v3(121.52,168.07)
  IN1 w0.133: v3(121.52,168.07) 124.04,168.07 124.88,167.22 125.56,167.22 125.96,166.82 125.96,166.62 125.64,166.29 125.64,166.1 125.79,165.96 125.97,165.96 126.29,166.27 126.51,166.27 126.67,166.11 126.67,165.88 126.34,165.55 126.34,164.77 126.74,164.37 126.74,164.25 127.32,163.67 128.02,163.67 128.33,163.37 128.55,163.37 129.07,163.89 129.25,163.89 129.38,163.76 129.38,163.58 128.89,163.08 128.89,162.9 129.02,162.77 129.2,162.77 129.68,163.25 129.86,163.25 129.99,163.12 129.99,162.94 129.73,162.69 v3(129.73,160.6) 129.19,160.06 129.19,152.59 125.82,149.22 123.11,149.22 122.18,148.3 121.78,148.3 v3(121.65,148.17)
  BOTTOM w0.127: v3(121.65,148.17) 121.38,147.9 120.11,147.9 119.56,148.45 VRAM4.J3 ; VRAM3.J3 122.2,167.94 121.95,168.19 121.95,168.6 121.83,168.73 121.65,168.73 121.52,168.6 v3(121.52,168.07)
  BOTTOM w0.152: U19.J27 135.95,162.46 135.43,161.94 134.89,161.94 134.75,161.8 134.75,161.48 134.6,161.33 134.39,161.33 134.24,161.48 134.24,161.72 134.07,161.89 133.83,161.89 133.66,161.72 133.66,160.85 133.41,160.6 130.37,160.6 130.19,160.42 130.19,160.17 130.37,159.99 132.54,159.99 132.72,159.81 132.72,159.56 132.54,159.38 131.74,159.38 131.54,159.18 131.54,157.73 131.36,157.55 131.12,157.55 130.94,157.73 130.94,159.28 130.77,159.45 130.53,159.45 130.36,159.28 130.36,157.63 130.17,157.45 129.91,157.45 129.73,157.63 v3(129.73,160.6)
FBA_CMD31: length 2.9
  TOP w0.127: v3(135.18,161.51) TP9.1
  BOTTOM w0.127: v3(135.18,161.51) 135.34,161.51 135.9,162.07 136.1,162.07 136.49,162.46 U19.J26
FBVDDQ_EN: length 78
  TOP w0.127: PR32.1 119.27,188.47 v3(119.66,188.87)
  IN1 w0.133: v3(168.03,162.17) 168.14,162.29 168.14,167.7 167.79,168.05 167.79,172.62 165.53,174.87 163.5,174.87 161.61,176.77 158.7,176.77 157.09,178.38 157.09,179.48 155.59,180.98 150.41,180.98 149.96,181.43 148.35,181.43 148.18,181.59 148.18,181.83 145.88,184.14 145.26,184.14 142.11,187.29 141,187.29 140.56,187.72 140.56,190.06 139.17,191.46 133.37,191.46 132.55,190.64 130.85,190.64 130.57,190.92 122.84,190.92 120.83,188.92 119.71,188.92 v3(119.66,188.87)
  BOTTOM w0.127: R743.2 171.23,161.53 R431.2 169.66,160.58 169.89,160.82 U18.4 169.89,162.31 169.8,162.4 168.25,162.4 v3(168.03,162.17)
FDI_CSYNC: length 51.3
  IN2 w0.133: v3(121.34,126.38) 121.35,126.37 122.52,126.37 123.75,127.6 125.73,127.6 126.3,127.04 135.06,127.04 144.26,117.84 148.03,117.84 148.8,117.08 149.29,117.08 152.12,114.25 152.12,113.64 153.49,112.27 153.49,111.73 154.09,111.13 v3(155.3,111.13)
  BOTTOM w0.089: U24.AL39 158.72,111.23 158.42,110.93 156.48,110.93 156.27,110.72 155.81,110.72 155.41,111.13 v3(155.3,111.13)
  BOTTOM w0.127: R463.1 118.75,122.63 120.06,123.95 v2(120.06,124.37) 120.48,124.37 121.34,125.23 v3(121.34,126.38)
FDI_CSYNC_R: length 17
  IN2 w0.133: v3(122.9,111.19) U27.H29 118.57,110.69 117.83,111.42 117.83,120.57 v5(118.47,121.2)
  BOTTOM w0.102: U27.H29 v3(122.9,111.19)
  BOTTOM w0.127: v5(118.47,121.2) 118.47,121.78 R463.2
FDI_INT: length 65.6
  IN2 w0.133: v3(155.96,111.15) 155.52,110.71 155.13,110.71 154.94,110.89 153.87,110.89 153.16,111.6 153.16,112.13 151.79,113.51 151.79,114.12 149.15,116.75 148.66,116.75 147.9,117.52 144.1,117.52 134.9,126.71 125.96,126.71 v3(125.56,127.12) ; v3(118.46,120.48) 118.16,120.18 118.16,112.14 118.6,111.7 121.38,111.7 v3(121.9,111.19)
  BOTTOM w0.089: v3(155.96,111.15) 156.01,111.15 156.39,111.53 158.36,111.53 158.66,111.83 U24.AL40
  BOTTOM w0.102: U27.J29 v3(121.9,111.19)
  BOTTOM w0.127: v3(125.56,127.12) 125.28,127.4 123.94,127.4 119.13,122.59 119.13,121.15 v3(118.46,120.48)
FDI_IREF: length 8.2
  BOTTOM w0.254: R470.1 150.71,118.05 153.41,115.35 154.43,115.35 155.53,114.25 156.43,114.25 U24.AT45
FDI_OVRVLTG: length 12.4
  BOTTOM w0.089: U24.AK1 159.36,94.94 158.99,94.57 158.99,93.42 160.13,92.28 160.13,89.8 v3(160.35,89.58) 160.51,89.42 160.51,88.7 159.9,88.09 159.9,87.85 159.81,87.76 159.81,87.41
  BOTTOM w0.127: R619.2 R620.1 159.28,85.51 159.81,86.04 159.81,87.41
FDI_RCOMP: length 8
  BOTTOM w0.203: R471.2 151.8,118.23 154.23,115.8 154.77,115.8 155.79,114.79 156.4,114.79 157.33,113.86 U24.AR44
FDI_TXN0: length 64.3
  TOP w0.127: v3(122,127.45) 121.76,127.68 120.61,127.68 120.25,127.32 v2(120.25,126.61) 120.01,126.85 119.78,126.85 119.71,126.79 119.71,123.75 118.49,122.52 117.92,122.52 115.55,120.15 115.55,115.42 115.83,115.15 v3(115.83,115.15)
  IN2 w0.102: v3(159.45,109.69) 159.03,110.11 159.03,110.48 158.7,110.81 157.98,110.81 155.78,113.01 155.75,113.01 155.73,113.03
  IN2 w0.133: v3(122,127.45) 122.24,127.68 122.69,127.68 123.39,128.39 126.04,128.39 126.62,127.81 135.41,127.81 144.6,118.61 144.61,118.61 148.67,118.61 149.39,117.88 150.2,117.88 154.35,113.73 155.03,113.73 155.73,113.03
  BOTTOM w0.102: v3(115.83,115.15) 116.29,114.69 U27.P33 ; v3(159.45,109.69) 159.7,109.44 U24.AJ35
FDI_TXN1: length 60.5
  TOP w0.127: v3(124.1,125.98) 123.85,126.23 122.67,126.23 121.79,125.35 v2(121.79,124.58) 121.02,124.58 120.77,124.34 120.77,123.56 118.85,121.65 118.29,121.65 117.96,121.32 117.96,117.01 116.59,115.64 116.59,114.32 116.72,114.19 v3(116.92,114.19)
  IN2 w0.102: 156.21,109.67 156.24,109.67 156.26,109.7 157.52,109.7 157.95,109.26 158.21,109.26 v3(158.43,109.04)
  IN2 w0.133: v3(124.1,125.98) 124.33,126.21 124.49,126.21 125.02,125.67 134.5,125.67 143.92,116.25 146.83,116.25 153.2,109.87 154.98,109.87 155.18,109.67 156.21,109.67
  BOTTOM w0.102: U24.AL35 158.84,109.44 v3(158.43,109.04) ; U27.N32 117.25,113.54 117.07,113.54 116.92,113.69 v3(116.92,114.19)
FDI_TXP0: length 64.2
  TOP w0.127: v3(115.04,115.16) 115.31,115.42 115.31,120.25 117.82,122.76 118.39,122.76 119.47,123.85 119.47,126.85 119.33,126.99 v2(119.33,127.53) 120.11,127.53 120.51,127.92 121.71,127.92 v3(122,128.21)
  IN2 w0.102: 155.91,113.21 155.93,113.19 155.93,113.16 158.07,111.02 158.78,111.02 v3(159.45,110.34)
  IN2 w0.133: 155.91,113.21 155.13,113.99 154.46,113.99 150.31,118.14 149.5,118.14 148.77,118.86 144.71,118.86 144.71,118.87 135.51,128.06 126.72,128.06 126.14,128.64 123.29,128.64 122.58,127.94 122.27,127.94 v3(122,128.21)
  BOTTOM w0.102: U24.AJ36 159.76,110.04 v3(159.45,110.34) ; v3(115.04,115.16) 115.4,114.8 U27.R33
FDI_TXP1: length 60.5
  TOP w0.127: v3(124.1,126.74) 123.83,126.47 122.57,126.47 121.59,125.5 v2(120.87,125.5) 120.87,124.78 120.53,124.44 120.53,123.66 118.75,121.89 118.19,121.89 117.72,121.42 117.72,117.11 116.35,115.74 116.35,114.66 v3(115.9,114.22)
  IN2 w0.102: v3(158.43,109.69) 158.21,109.47 158.04,109.47 157.61,109.9 156.26,109.9 156.24,109.92 156.21,109.92
  IN2 w0.133: 156.21,109.92 155.29,109.92 155.09,110.13 153.31,110.13 146.93,116.5 144.03,116.5 134.6,125.93 125.13,125.93 124.6,126.46 124.38,126.46 v3(124.1,126.74)
  BOTTOM w0.102: U27.P32 116.38,113.69 115.9,114.17 v3(115.9,114.22) ; v3(158.43,109.69) 158.74,109.69 158.97,109.91 U24.AL36
G_MBCLK: length 151.6
  TOP w0.127: v3(110.11,7.49) 109.96,7.64 109.96,8.8 C338.1 108.84,9.92 v2(108.84,11.14) 108.84,11.42 108.59,11.68 108.59,12.29 107.94,12.93 R367.1 ; v3(185,60.62) 184.71,60.33 U13.94
  IN1 w0.133: v3(185,60.62) 185.44,60.62 186,60.06 186,55.06 185.15,54.21 185.15,50.88 185.2,50.83 185.2,49.05 187.22,47.02 188.32,47.02 189.18,46.16 189.18,20.83 183.19,14.83 180.35,14.83 175.62,10.1 173.82,10.1 173.07,10.85 173.07,12.68 170.61,15.14 169.4,15.14 165.71,18.82 158.77,18.82 153.96,23.64 144.02,23.64 142.12,21.73 136.06,21.73 130.3,15.98 125.13,15.98 124.81,16.3 121.23,16.3 119.61,14.67 119.61,10.55 116.26,7.21 111.42,7.21 111.4,7.23 110.37,7.23 v3(110.11,7.49)
G_MBCLK_R: length 6
  TOP w0.127: U16.4 111.45,12.4 110.75,13.1 109.05,13.1 R367.2 108.72,13.52 107.94,14.3 R366.1 v2(106.89,14.57)
G_MBDATA: length 148.2
  TOP w0.127: U13.95 184.35,60.73 v3(185,61.38) ; R376.1 C341.1 110.64,6.82 v3(110.72,6.75)
  IN1 w0.133: v3(110.72,6.75) 110.95,6.97 111.29,6.97 111.31,6.95 116.37,6.95 119.87,10.44 119.87,14.56 121.34,16.04 124.7,16.04 125.02,15.72 130.41,15.72 136.17,21.47 142.23,21.47 144.13,23.38 153.85,23.38 158.67,18.56 165.61,18.56 169.29,14.88 170.5,14.88 172.81,12.57 172.81,10.74 173.71,9.84 175.73,9.84 180.46,14.57 183.29,14.57 189.44,20.72 189.44,46.27 188.43,47.28 187.33,47.28 185.46,49.15 185.46,50.94 185.41,50.99 185.41,54.1 186.26,54.95 186.26,60.17 185.04,61.38 v3(185,61.38)
G_MBDATA_R: length 4.6
  TOP w0.127: v2(111.79,10.28) R376.2 R377.1 112.93,9.47 112.68,9.72 U16.6
GC6_FB_EN: length 21.6
  IN2 w0.133: v3(167.85,160.7) 168.53,161.38 168.53,163.54 168.03,164.05 168.03,166.28 166.19,168.12 166.19,169.68 167.34,170.83 167.34,174.77 v3(166.93,175.18)
  BOTTOM w0.127: R387.2 164.76,177.14 v2(164.77,177.13) 164.77,176.61 166.21,175.18 v3(166.93,175.18) ; v3(167.85,160.7) 167.34,161.21 R425.1
GPIO0: length 4.2
  TOP w0.102: v3(156.91,98.78) 156.47,98.34 154.6,98.34 154.38,98.56 154.09,98.56 153.89,98.35 R153.2
  BOTTOM w0.102: U24.AT8 156.91,98.36 v3(156.91,98.78)
GPIO2: length 26.8
  IN2 w0.089: v3(168.75,101.7) 169.17,102.13 170.33,102.13 171.33,103.13 171.33,103.39 171.61,103.67 171.75,103.67
  IN2 w0.133: 171.75,103.67 173.34,103.67 174.01,104.34 176.46,104.34 176.59,104.21 179.94,104.21 181.18,105.45 184.38,105.45 184.85,105.91 185.58,105.91 185.92,105.56 v3(185.92,105.04)
  BOTTOM w0.102: v3(168.75,101.7) 168.99,101.94 U24.G17
  BOTTOM w0.127: RP7.2 181.66,101.97 181.8,102.11 183.09,102.11 183.23,102.26 183.23,102.7 185.58,105.04 v3(185.92,105.04)
GPIO8: length 190.5
  IN1 w0.133: v3(153.71,93.76) 152.4,93.76 151.9,93.26 151.2,93.26 150.88,93.59 150.88,94.07 150.07,94.87 147.69,94.87 147.17,94.35 142.89,94.35 140.61,96.64 140.61,100.22 137.47,103.35 137.47,109.17 140.1,111.79 140.1,120.7 129.92,130.88 116.23,130.88 104.36,142.76 104.36,160.18 106.61,162.42 106.61,165.6 105.18,167.02 105.18,175.1 102.06,178.22 102.06,180.64 104.7,183.29 105.55,183.29 106.84,184.57 106.84,186.91 105.9,187.85 v3(105.9,188.41)
  IN2 w0.133: v3(153.71,93.76) 152.7,92.75 152.14,92.75 151.52,92.13 151.52,89.95 152.58,88.89 152.58,85.11 152.15,84.68 152.15,82.85 152.7,82.3 155.3,82.3 157.98,79.62 v3(159.11,79.62)
  BOTTOM w0.102: 164.87,87.41 R601.1 164.44,88.36 164.44,90.44 164.16,90.72 164.16,92.04 163.52,92.69 163.52,94.97 163.42,95.07 U24.Y1
  BOTTOM w0.127: v3(159.11,79.62) 159.7,79.03 165.73,79.03 165.89,79.2 R636.1 165.35,82.45 165.35,83 165.65,83.3 165.65,84.34 165.64,84.35 165.64,85.31 165.44,85.51 R621.2 165.03,85.51 164.66,85.88 164.66,87.19 164.87,87.41 ; v3(105.9,188.41) v2(105.9,189.4) 105.9,189.5 106.48,190.08 106.86,190.08 106.86,190.08 CN2.2
GPIO12_ACIN: length 22.3
  BOTTOM w0.127: Q45.1 167.42,177.11 167.42,175.02 167.1,174.71 164.41,174.71 v2(164.27,174.57) 164.26,174.57 R403.1 160.4,170.71 156.1,170.71 153.75,168.35 153.75,167.2 153.6,167.05 152.9,167.05 U19.D7
GPIO13: length 6
  BOTTOM w0.079: 171.76,104.36 171.39,104.36 171.16,104.12 170.69,104.12 U24.C22
  BOTTOM w0.102: 171.76,104.36 171.88,104.36 172.42,104.89 173.89,104.89
  BOTTOM w0.127: 173.89,104.89 174.22,105.23 174.22,105.23 174.33,105.23 175.22,106.11 TP98.1
GPIO15: length 19.8
  TOP w0.127: v3(158.39,86.97) 158.42,86.94 R223.1 160.32,86.94 v3(160.38,86.89)
  IN1 w0.133: v3(158.39,86.97) 158.39,88.75 159.99,90.35 161.57,90.35 161.89,90.68 161.89,91.69 161.47,92.11 161.47,92.73 161.78,93.04 162.33,93.04 163.57,94.28 163.57,95.92 163.24,96.25 163.24,96.77 163.48,97.01 163.48,99.46 163.08,99.86 v3(162.98,99.86)
  BOTTOM w0.102: v3(162.98,99.86) 162.59,99.46 U24.AB11
GPIO16: length 10.8
  BOTTOM w0.102: U24.AN2 158.04,95.47 158.04,95.03 157.99,94.98 157.99,92.36 158.39,91.96 158.39,90.73 v3(158.88,90.24) 158.42,89.78 158.42,89.05 157.89,88.52 157.18,88.52 156.65,87.99 R598.1 R597.2
GPIO21: length 13
  BOTTOM w0.102: 152.7,87.42 152.7,87.9 152.97,88.17 154.24,88.17 155.25,89.18 155.25,89.84 156.92,91.51 U24.AT1
  BOTTOM w0.127: R622.2 151.49,85.95 151.49,86.33 151.84,86.67 R610.1 152.7,87.3 152.7,87.42
GPIO24: length 7.1
  TOP w0.089: 163.33,94.2 163.33,94.41 163.42,94.51 163.42,96.02 163.18,96.26 163.18,96.86 163.4,97.07 163.4,97.97 v3(163.97,98.54)
  TOP w0.127: R184.1 163.33,93.06 163.33,94.2
  BOTTOM w0.102: U24.Y10 163.81,98.54 v3(163.97,98.54)
GPIO35: length 6.1
  BOTTOM w0.102: R569.2 158.02,90.33 R568.1 158.19,90.49 158.19,91.08 v3(157.97,91.31) 157.73,91.54 U24.AP1
GPIO36: length 11
  BOTTOM w0.102: U24.AT3 156.92,95.59 157.02,95.48 157.33,95.18 157.33,91.63 155.45,89.76 155.45,89.08 154.47,88.09 R596.1 154.2,87.67 154.12,87.74 153.6,87.74 153.52,87.67 R595.2
GPIO49: length 16.2
  TOP w0.127: v3(161.04,84.8) 160.33,85.51 R229.2 R228.2 ; R226.1 R227.1 R228.2 ; R228.2 159.04,85.91 v3(159.36,86.22)
  BOTTOM w0.089: U24.AK3 159.27,95.96 159.27,95.49 159.05,95.27 159.05,94.95 158.81,94.71 158.81,93.25 159.95,92.1 159.95,89.37 159.65,89.06 159.65,87.9 159.53,87.79 159.53,87.41
  BOTTOM w0.127: v3(159.36,86.22) 159.53,86.4 159.53,87.41
GPIO57: length 8.8
  TOP w0.127: R185.1 165.26,93.6 v3(165.03,93.83)
  IN1 w0.133: v3(165.03,93.83) 165.89,94.69 165.89,96.61 165.47,97.03 165.47,99.56 165.15,99.88 v3(164.96,99.88)
  BOTTOM w0.102: v3(164.96,99.88) 164.77,100.06 U24.U12
GPIO70: length 19.5
  IN1 w0.089: 171.35,98.52 170.78,99.09 169.78,99.09 169.53,99.34 169.06,99.34 v3(168.68,99.73)
  IN1 w0.133: 171.35,98.52 171.4,98.47 171.4,97.82 172.11,97.11 177.07,97.11 178.17,96.01 181.44,96.01 183.03,94.41 v3(184.21,94.41)
  BOTTOM w0.102: v3(168.68,99.73) 168.99,100.03 U24.G13
  BOTTOM w0.127: v3(184.21,94.41) 184.43,94.64 R556.1
GPIO71: length 21
  IN1 w0.089: 171.35,99.87 170.89,100.33 169.56,100.33 169.55,100.32 169.22,100.32 169.22,100.33 169.13,100.33 v3(168.74,100.72)
  IN1 w0.133: 171.35,99.87 172.46,98.76 172.51,98.76 172.57,98.7 172.95,98.7 173.01,98.76 176.52,98.76 177.27,98.01 179.02,98.01 179.29,97.74 181.63,97.74 183.52,95.85 184.4,95.85 v3(184.91,95.33)
  BOTTOM w0.102: v3(168.74,100.72) 168.39,101.07 U24.H15
  BOTTOM w0.127: v3(184.91,95.33) 184.43,95.33 183.76,94.66 R555.1
GPP_TX4N_LAN: length 4.8
  TOP w0.127: U7.18 28.92,101.01 29,101.08 29,101.38 29.22,101.61 29.71,101.61 29.81,101.7 29.81,101.88 v2(29.31,102.38) 29.87,102.93 29.87,103.61 29.73,103.74 C156.1
GPP_TX4P_LAN: length 4.8
  TOP w0.127: C157.1 30.23,103.74 30.11,103.62 30.11,102.88 v2(30.61,102.38) 30.05,101.82 30.05,101.6 29.81,101.36 29.32,101.36 29.24,101.28 29.24,101.09 29.32,101.01 U7.17
GPU_PEX_RST_HOLD#: length 34.4
  IN1 w0.133: v3(166.91,165.98) 166.37,165.45 166.37,159.81 162.62,156.05 162.62,153.18 165.21,150.59 v3(165.89,150.59)
  BOTTOM w0.127: v3(165.89,150.59) 166.13,150.34 R440.1 166.65,151.04 166.65,151.05 U21.1 ; U19.C4 155.37,167.82 159.6,167.82 160.4,167.02 164.77,167.02 165.28,166.52 166.37,166.52 v3(166.91,165.98)
GPU_PWR_GD: length 38.2
  IN1 w0.133: v3(169.3,166.62) 169.3,162.63 169.94,161.98 169.94,159.06 169.68,158.79 169.68,157.78 170.17,157.29 170.17,148.82 169.47,148.13 169.47,146.96 170.16,146.27 170.16,140.93 171.78,139.31 177.72,139.31 v3(178.29,139.87)
  BOTTOM w0.127: v3(169.3,166.62) 169.49,166.42 R412.1 ; v3(177.75,140.3) 177.86,140.3 v3(178.29,139.87) 178.59,140.18 PR171.2
GPUT_CLK_L: length 10
  TOP w0.127: v3(150.41,167.04) 150.4,167.04 150.4,168.36 v2(151.56,169.53) 151.15,169.53 150.25,170.43 150.25,171.49 151.01,172.26 151.12,172.26 R10.2 151.76,172.89 Q3.4
  BOTTOM w0.127: v3(150.41,167.04) 150.41,167.04 U19.D9
GPUT_DATA_L: length 8.1
  TOP w0.127: v3(152.07,167.04) 152.07,167.45 v2(152.33,167.71) 152.35,167.73 152.35,169.13 153.22,170 R12.2 153.52,170.45 153.9,170.07 154.92,170.07 155.42,170.58 Q3.1
  BOTTOM w0.127: U19.D8 152.05,167.04 v3(152.07,167.04)
H_CPU_SVIDART#: length 14.7
  IN2 w0.133: v5(98.04,110.15) 97.32,109.42 97.32,109.04 95.81,107.53 94.65,107.53 94.38,107.25 94.38,106.72 93.93,106.28 93.56,106.28 92.97,105.69 92.97,105.33 90.94,103.29 90.67,103.29 90.25,102.88 v3(90.25,102.58)
  BOTTOM w0.102: v5(98.04,110.15) 98.4,109.79 U27.AM28
  BOTTOM w0.127: v3(90.25,102.58) 90,102.83 R521.1
H_CPU_SVIDCLK: length 17.6
  IN2 w0.133: v3(97.93,111.15) 97.49,110.72 96.89,110.72 96.36,110.19 96.36,109.09 95.39,108.12 93.63,108.12 90.78,105.28 v3(90.78,104.92)
  BOTTOM w0.114: v3(97.93,111.15) U27.AM29
  BOTTOM w0.127: R524.1 85.55,104.03 v3(86.11,104.59) 86.59,104.59 86.87,104.31 89.62,104.31 89.84,104.54 90.4,104.54 v3(90.78,104.92)
H_CPU_SVIDDAT: length 18.8
  IN2 w0.133: v3(91.02,102.5) 93.75,105.23 94.79,105.23 96.42,106.86 96.42,107.31 98.83,109.71 v3(98.83,110.22)
  BOTTOM w0.114: v3(98.83,110.22) 99.36,109.69 U27.AL28
  BOTTOM w0.127: R534.1 85.96,101.2 86.67,100.49 R533.2 89.01,100.49 v3(91.02,102.5)
H_PECI: length 231.6
  TOP w0.114: v3(145.89,49.14) 151.43,54.68 151.43,66.65 151.13,66.95 151.13,70.87 151.77,71.51 151.77,71.91 151.85,71.99 ; R275.2 170.03,68.42 v3(169.14,69.31) 168.92,69.31 168.03,70.21 168.03,70.63 166.49,72.17 155.98,72.17 155.73,71.92 151.92,71.92 151.85,71.99 ; v3(151.85,71.99) 151.85,71.99
  IN1 w0.127: v3(149.89,86.26) 149.51,85.88 149.51,84.01 148.74,83.25 148.74,77.68 151.83,74.6 151.83,72.01 v3(151.85,71.99)
  IN2 w0.127: v3(145.89,49.14) 143.82,47.07 143.81,47.07 141.25,44.51 141.25,43.12 138.63,40.5 138.09,40.5 135.46,37.87 122.33,37.87 117.62,33.16 113.53,33.16 113.04,32.66 91.88,32.66 91.45,33.1 83.86,33.1 81.13,35.83 77.74,35.83 74.79,38.79 74.65,38.79 66.96,46.47 66.96,59.56 68.18,60.78 68.18,73.07 69.45,74.35 69.45,84.46 83.6,98.6 83.6,100.09 86.01,102.51 86.01,103.08 92.41,109.48 94.6,109.48 v3(94.93,109.15)
  BOTTOM w0.114: R593.2 149.89,86.89 149.89,86.26 v3(149.89,86.26) ; U27.AR27 v3(94.93,109.15)
H_PROCHOT#: length 449.5
  IN2 w0.133: v4(35.58,99.27) 34.56,98.25 34.56,92.28 32.11,89.83 32.11,74.95 30.28,73.12 28.71,73.12 28.22,72.64 28.22,70.27 25.28,67.32 25.28,62.3 19.49,56.51 19.49,50.97 18.98,50.47 18.98,42.53 22.46,39.06 30.2,39.06 30.97,39.82 36.17,39.82 39.27,36.72 39.27,35.04 44.56,29.76 44.56,29.5 51.53,22.53 67.55,22.53 70.54,25.52 142.88,25.52 147.62,30.27 147.62,41.21 152,45.59 152,48.02 151.46,48.56 151.46,58.01 v3(153.12,59.67) ; v3(146.52,181.74) 145.95,182.32 144.55,182.32 140.5,186.37 140.5,187.67 136.48,191.69 130.08,191.69 130,191.61 120.3,191.61 114.38,185.69 110.98,185.69 110.44,185.16 104.8,185.16 101.15,181.51 101.15,172.42 103.79,169.78 v3(103.79,141.7)
  BOTTOM w0.127: v3(153.12,59.67) 153.92,58.87 157.74,58.87 Q53.3 ; 44.56,100.4 45.1,99.86 PR113.2 45.11,99.79 45.9,99 45.9,95.98 45.41,95.48 PU7.30 ; 44.56,100.4 43.65,100.4 43.49,100.25 36.55,100.25 v4(35.58,99.27) ; 44.56,100.4 44.56,100.88 46.09,102.42 50.98,102.42 51.22,102.18 51.24,102.18 54.46,98.95 63.36,98.95 67.14,102.73 67.14,104.19 68.89,105.94 73.36,105.94 95.01,127.59 R453.1 R454.1 104.5,132.92 104.5,140.99 v3(103.79,141.7) ; v3(146.52,181.74) 146.23,181.74 145.7,181.21 145.7,179.27 146.46,178.5 PQ9.3 147.45,177.83 147.09,177.46 PR40.1
H_PROCHOT#_R: length 19.5
  TOP w0.127: v3(98.85,112.14) 98.85,113.57 99.38,114.1 99.38,116.59 100.25,117.46 100.25,120.73 100.39,120.87 100.39,121.37 100.07,121.69 99.01,121.69 98.68,122.01 98.68,124.86 98.25,125.29 98.25,126 98.81,126.56 v3(99.95,126.56)
  BOTTOM w0.102: U27.AM30 v3(98.85,112.14)
  BOTTOM w0.127: R454.2 99.41,126.56 v3(99.95,126.56)
H_PWRGOOD: length 97.5
  TOP w0.114: R50.1 95.71,121.55 95.71,118.84 v3(95.85,118.7)
  IN1 w0.127: v3(153.75,92.27) 153.75,92.16 151.86,90.26 146.13,90.26 145.7,90.7 141.69,90.7 132.92,99.46 132.92,111.02 134.18,112.27 134.18,113.32 135.01,114.15 135.01,117.63 134.18,118.46 134.18,120.64 132.68,122.14 116.08,122.14 113.63,119.69 96.84,119.69 v3(95.85,118.7)
  BOTTOM w0.102: TP124.1 153.6,92.12 v3(153.75,92.27) 154.59,93.11 154.59,93.67 155.8,94.88 155.8,95.26 155.8,95.26 155.98,95.44 155.98,95.44 156.01,95.47 156.01,95.94 U24.AV3
H_PWRGOOD_R: length 12.7
  TOP w0.114: R50.2 96.38,122.71 97.17,121.93 R51.2 97.51,121.93 97.87,122.29 98.1,122.29 98.25,122.14 98.25,121.78 v3(98.42,121.6) 99.05,120.97 99.05,120.03 99.39,119.7 R58.1 99.69,119.46 99.55,119.32 99.3,119.32 99.17,119.19 99.17,119 99.3,118.86 99.55,118.86 99.69,118.72 99.69,117.98 99.48,117.77 98.83,117.77 98.52,117.46 98.52,117.25 98.63,117.14 98.83,117.14 98.96,117 98.96,116.81 98.83,116.68 98.61,116.68 98.45,116.52 98.45,116.3 98.61,116.14 v3(98.77,116.14)
  BOTTOM w0.102: U27.AL34 99.22,115.69 v3(98.77,116.14)
HDA_BCLK_R: length 12.8
  BOTTOM w0.102: 173.93,106.93 173.93,106.74 173.85,106.66 173.6,106.66 173.51,106.57 173.51,106.27 173.44,106.19 173.14,106.19 173.04,106.29 173.04,106.7 172.96,106.78 172.76,106.78 172.63,106.65 172.63,106.05 172.53,105.95 172.33,105.95 172.23,106.05 172.23,106.68 172.13,106.78 171.92,106.78 171.82,106.68 171.82,106.07 171.72,105.97 171.39,105.97 171.2,105.79 171.2,105.42 U24.B25
  BOTTOM w0.127: 173.93,106.93 173.93,107.24 174.13,107.44 174.45,107.44 174.55,107.54 174.55,107.79 174.65,107.89 175.08,107.89 175.19,108 175.19,108.27 175.28,108.37 175.55,108.37 175.85,108.07 176,108.07 176.13,108.2 176.13,108.58 176.58,109.03 176.58,109.17 176.38,109.37 176.15,109.37 175.59,108.8 R498.2
HDA_RST#_R: length 13.4
  BOTTOM w0.102: 176.26,106.51 176.26,106.75 176.1,106.9 175.48,106.9 173.68,105.1 172.22,105.1 171.67,104.55 171.39,104.55 171.08,104.86 U24.C24 ; 176.71,106.51 176.73,106.53
  BOTTOM w0.127: 176.71,106.51 176.69,106.5 176.69,106.1 176.6,106.01 176.34,106.01 176.26,106.1 176.26,106.51 ; R506.2 179.08,106.44 179.28,106.24 179.28,105.78 179.19,105.69 178.67,105.69 178.16,106.2 178.16,106.7 178.03,106.83 177.8,106.83 177.7,106.72 177.7,106.42 177.59,106.3 177.28,106.3 176.97,106.62 176.81,106.62 176.73,106.53
HDA_SDO_R: length 75.7
  TOP w0.127: U13.106 178.03,63.62 178.39,63.98 178.92,63.98 180.18,65.23 v4(181.06,65.23)
  BOTTOM w0.102: U24.A24 171.96,105.3 173.53,105.3 175.44,107.21 176.46,107.21
  BOTTOM w0.127: v4(181.06,65.23) 180.59,65.23 180.25,65.57 180.25,66.62 179.23,67.65 179.23,70.15 178.68,70.69 178.68,71.15 174.74,75.09 174.74,76.81 175.14,77.21 175.16,77.21 179.02,81.07 179.02,82.47 183.48,86.92 184.76,86.92 187.19,89.35 187.19,90.91 188.6,92.32 188.6,97.42 187.96,98.06 187.96,100.26 188.84,101.13 188.84,106.39 186.88,108.35 182,108.35 181.64,108 179.96,108 179.88,108.07 178.21,108.07 177.96,108.32 R501.1 177.51,108.04 177.08,107.61 R505.2 176.46,107.21
