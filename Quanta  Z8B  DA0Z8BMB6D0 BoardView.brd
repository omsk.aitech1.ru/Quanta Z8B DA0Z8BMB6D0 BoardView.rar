# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ15: length 61.4
  IN2 w0.089: 92.41,88.84 93.25,89.68 94.14,89.68 94.44,89.99 94.44,90.37 94.75,90.67 95.31,90.67 95.53,90.9 95.53,91.32 95.76,91.56 96.33,91.56 v5(96.93,92.16)
  IN2 w0.133: v3(82.44,54.67) 81.56,55.56 81.56,56.8 81.39,56.97 81.39,58.26 81.13,58.52 81.13,66.99 80.38,67.74 80.38,74.46 78.29,76.54 78.29,82.59 82,86.3 89.58,86.3 89.72,86.43 89.72,86.58 89.38,86.92 89.38,87.1 89.67,87.39 89.9,87.39 90.32,86.97 90.54,86.97 90.7,87.13 90.7,87.36 90.28,87.78 90.28,88 90.44,88.16 90.66,88.16 91.09,87.73 91.32,87.73 91.48,87.88 91.48,88.11 91.05,88.53 91.05,88.75 91.21,88.91 91.43,88.91 91.86,88.49 92.05,88.49 92.41,88.84
  BOTTOM w0.114: U27.AN11 96.93,92.22 v5(96.93,92.16)
  BOTTOM w0.127: JDIM1.36 84.55,52.57 v3(82.44,54.67)
M_B_DQ16: length 41.5
  IN2 w0.089: 92.41,84.14 92.95,84.68 94.11,84.68 94.5,85.07 94.5,85.72 v5(94.93,86.16)
  IN2 w0.133: 92.41,84.14 88.07,79.8 88.07,78.33 85.87,76.14 85.87,73.57 84.79,72.49 84.79,55.6 85.25,55.14 85.25,53.34 85.39,53.19 85.86,53.19 v3(86.11,53.44)
  BOTTOM w0.114: U27.AR5 94.93,86.22 v5(94.93,86.16)
  BOTTOM w0.127: JDIM1.42 86.35,53.2 v3(86.11,53.44)
M_B_DQ17: length 42.5
  IN2 w0.089: 92.41,84.8 93.27,85.67 94.01,85.67 94.49,86.15 94.49,86.72 v3(94.93,87.16)
  IN2 w0.133: v3(84.1,54.33) 84.43,54.33 84.74,54.63 84.74,55.1 84.44,55.4 84.44,58.03 84.4,58.07 84.4,72.65 85.48,73.73 85.48,76.35 87.68,78.55 87.68,80.08 92.41,84.8
  BOTTOM w0.114: v3(94.93,87.16) 94.93,87.22 U27.AR6
  BOTTOM w0.127: v3(84.1,54.33) 84.46,54.33 85.75,53.03 JDIM1.40
M_B_DQ18: length 44
  IN2 w0.089: v3(97.93,86.16) 97.65,86.16 97.34,85.85 97.34,85 97.1,84.75 96.63,84.75 96.33,84.45 96.33,83.87 95.2,82.75 94.15,82.75 93.99,82.59
  IN2 w0.133: 93.99,82.59 93.94,82.54 93.94,82.4 94.21,82.13 94.21,81.91 94.05,81.75 93.83,81.75 93.53,82.05 93.34,82.05 93.15,81.85 93.15,81.66 93.39,81.43 93.39,81.2 93.23,81.04 93.01,81.04 92.77,81.28 92.58,81.28 90.19,78.89 90.19,77.45 88,75.25 88,61.67 87.86,61.54 87.44,61.54 87.3,61.4 87.3,61.13 87.44,61 87.86,61 88,60.87 88,60.59 87.86,60.45 87.38,60.45 87.25,60.32 87.25,60.05 87.38,59.91 87.86,59.91 88,59.78 88,59.51 87.86,59.37 87.39,59.37 87.25,59.24 87.25,58.97 87.39,58.83 87.86,58.83 88,58.7 88,57.46 v3(87.61,57.08)
  BOTTOM w0.114: v3(97.93,86.16) 97.93,86.22 U27.AM5
  BOTTOM w0.127: v3(87.61,57.08) 89.05,58.51 JDIM1.51
M_B_DQ19: length 44.8
  IN2 w0.089: 94.21,81.48 96.52,83.79 96.52,84.31 96.77,84.56 97.17,84.56 97.52,84.91 97.52,85.44 97.72,85.64 98.25,85.64 98.48,85.87 98.48,86.6 v5(97.93,87.16)
  IN2 w0.133: 94.21,81.48 93.15,80.41 92.96,80.41 92.7,80.67 92.51,80.67 92.32,80.47 92.32,80.28 92.58,80.03 92.58,79.84 92.38,79.65 92.19,79.65 91.94,79.9 91.75,79.9 91.56,79.71 91.56,79.52 91.81,79.27 91.81,79.08 91.62,78.88 91.43,78.88 91.18,79.14 90.99,79.14 90.58,78.73 90.58,77.29 88.38,75.09 88.38,54.07 88.2,53.89 v3(87.69,53.89)
  BOTTOM w0.114: U27.AM6 97.93,87.22 v5(97.93,87.16)
  BOTTOM w0.127: JDIM1.50 88.75,52.82 v3(87.69,53.89)
M_B_DQ20: length 41.2
  IN2 w0.089: 92.41,85.35 93.21,86.16 v3(93.93,86.16)
  IN2 w0.133: v3(83.98,57.06) 83.58,57.46 83.58,58.07 84.01,58.51 84.01,73.28 84.15,73.41 84.61,73.41 84.75,73.54 84.75,73.82 84.61,73.95 84.13,73.95 83.99,74.09 83.99,74.36 84.12,74.49 84.79,74.49 84.92,74.62 84.92,74.9 84.79,75.03 84.13,75.03 83.99,75.17 83.99,75.61 87.29,78.91 87.29,80.24 92.41,85.35
  BOTTOM w0.114: v3(93.93,86.16) 93.93,86.22 U27.AT5
  BOTTOM w0.127: JDIM1.39 85.45,58.53 84.94,58.02 84.94,57.53 84.48,57.06 v3(83.98,57.06)
M_B_DQ21: length 42.2
  IN2 w0.089: 92.41,85.98 93.58,87.16 93.66,87.16
  IN2 w0.133: 92.41,85.98 86.9,80.48 86.9,79.07 83.56,75.72 83.56,58.73 83.27,58.44 83.27,56.34 v3(83.96,55.65) ; 93.66,87.16 v3(93.93,87.16)
  BOTTOM w0.114: v3(93.93,87.16) 93.93,87.22 U27.AT6
  BOTTOM w0.127: v3(83.96,55.65) 85.35,57.05 85.35,57.91 86.05,58.61 JDIM1.41
M_B_DQ22: length 43.8
  IN2 w0.089: v5(96.93,86.16) 96.93,85.86 96.52,85.45 96.52,84.91 96.17,84.56 95.71,84.56 95.52,84.37 95.52,83.8 95.28,83.56 94.72,83.56 94.29,83.13 93.88,83.13 93.22,82.47
  IN2 w0.133: v3(87.61,55.86) 87.08,56.39 87.08,58.3 86.78,58.6 86.78,62.24 86.91,62.36 87.43,62.36 87.56,62.5 87.56,62.77 87.43,62.9 86.94,62.9 86.81,63.04 86.81,63.31 86.94,63.44 87.43,63.44 87.56,63.58 87.56,63.82 87.4,63.97 87.03,63.97 86.9,64.11 86.9,64.38 87.03,64.51 87.45,64.51 87.61,64.67 87.61,75.42 89.81,77.61 89.81,79.05 93.22,82.47
  BOTTOM w0.114: U27.AN5 96.93,86.22 v5(96.93,86.16)
  BOTTOM w0.127: JDIM1.53 89.65,58.63 88.81,57.79 88.81,57.05 v3(87.61,55.86)
M_B_DQ23: length 44.7
  IN2 w0.089: 92.94,82.74 93.51,83.3 94.21,83.3 94.64,83.74 95.2,83.74 95.33,83.87 95.33,84.45 95.63,84.75 96.1,84.75 96.33,84.99 96.33,85.82 96.53,86.02 96.53,86.75 v3(96.93,87.16)
  IN2 w0.133: 92.94,82.74 89.42,79.21 89.42,77.77 87.22,75.58 87.22,66.14 87.09,66 86.53,66 86.4,65.87 86.4,65.6 86.53,65.46 87.09,65.46 87.22,65.33 87.22,65.06 87.09,64.92 86.53,64.92 86.4,64.79 86.4,58.44 86.69,58.14 86.69,55.15 87.3,54.53 v3(87.69,54.53)
  BOTTOM w0.114: v3(96.93,87.16) 96.93,87.22 U27.AN6
  BOTTOM w0.127: v3(87.69,54.53) 87.71,54.53 88.65,53.59 88.65,53.51 89.35,52.81 JDIM1.52
M_B_DQ24: length 42.6
  IN2 w0.089: 95.41,80.27 95.85,80.71 96.37,80.71 96.88,81.22 97.95,81.22 98.53,81.8 98.53,83.46 98.74,83.67 99.13,83.67 99.43,83.97 99.43,84.41 99.68,84.66 100.43,84.66 v5(100.93,85.16)
  IN2 w0.133: v3(89.52,55.53) 90,56 90,56.33 90.62,56.96 90.62,59.17 90.95,59.49 90.95,64.36 90.82,64.49 90.22,64.49 90.09,64.63 90.09,64.9 90.23,65.04 90.78,65.04 90.95,65.21 90.95,75.25 92.28,76.58 92.28,77.14 95.41,80.27
  BOTTOM w0.102: v5(100.93,85.16) 100.93,85.22 U27.AJ4
  BOTTOM w0.127: JDIM1.58 91.15,52.77 89.95,53.97 89.95,55.1 v3(89.52,55.53)
M_B_DQ25: length 42.1
  IN2 w0.089: 95.14,80.55 95.63,81.04 96.34,81.04 96.78,81.48 97.75,81.48 98.33,82.05 98.33,84.12 98.96,84.75 99.1,84.75 99.5,85.16 v3(99.93,85.16)
  IN2 w0.133: 95.14,80.55 91.89,77.3 91.89,76.74 89.7,74.55 89.7,70.57 90.33,69.94 90.33,68.94 89.7,68.3 89.7,64.18 89.87,64 90.35,64 90.49,63.87 90.49,63.57 90.35,63.44 89.83,63.44 89.7,63.31 89.7,63.03 89.83,62.9 90.35,62.9 90.49,62.77 90.49,62.49 90.35,62.36 89.83,62.36 89.7,62.23 89.7,61.96 89.83,61.82 90.33,61.82 90.46,61.69 90.46,61.42 90.33,61.28 89.83,61.28 89.7,61.15 89.7,60.88 89.83,60.74 90.43,60.74 90.56,60.61 90.56,59.65 90.23,59.33 90.23,57.92 89.8,57.49 v3(89.8,57.49)
  BOTTOM w0.102: U27.AK4 99.93,85.22 v3(99.93,85.16)
  BOTTOM w0.127: JDIM1.57 90.85,58.55 v3(89.8,57.49)
M_B_DQ26: length 39.8
  IN2 w0.089: 97.45,79.3 97.72,79.57 98.3,79.57 100.89,82.16 v3(100.93,82.16)
  IN2 w0.133: v3(92.52,56.52) 93.08,56.52 93.62,57.06 93.62,65.67 93.49,65.81 93.21,65.81 93.08,65.94 93.08,66.21 93.21,66.35 93.49,66.35 93.62,66.48 93.62,66.75 93.49,66.89 93.21,66.89 93.08,67.02 93.08,67.29 93.21,67.43 93.49,67.43 93.62,67.56 93.62,67.83 93.49,67.97 93.21,67.97 93.08,68.1 93.08,68.49 93.21,68.62 93.51,68.62 93.65,68.75 93.65,69.03 93.51,69.16 93.21,69.16 93.08,69.29 93.08,69.61 93.2,69.74 93.48,69.74 93.63,69.89 93.63,71.88 93.5,72.02 93.21,72.02 93.08,72.15 93.08,72.42 93.21,72.56 93.5,72.56 93.63,72.69 93.63,72.96 93.5,73.1 93.21,73.1 93.08,73.23 93.08,74.37 94.41,75.7 94.41,76.26 96.44,78.29 97.45,79.3
  BOTTOM w0.102: U27.AJ1 100.93,82.22 v3(100.93,82.16)
  BOTTOM w0.127: JDIM1.69 94.45,57.71 93.26,56.52 v3(92.52,56.52)
M_B_DQ27: length 40.7
  IN2 w0.089: 96.82,79.22 97.45,79.85 98.25,79.85 100.34,81.94 100.34,82.56 v5(100.93,83.16)
  IN2 w0.133: v3(92.52,57.18) 93.07,57.18 93.24,57.34 93.24,58.68 93.1,58.82 92.85,58.82 92.71,58.95 92.71,59.22 92.85,59.35 93.1,59.35 93.24,59.49 93.24,59.76 93.1,59.89 92.82,59.89 92.69,60.03 92.69,60.3 92.82,60.43 93.1,60.43 93.24,60.57 93.24,60.84 93.1,60.97 92.82,60.97 92.69,61.11 92.69,61.38 92.82,61.51 93.1,61.51 93.24,61.65 93.24,61.92 93.1,62.05 92.82,62.05 92.69,62.19 92.69,62.46 92.82,62.59 93.1,62.59 93.24,62.73 93.24,63 93.1,63.13 92.82,63.13 92.69,63.27 92.69,63.54 92.82,63.67 93.1,63.67 93.24,63.81 93.24,64.08 93.1,64.21 92.82,64.21 92.69,64.35 92.69,64.62 92.82,64.75 93.1,64.75 93.24,64.89 93.24,65.16 93.1,65.29 92.82,65.29 92.69,65.43 92.69,71.01 92.82,71.14 93.09,71.14 93.24,71.29 93.24,71.5 93.09,71.65 92.82,71.65 92.69,71.77 92.69,74.53 94.02,75.86 94.02,76.42 96.82,79.22
  BOTTOM w0.102: v5(100.93,83.16) 100.93,83.22 U27.AJ2
  BOTTOM w0.127: JDIM1.67 93.85,57.8 93.23,57.18 v3(92.52,57.18)
M_B_DQ28: length 37.4
  IN2 w0.102: v3(97.93,82.22) 97.57,82.57 96.65,82.57 96.42,82.34 96.42,81.98 96.11,81.67 95.17,81.67 94.59,81.09
  IN2 w0.133: v3(89.44,54.15) 88.92,54.67 88.92,74.87 91.12,77.07 91.12,77.62 94.59,81.09
  BOTTOM w0.114: U27.AM1 v3(97.93,82.22)
  BOTTOM w0.127: JDIM1.56 90.55,52.95 89.44,54.06 v3(89.44,54.15)
M_B_DQ29: length 36.8
  IN2 w0.089: 94.87,80.82 95.36,81.32
  IN2 w0.102: v5(96.93,82.16) 96.93,81.96 96.29,81.32 95.36,81.32
  IN2 w0.133: 94.87,80.82 91.51,77.46 91.51,76.91 89.31,74.71 89.31,70.41 89.95,69.78 89.95,69.1 89.31,68.46 89.31,60.49 89.45,60.35 89.86,60.35 90.02,60.2 90.02,59.97 89.86,59.82 89.45,59.82 89.31,59.68 89.31,59.41 89.45,59.28 89.69,59.28 89.85,59.12 89.85,58.89 89.69,58.74 89.45,58.74 89.31,58.6 89.31,57.31 v3(89.8,56.82)
  BOTTOM w0.114: v5(96.93,82.16) 96.93,82.22 U27.AN1
  BOTTOM w0.127: JDIM1.59 91.45,57.23 91.04,56.82 v3(89.8,56.82)
M_B_DQ30: length 40.3
  IN2 w0.102: 100.48,81.39 100.84,81.75 101.1,81.75 101.35,82 101.35,83.36 101.14,83.56 100.69,83.56 100.29,83.16 v3(99.93,83.16)
  IN2 w0.133: v3(92.52,55.2) 93.76,55.2 94.04,55.47 94.04,74.78 94.8,75.54 94.8,76.1 97.97,79.27 98.35,79.27 100.48,81.39
  BOTTOM w0.102: v3(99.93,83.16) 99.93,83.22 U27.AK2
  BOTTOM w0.127: v3(92.52,55.2) 93.42,55.2 94.75,53.86 JDIM1.70
M_B_DQ31: length 39.3
  IN2 w0.089: v3(99.93,82.16) 99.93,82.01 98.28,80.36 97.41,80.36 96.43,79.37
  IN2 w0.133: 96.43,79.37 93.63,76.58 93.63,76.02 92.3,74.69 92.3,58.93 91.97,58.6 91.97,55.08 91.05,54.16 91.05,53.79 91.32,53.51 91.55,53.51 v3(92.52,54.48)
  BOTTOM w0.102: U27.AK1 99.93,82.22 v3(99.93,82.16)
  BOTTOM w0.127: v3(92.52,54.48) 92.69,54.66 93.14,54.66 94.15,53.65 JDIM1.68
M_B_DQ32: length 40.2
  IN2 w0.089: v5(119.93,83.16) 119.49,82.72 118.75,82.72 118.52,82.49 118.52,82 119.4,81.12
  IN2 w0.133: 119.4,81.12 120.57,79.95 120.57,79.65 121.59,78.62 121.59,69.7 117.61,65.71 117.61,65.52 118.04,65.09 118.04,64.9 117.85,64.71 117.66,64.71 117.22,65.14 117.04,65.14 116.84,64.95 116.84,64.76 117.28,64.32 117.28,64.14 115.94,62.8 115.94,60.44 114.02,58.52 114.02,55.51 v3(114.94,54.59)
  BOTTOM w0.114: U27.L2 v5(119.93,83.16)
  BOTTOM w0.127: JDIM1.132 115.75,53.78 v3(114.94,54.59)
M_B_DQ33: length 39.6
  IN2 w0.089: 118.83,81.12 118.33,81.62 118.33,82.56 v3(118.93,83.16)
  IN2 w0.133: v3(114.89,53.93) 114.27,53.93 113.8,54.4 113.8,54.94 113.63,55.11 113.63,58.68 115.55,60.6 115.55,62.96 115.96,63.36 115.96,63.57 115.55,63.98 115.55,64.21 115.72,64.38 115.91,64.38 116.35,63.94 116.54,63.94 116.73,64.14 116.73,64.32 116.3,64.76 116.3,64.95 121.07,69.72 121.07,78.6 120.18,79.49 120.18,79.77 118.83,81.12
  BOTTOM w0.114: U27.M2 v3(118.93,83.16)
  BOTTOM w0.127: JDIM1.130 115.15,52.76 115.32,52.93 115.32,53.5 v3(114.89,53.93)
M_B_DQ34: length 42.9
  IN2 w0.089: v3(119.93,85.16) 119.43,85.16 119.33,85.06 119.33,84.83 119.42,84.75 121.17,84.75 121.52,84.4 121.52,83.99 121.76,83.75 122.19,83.75 122.53,83.41 122.53,82.99 122.76,82.75 123.39,82.75 123.52,82.62 123.52,81.99 123.97,81.55 123.97,81.37
  IN2 w0.133: 123.97,81.37 123.97,81.13 123.84,81 123.31,81 123.18,80.86 123.18,80.59 123.31,80.46 123.84,80.46 124.15,80.14 124.15,67.44 118.45,61.74 118.45,59.39 118.06,59 118.06,56.3 117.93,56.17 v3(117.66,56.17)
  BOTTOM w0.114: U27.L4 v3(119.93,85.16)
  BOTTOM w0.127: JDIM1.143 119.05,56.53 118.69,56.17 v3(117.66,56.17)
M_B_DQ35: length 42.8
  IN2 w0.089: v5(118.93,85.16) 118.42,85.16 118.32,85.06 118.32,84.65 118.41,84.56 121.1,84.56 121.33,84.32 121.33,83.91 121.68,83.56 122.1,83.56 122.35,83.3 122.35,81.97 122.71,81.61 122.71,81.12
  IN2 w0.133: v3(117.61,57.02) 117.61,56.79 117.35,56.53 117.05,56.53 116.9,56.69 116.9,56.94 117.21,57.26 117.21,57.45 117.06,57.6 116.62,57.6 116.52,57.7 116.52,58.01 116.67,58.16 117.5,58.16 117.67,58.33 117.67,59.16 118.07,59.56 118.07,61.9 123.77,67.6 123.77,79.46 122.71,80.51 122.71,81.12
  BOTTOM w0.114: U27.M4 v5(118.93,85.16)
  BOTTOM w0.127: JDIM1.141 118.45,57.18 118.3,57.02 v3(117.61,57.02)
M_B_DQ36: length 38.9
  IN2 w0.133: v3(119.93,82.16) 119.93,81.69 120.11,81.5 120.3,81.5 120.55,81.75 120.74,81.75 120.93,81.56 120.93,81.37 120.68,81.12 120.68,80.93 121.34,80.27 121.34,79.97 122.38,78.93 122.38,69.39 121.78,68.79 121.78,68.6 122.2,68.18 122.2,67.95 122.05,67.8 121.82,67.8 121.4,68.22 121.21,68.22 121.02,68.03 121.02,67.84 121.44,67.41 121.44,67.19 121.28,67.03 121.06,67.03 120.63,67.46 120.45,67.46 120.25,67.26 120.25,67.03 120.67,66.61 120.67,66.42 120.48,66.23 120.29,66.23 119.87,66.65 119.64,66.65 119.48,66.49 119.48,66.27 119.91,65.85 119.91,65.66 116.71,62.46 116.71,60.12 114.88,58.28 v3(114.88,57.17)
  BOTTOM w0.114: v3(119.93,82.16) U27.L1
  BOTTOM w0.127: JDIM1.129 114.85,58.42 115.42,57.85 115.42,57.3 115.3,57.17 v3(114.88,57.17)
M_B_DQ37: length 38.6
  IN2 w0.089: v3(118.93,82.16) 118.93,82.14 119.95,81.12
  IN2 w0.133: v3(114.92,55.88) 114.53,55.88 114.41,56 114.41,58.36 116.33,60.28 116.33,62.64 118.59,64.9 118.59,65.09 118.15,65.52 118.15,65.71 118.35,65.91 118.54,65.91 118.97,65.47 119.16,65.47 119.35,65.66 119.35,65.85 118.92,66.29 118.92,66.48 121.99,69.55 121.99,78.77 120.95,79.81 120.95,80.11 119.95,81.12
  BOTTOM w0.114: U27.M1 v3(118.93,82.16)
  BOTTOM w0.127: JDIM1.131 115.45,58.55 115.75,58.25 115.75,56.02 115.6,55.88 v3(114.92,55.88)
M_B_DQ38: length 43.5
  IN2 w0.089: 124.54,81.15 124.54,82.11 123.1,83.56 122.69,83.56 122.33,83.92 122.33,84.32 122.1,84.56 121.68,84.56 121.33,84.91 121.33,85.32 121.07,85.58 119.7,85.58 119.59,85.69 119.59,85.81 v5(119.93,86.16)
  IN2 w0.133: 118.19,54.68 118.19,54.68 118.19,54.68 ; 118.19,54.68 118.45,54.93 118.45,55.16 118.22,55.39 118.22,55.92 118.45,56.15 118.45,58.84 118.84,59.23 118.84,61.58 124.54,67.28 124.54,81.15 ; 118.19,54.68 117.82,54.68 v3(117.64,54.87)
  BOTTOM w0.114: U27.L5 v5(119.93,86.16)
  BOTTOM w0.127: JDIM1.142 118.75,53.03 119,53.28 119,54.32 118.46,54.87 v3(117.64,54.87)
M_B_DQ39: length 43.7
  IN2 w0.089: v3(118.93,86.16) 119.36,86.16 119.84,86.63 120.22,86.63 120.4,86.45 120.4,86.02 120.67,85.75 121.15,85.75 121.52,85.38 121.52,84.99 121.76,84.75 122.17,84.75 122.52,84.4 122.52,84 122.76,83.75 123.15,83.75 124.84,82.06
  IN2 w0.133: v3(117.61,54.22) 118.31,54.22 118.75,54.66 118.75,58.6 119.23,59.07 119.23,61.42 124.93,67.12 124.93,81.97 124.84,82.06
  BOTTOM w0.114: U27.M5 v3(118.93,86.16)
  BOTTOM w0.127: JDIM1.140 118.15,54.03 117.97,54.22 v3(117.61,54.22)
M_B_DQ40: length 48.4
  IN2 w0.089: 127.43,83.93 127.43,83.76
  IN2 w0.133: 127.43,83.76 127.43,83 127.82,82.62 127.82,76.44 127.68,76.3 126.76,76.3 126.63,76.17 126.63,75.9 126.76,75.76 127.68,75.76 127.82,75.63 127.82,75.36 127.68,75.22 126.76,75.22 126.63,75.09 126.63,74.82 126.76,74.68 127.68,74.68 127.82,74.55 127.82,74.28 127.68,74.15 126.76,74.15 126.63,74.01 126.63,66.42 120.93,60.72 120.93,57.09 119.95,56.11 v3(119.87,56.11) ; v5(123.93,89.16) 123.93,88.08 125.33,86.68 126.03,86.68 126.35,86.36 126.35,85.88 126.63,85.6 127.09,85.6 127.43,85.25 127.43,83.93
  BOTTOM w0.114: v5(123.93,89.16) 123.87,89.16 U27.G7
  BOTTOM w0.127: v3(119.87,56.11) 120.02,56.11 120.85,56.93 JDIM1.149
M_B_DQ41: length 48.7
  IN2 w0.133: v3(119.87,54.79) 119.41,55.25 119.41,57.95 120.16,58.69 120.16,61.04 125.86,66.74 125.86,80.18 125.99,80.32 126.76,80.32 126.89,80.45 126.89,80.72 126.76,80.86 125.99,80.86 125.86,80.99 125.86,81.26 125.99,81.4 126.76,81.4 126.89,81.53 126.89,81.8 126.76,81.94 125.99,81.94 125.86,82.07 125.86,82.37 125.43,82.8 125.43,84.36 125.11,84.68 124.66,84.68 124.41,84.93 124.41,85.39 124.13,85.67 123.67,85.67 123.44,85.91 123.44,86.44 123.19,86.69 122.63,86.69 121.47,87.85 121.47,89.69 v5(121.93,90.16)
  BOTTOM w0.114: U27.J8 121.87,90.16 v5(121.93,90.16)
  BOTTOM w0.127: JDIM1.148 120.55,52.77 120.58,52.8 120.58,53.81 120.26,54.13 120.26,54.4 v3(119.87,54.79)
M_B_DQ42: length 48.6
  IN2 w0.089: 129.27,81.92 129.27,83.09 129.35,83.17 129.35,85.3 129.1,85.56 128.63,85.56 128.33,85.86 128.33,86.32 128.1,86.56 127.63,86.56 127.33,86.86 127.33,87.32 127.1,87.56 126.63,87.56 126.33,87.86 126.33,88.32 126.1,88.56 125.63,88.56 125.33,88.86 125.33,89.32 125.1,89.56 124.63,89.56 124.35,89.84 124.03,90.16 v3(123.93,90.16)
  IN2 w0.133: 129.27,81.92 129.27,73.38 128.61,72.72 128.61,72.44 128.74,72.31 129.14,72.31 129.27,72.18 129.27,71.91 129.14,71.77 128.81,71.77 128.68,71.64 128.68,71.37 128.81,71.23 129.14,71.23 129.27,71.1 129.27,70.83 129.14,70.69 128.19,70.69 128.05,70.56 128.05,70.27 128.19,70.14 129.14,70.14 129.27,70.01 129.27,69.73 129.14,69.6 128.19,69.6 128.05,69.47 128.05,65.92 122.72,60.59 122.28,60.16 122.28,58.07 122.14,57.93 122.14,57.51 v3(122.54,57.11)
  BOTTOM w0.114: U27.G8 123.4,90.19 123.52,90.32 123.77,90.32 v3(123.93,90.16)
  BOTTOM w0.127: JDIM1.157 123.25,57.48 122.88,57.11 v3(122.54,57.11)
M_B_DQ43: length 48.7
  IN2 w0.089: 129.66,84.64 129.66,85.4 129.31,85.75 128.71,85.75 128.52,85.94 128.52,86.4 128.17,86.75 127.71,86.75 127.52,86.94 127.52,87.4 127.17,87.75 126.71,87.75 126.52,87.94 126.52,88.4 126.17,88.75 125.71,88.75 125.52,88.94 125.52,89.4 125.17,89.75 124.71,89.75 124.53,89.93 124.53,90.56 v3(123.93,91.16)
  IN2 w0.133: v3(122.61,55.81) 122.85,55.81 123.02,55.97 123.02,57.98 122.67,58.33 122.67,60 128.44,65.76 128.44,69.08 128.57,69.21 129.53,69.21 129.66,69.35 129.66,84.64
  BOTTOM w0.114: v3(123.93,91.16) 123.87,91.16 U27.G9
  BOTTOM w0.127: v3(122.61,55.81) 123.1,55.81 123.85,56.56 JDIM1.159
M_B_DQ44: length 48.6
  IN2 w0.133: v3(119.9,57.07) 120.36,57.07 120.54,57.25 120.54,60.88 126.24,66.58 126.24,76.56 126.38,76.69 127.15,76.69 127.28,76.82 127.28,77.1 127.15,77.23 126.38,77.23 126.24,77.36 126.24,77.64 126.38,77.77 127.15,77.77 127.28,77.9 127.28,78.18 127.15,78.31 126.38,78.31 126.24,78.44 126.24,78.72 126.38,78.85 127.15,78.85 127.28,78.98 127.28,79.26 127.15,79.39 126.38,79.39 126.24,79.52 126.24,79.8 126.38,79.93 127.15,79.93 127.28,80.06 127.28,82.27 127.06,82.49 126.67,82.49 126.47,82.7 126.47,84.42 126.2,84.69 125.65,84.69 125.4,84.94 125.4,85.49 125.2,85.69 124.65,85.69 124.44,85.91 124.44,86.99 123.98,87.45 123.64,87.45 v3(121.93,89.16)
  BOTTOM w0.114: v3(121.93,89.16) 121.87,89.16 U27.J7
  BOTTOM w0.127: JDIM1.147 120.25,58.62 120.53,58.34 120.53,57.24 120.35,57.07 v3(119.9,57.07)
M_B_DQ45: length 48.5
  IN2 w0.089: 124.84,82.64 124.72,82.64 124.41,82.95 124.41,83.35
  IN2 w0.133: v3(119.85,54.03) 119.43,53.61 119.23,53.61 118.98,53.87 118.98,54.09 119.26,54.37 119.26,54.86 119.08,55.03 119.08,58.16 119.77,58.85 119.77,61.2 125.47,66.9 125.47,82.2 125.02,82.64 124.84,82.64 ; 124.41,83.35 124.41,84 124.42,84.01 124.42,84.33 124.1,84.66 123.65,84.66 123.43,84.87 123.43,85.37 123.13,85.67 122.71,85.67 122.39,85.99 122.39,86.37 120.47,88.3 120.47,90.43 120.66,90.62 121.4,90.62 v3(121.93,91.16)
  BOTTOM w0.114: v3(121.93,91.16) 121.87,91.16 U27.J9
  BOTTOM w0.127: v3(119.85,54.03) 120.3,53.57 120.3,53.06 119.95,52.71 JDIM1.146
M_B_DQ46: length 49.1
  IN2 w0.089: 130.3,86.47 130.14,86.64 129.69,86.64 129.33,87 129.33,87.45 129.12,87.65 128.84,87.65 128.34,88.16 128.34,88.34 128.11,88.57 127.5,88.57 127.33,88.73 127.33,89.34 126.93,89.75 125.74,89.75 125.52,89.97 125.52,91.15 125.01,91.67 124.42,91.67 v3(123.93,92.16)
  IN2 w0.133: v3(123.61,53.16) 123.98,53.54 123.98,54.8 123.65,55.12 123.65,58.39 123.45,58.59 123.45,59.67 123.67,59.9 129.21,65.44 129.21,67.8 130.56,69.15 130.56,86.22 130.3,86.47
  BOTTOM w0.114: v3(123.93,92.16) 123.87,92.16 U27.G10
  BOTTOM w0.127: JDIM1.158 123.55,53.11 v3(123.61,53.16)
M_B_DQ47: length 49.5
  IN2 w0.089: v3(121.9,92) 122.27,91.64 124.03,91.64 124.45,91.22 124.45,90.91 124.81,90.56 125.1,90.56 125.33,90.32 125.33,89.9 125.68,89.56 126.1,89.56 126.41,89.24 126.41,89.1 126.84,88.67 126.98,88.67 127.4,88.25 127.4,88.11 127.95,87.56 128.1,87.56 128.44,87.21 128.44,86.9 128.78,86.56 129.1,86.56 129.48,86.17 129.48,85.99 130.05,85.42 130.05,85.03
  IN2 w0.133: v3(123.55,54.51) 123.35,54.72 123.35,58.11 123.06,58.4 123.06,59.83 123.07,59.84 128.83,65.6 128.83,67.97 130.05,69.19 130.05,85.03
  BOTTOM w0.114: v3(121.9,92) 121.72,92 U27.J10
  BOTTOM w0.127: JDIM1.160 124.15,52.76 124.06,52.85 124.06,54.01 v3(123.55,54.51)
M_B_DQ48: length 48.8
  IN2 w0.133: v3(125.53,55.72) 125,56.26 125,57.91 125.15,58.06 125.15,58.64 132.26,65.75 132.26,70.85 132.4,70.98 132.51,70.98 132.64,71.12 132.64,71.39 132.51,71.52 132.4,71.52 132.26,71.66 132.26,71.93 132.4,72.06 132.51,72.06 132.64,72.2 132.64,72.47 132.51,72.6 132.4,72.6 132.26,72.74 132.26,73.01 132.4,73.14 132.51,73.14 132.64,73.28 132.64,73.55 132.51,73.68 132.4,73.68 132.26,73.81 132.26,74.09 132.4,74.22 132.51,74.22 132.64,74.35 132.64,74.63 132.51,74.76 132.4,74.76 132.26,74.89 132.26,75.17 132.4,75.3 132.51,75.3 132.64,75.43 132.64,75.71 132.51,75.84 132.4,75.84 132.26,75.97 132.26,76.25 132.4,76.38 132.51,76.38 132.64,76.51 132.64,76.79 132.51,76.92 132.4,76.92 132.26,77.05 132.26,77.33 132.4,77.46 132.51,77.46 132.64,77.59 132.64,77.87 132.51,78 132.4,78 132.26,78.13 132.26,78.41 132.4,78.54 132.51,78.54 132.64,78.67 132.64,78.95 132.51,79.08 132.4,79.08 132.26,79.21 132.26,79.49 132.4,79.62 132.51,79.62 132.64,79.75 132.64,80.03 132.51,80.16 132.4,80.16 132.26,80.29 132.26,80.56 132.4,80.7 132.51,80.7 132.64,80.83 132.64,87.11 129.93,89.82 v5(129.93,90.16)
  BOTTOM w0.102: U27.A8 129.46,89.69 v5(129.93,90.16)
  BOTTOM w0.127: v3(125.53,55.72) 125.07,55.72 124.88,55.91 124.88,58.25 125.65,59.02 JDIM1.165
M_B_DQ49: length 49.8
  IN2 w0.089: v3(128.93,90.16) 129.39,89.69 129.39,88.92 129.58,88.73 130.47,88.73 130.77,88.43
  IN2 w0.133: v3(125.51,54.45) 125.2,54.75 125.2,55.42 124.67,55.95 124.67,58.13 124.76,58.22 124.76,58.97 131.87,66.08 131.87,81.06 132.01,81.19 132.12,81.19 132.25,81.33 132.25,81.6 132.12,81.73 132.01,81.73 131.87,81.87 131.87,82.14 132.01,82.27 132.12,82.27 132.25,82.4 132.25,82.68 132.12,82.81 132.01,82.81 131.87,82.94 131.87,83.22 132.01,83.35 132.12,83.35 132.25,83.48 132.25,83.76 132.12,83.89 132.01,83.89 131.87,84.02 131.87,84.3 132.01,84.43 132.12,84.43 132.25,84.56 132.25,84.84 132.12,84.97 132.01,84.97 131.87,85.1 131.87,85.38 132.01,85.51 132.12,85.51 132.25,85.64 132.25,85.92 132.12,86.05 132.01,86.05 131.87,86.18 131.87,87.32 130.77,88.43
  BOTTOM w0.114: v3(128.93,90.16) 128.87,90.16 U27.B8
  BOTTOM w0.127: v3(125.51,54.45) 124.49,55.46 124.49,58.39 125.05,58.95 JDIM1.163
M_B_DQ50: length 48.9
  IN2 w0.089: v3(129.93,91.16) 130.51,91.16 131.28,90.38
  IN2 w0.133: 131.28,90.38 133.99,87.67 133.99,70.56 133.61,70.18 133.61,65.17 126.99,58.54 126.99,56.81 126.39,56.22 126.39,54.43 126.52,54.3 127.42,54.3 127.56,54.15 127.56,53.9 127.41,53.74 126.72,53.74 126.57,53.59 126.57,53.26 126.7,53.14 v3(128.35,53.14)
  BOTTOM w0.114: v3(129.93,91.16) 129.87,91.16 U27.A9
  BOTTOM w0.127: JDIM1.174 v3(128.35,53.14)
M_B_DQ51: length 50.4
  IN2 w0.089: 131.28,90.93 130.65,91.56 129.76,91.56 129.36,91.16 v3(128.93,91.16)
  IN2 w0.133: 131.28,90.93 134.38,87.83 134.38,70.39 134,70.02 134,65.01 133.64,64.65 127.37,58.38 127.37,56.65 127.01,56.28 127.01,55.98 127.13,55.85 127.66,55.85 127.77,55.75 127.77,55.42 127.61,55.27 127.06,55.27 126.91,55.12 126.91,54.83 127.06,54.68 127.58,54.68 127.81,54.45 v3(128.33,54.45)
  BOTTOM w0.114: U27.B9 128.87,91.16 v3(128.93,91.16)
  BOTTOM w0.127: JDIM1.176 128.95,52.69 129.17,52.91 129.17,54.22 128.93,54.45 v3(128.33,54.45)
M_B_DQ52: length 51.1
  IN2 w0.089: 130.68,87.14 130.16,87.65 129.86,87.65 129.41,88.11 129.41,88.33 129.19,88.56 128.55,88.56 128.36,88.75 127.73,88.75 127.53,88.94 127.53,89.53 126.93,90.13 v5(126.93,90.16)
  IN2 w0.133: 130.68,87.14 131.1,86.72 131.1,68.93 129.75,67.58 129.75,65.21 123.99,59.44 123.99,55.46 124.52,54.93 124.52,52.32 124.69,52.14 126.72,52.14 126.85,52.27 126.85,52.57 126.72,52.7 125.66,52.7 125.52,52.84 v3(125.52,53.49)
  BOTTOM w0.114: U27.D8 126.87,90.16 v5(126.93,90.16)
  BOTTOM w0.127: v3(125.52,53.49) 125.52,52.94 125.35,52.78 JDIM1.164
M_B_DQ53: length 51.7
  IN2 w0.089: v3(125.93,90.16) 126.42,90.65 127.09,90.65 127.37,90.37 127.37,90.04 127.7,89.71 128.18,89.71 128.33,89.56 128.33,89.03 128.63,88.73 129.26,88.73 129.44,88.56 130.1,88.56 130.89,87.76
  IN2 w0.133: 130.89,87.76 131.49,87.16 131.49,68.08 131.17,67.76 130.48,67.76 130.32,67.6 130.32,67.36 130.48,67.2 131.2,67.2 131.36,67.04 131.36,66.81 131.2,66.64 130.3,66.64 130.14,66.49 130.14,66.27 130.3,66.11 130.81,66.11 130.97,65.95 130.97,65.73 130.81,65.57 130.27,65.57 130.14,65.44 130.14,65.05 124.37,59.28 124.37,55.65 124.85,55.17 124.85,54.19 v3(125.01,54.03)
  BOTTOM w0.102: U27.E8 125.87,90.16 v3(125.93,90.16)
  BOTTOM w0.127: JDIM1.166 125.95,52.93 126.14,53.11 126.14,53.74 125.85,54.03 v3(125.01,54.03)
M_B_DQ54: length 52.4
  IN2 w0.089: v3(126.93,91.16) 126.67,91.41 126.67,91.63 126.8,91.75 130.86,91.75 131.17,91.45 131.28,91.45
  IN2 w0.133: 131.28,91.45 131.3,91.45 134.77,87.99 134.77,69.86 134.63,69.73 134.52,69.73 134.39,69.59 134.39,69.32 134.52,69.19 134.63,69.19 134.77,69.06 134.77,68.78 134.63,68.65 134.52,68.65 134.39,68.52 134.39,68.24 134.52,68.11 134.63,68.11 134.77,67.98 134.77,67.7 134.63,67.57 134.52,67.57 134.39,67.44 134.39,67.16 134.52,67.03 134.63,67.03 134.77,66.9 134.77,66.62 134.63,66.49 134.52,66.49 134.39,66.36 134.39,66.08 134.52,65.95 134.63,65.95 134.77,65.82 134.77,65.23 127.76,58.22 127.76,56.45 127.92,56.29 128.14,56.29 128.3,56.45 v3(128.3,57.11)
  BOTTOM w0.114: U27.D9 126.87,91.16 v3(126.93,91.16)
  BOTTOM w0.127: JDIM1.175 128.65,58.83 128.86,58.63 128.86,56.97 128.76,56.87 128.43,56.87 128.3,56.99 v3(128.3,57.11)
M_B_DQ55: length 52.4
  IN2 w0.089: v3(125.93,91.16) 125.93,91.59 126.33,91.99 126.33,92.12 126.76,92.56 130.57,92.56 131.14,91.98 131.28,91.98
  IN2 w0.133: 131.28,91.98 131.32,91.98 135.16,88.15 135.16,65.07 128.81,58.72 128.81,56.4 128.33,55.92 v3(128.33,55.77)
  BOTTOM w0.114: U27.E9 125.87,91.16 v3(125.93,91.16)
  BOTTOM w0.127: v3(128.33,55.77) 129.16,56.61 129.16,58.65 129.25,58.74 JDIM1.177
M_B_DQ56: length 56.5
  IN2 w0.089: 131.28,93.84 131.01,93.84 130.3,94.56 128.69,94.56 128.34,94.91 128.34,95.31 128.1,95.56 127.69,95.56 127.33,95.92 127.33,96.32 126.98,96.67 126.42,96.67 v3(125.93,97.16)
  IN2 w0.133: v3(129.66,56.47) 129.66,56.8 130.89,58.03 130.89,58.74 137.27,65.12 137.27,69.4 137.13,69.53 136.6,69.53 136.47,69.67 136.47,69.94 136.6,70.07 137.13,70.07 137.27,70.21 137.27,70.48 137.11,70.63 136.63,70.63 136.47,70.79 136.47,88.69 131.32,93.84 131.28,93.84
  BOTTOM w0.114: v3(125.93,97.16) 125.87,97.16 U27.E15
  BOTTOM w0.127: JDIM1.183 131.05,58.89 130.89,58.73 130.89,57.7 v3(129.66,56.47)
M_B_DQ57: length 55.9
  IN2 w0.089: v3(126.93,97.16) 127.52,96.56 127.52,96 127.76,95.75 128.22,95.75 128.52,95.46 128.53,95.45 128.53,94.99 128.76,94.75 130.61,94.75 130.87,94.49 131.22,94.49 131.28,94.43
  IN2 w0.133: v3(129.66,53.39) 130.09,53.82 130.09,56.67 131.07,57.65 131.45,57.65 131.85,58.05 131.85,59.15 137.69,65 137.69,70.6 136.86,71.43 136.86,88.85 131.28,94.43
  BOTTOM w0.114: U27.D15 126.87,97.16 v3(126.93,97.16)
  BOTTOM w0.127: v3(129.66,53.39) 130.15,52.89 JDIM1.180
M_B_DQ58: length 55.9
  IN2 w0.133: v3(129.93,97.16) 130.14,96.95 131.77,96.95 138.98,89.74 138.98,84.18 139.12,84.04 139.38,84.04 139.51,83.91 139.51,83.64 139.38,83.5 139.12,83.5 138.98,83.37 138.98,83.09 139.11,82.96 139.67,82.96 139.82,82.81 139.82,64.12 134.51,58.81 134.51,56.14 133.65,55.28 v3(133.15,55.28)
  BOTTOM w0.114: U27.A15 129.87,97.16 v3(129.93,97.16)
  BOTTOM w0.127: JDIM1.194 134.35,54.08 v3(133.15,55.28)
M_B_DQ59: length 56.1
  IN2 w0.102: 130.79,97.45 130.21,97.45 130.1,97.56 129.34,97.56 v3(128.93,97.16)
  IN2 w0.133: v3(133.25,53.96) 134.9,55.61 134.9,58.65 140.21,63.95 140.21,83.76 139.37,84.6 139.37,89.9 131.82,97.45 130.79,97.45
  BOTTOM w0.114: U27.B15 128.87,97.16 v3(128.93,97.16)
  BOTTOM w0.127: JDIM1.192 133.75,53.46 v3(133.25,53.96)
M_B_DQ60: length 56.2
  IN2 w0.089: 131.28,92.62 131.12,92.62 130.39,93.34 130.39,93.36 130.19,93.56 127.67,93.56 127.41,93.83 127.41,94.38 127.18,94.61 126.68,94.61 126.47,94.81 126.47,96 126.32,96.16 v3(125.93,96.16)
  IN2 w0.133: v3(129.62,54.84) 129.18,54.4 129.01,54.4 128.86,54.55 128.86,54.93 129.16,55.23 129.16,58.59 129.43,58.87 129.72,58.87 135.69,64.84 135.69,88.37 131.45,92.62 131.28,92.62
  BOTTOM w0.114: U27.E14 125.72,96.01 125.87,96.16 v3(125.93,96.16)
  BOTTOM w0.127: v3(129.62,54.84) 130.75,53.71 JDIM1.182
M_B_DQ61: length 55
  IN2 w0.089: v3(126.93,96.16) 126.93,95.9 127.44,95.4 127.44,94.91 127.72,94.63 128.35,94.63 128.53,94.45 128.53,93.99 128.76,93.75 130.47,93.75 130.99,93.23 131.28,93.23
  IN2 w0.133: 131.28,93.23 131.38,93.23 136.08,88.53 136.08,69.28 136.22,69.15 136.75,69.15 136.88,69.01 136.88,68.74 136.75,68.61 136.22,68.61 136.08,68.47 136.08,68.2 136.22,68.07 136.75,68.07 136.88,67.93 136.88,67.66 136.75,67.53 136.22,67.53 136.08,67.39 136.08,67.12 136.22,66.99 136.75,66.99 136.88,66.85 136.88,66.58 136.75,66.45 136.22,66.45 136.08,66.31 136.08,66.04 136.22,65.91 136.75,65.91 136.88,65.77 136.88,65.5 136.75,65.37 136.22,65.37 136.08,65.23 136.08,64.67 130.48,59.07 130.48,58.17 130.07,57.76 v3(129.66,57.76)
  BOTTOM w0.114: U27.D14 126.87,96.16 v3(126.93,96.16)
  BOTTOM w0.127: v3(129.66,57.76) 130.45,58.56 JDIM1.181
M_B_DQ62: length 55.9
  IN2 w0.133: v3(133.25,57.85) 133.57,57.85 133.74,58.02 133.74,59.13 139.05,64.44 139.05,75.57 138.91,75.7 138.34,75.7 138.21,75.83 138.21,76.11 138.34,76.24 138.91,76.24 139.05,76.37 139.05,76.65 138.91,76.78 138.34,76.78 138.21,76.91 138.21,77.19 138.34,77.32 138.91,77.32 139.05,77.45 139.05,77.73 138.91,77.86 138.34,77.86 138.21,77.99 138.21,78.27 138.34,78.4 138.91,78.4 139.05,78.53 139.05,78.81 138.91,78.94 138.34,78.94 138.21,79.07 138.21,79.36 138.34,79.49 138.91,79.49 139.05,79.63 139.05,79.9 138.91,80.03 138.34,80.03 138.21,80.16 138.21,80.43 138.34,80.56 138.91,80.56 139.05,80.69 139.05,80.97 138.91,81.1 138.34,81.1 138.21,81.23 138.21,89.42 131.47,96.16 v3(129.93,96.16)
  BOTTOM w0.114: U27.A14 129.87,96.16 v3(129.93,96.16)
  BOTTOM w0.127: JDIM1.191 133.45,58.84 133.68,58.6 133.68,58.03 133.5,57.85 v3(133.25,57.85)
M_B_DQ63: length 55.7
  IN2 w0.102: 131.18,96.56 129.34,96.56 v3(128.93,96.16)
  IN2 w0.133: v3(133.25,56.57) 133.67,56.15 133.96,56.15 134.13,56.32 134.13,58.97 139.43,64.28 139.43,81.35 139.3,81.49 138.73,81.49 138.6,81.62 138.6,81.89 138.73,82.03 139.3,82.03 139.43,82.16 139.43,82.43 139.3,82.57 138.76,82.57 138.6,82.74 138.6,89.58 131.61,96.56 131.18,96.56
  BOTTOM w0.114: U27.B14 128.87,96.16 v3(128.93,96.16)
  BOTTOM w0.127: JDIM1.193 134.05,57.37 v3(133.25,56.57)
M_B_DQSN0: length 69.9
  IN2 w0.089: 92.41,95.44 92.42,95.46 92.49,95.46 92.61,95.58 92.74,95.71 92.74,96.08 93.41,96.75 94.09,96.75 94.34,97 94.34,97.39 94.71,97.75 95.09,97.75 95.34,98 95.34,98.57 v3(95.93,99.15)
  IN2 w0.133: 92.41,95.44 91.35,94.39 82.92,94.39 71.95,83.41 71.95,75.95 72.24,75.65 73.05,75.65 73.18,75.52 73.18,75.25 73.05,75.11 72.23,75.11 71.95,74.83 71.95,74.28 72.29,73.94 72.92,73.94 73.11,73.74 73.11,73.54 72.63,73.05 72.63,72.57 74.27,70.94 74.27,59.75 75,59.01 75,54.51 75.28,54.23 75.69,54.23 75.8,54.12 v3(75.8,53.77)
  BOTTOM w0.114: v3(95.93,99.15) 95.93,99.22 U27.AP18
  BOTTOM w0.127: v3(75.8,53.77) 75.8,54.06 75.95,54.2 76.34,54.2 76.46,54.08 76.46,53.44 76.92,52.99 76.92,52.81 76.75,52.64 JDIM1.10
M_B_DQSN1: length 59.3
  IN2 w0.089: v3(95.93,92.16) 96.26,92.16 96.33,92.23 96.33,92.56 96.23,92.66 95.68,92.66 95.52,92.49 95.52,91.93 95.16,91.56 94.77,91.56 94.52,91.31 94.52,90.93 94.17,90.57 93.6,90.57 92.71,89.69 92.46,89.69 92.42,89.64 92.41,89.64
  IN2 w0.133: 92.41,89.64 91.15,89.64 88.35,86.84 87.58,86.84 87.29,87.13 87.29,87.6 87.16,87.73 86.88,87.73 86.75,87.6 86.75,87.13 86.46,86.84 85.96,86.84 85.67,87.13 85.67,87.6 85.53,87.73 85.26,87.73 84.36,86.84 81.78,86.84 77.75,82.81 77.75,76.27 79.84,74.19 79.84,67.52 80.45,66.9 80.45,56.96 80.56,56.86 80.8,56.86 80.95,57.02 v3(80.95,57.43)
  BOTTOM w0.114: U27.AP11 96.01,92.69 95.93,92.61 v3(95.93,92.16)
  BOTTOM w0.127: JDIM1.27 81.85,58.92 82.02,58.76 82.02,58.59 81.61,58.18 81.61,57.16 81.46,57.02 81.06,57.02 80.95,57.12 v3(80.95,57.43)
M_B_DQSN2: length 42.9
  IN2 w0.089: v3(95.93,86.16) 96.22,86.45 96.22,86.65 96.12,86.75 95.78,86.75 95.51,86.48 95.51,84.92 95.16,84.57 94.76,84.57 94.52,84.33 94.52,83.89 94.15,83.53 92.9,83.53 92.62,83.24 92.62,83.18 92.6,83.16
  IN2 w0.133: v3(86.03,56.78) 86.03,56.59 85.91,56.46 85.58,56.46 85.42,56.61 85.42,57.91 85.65,58.14 85.65,72.21 86.68,73.23 86.68,75.8 88.88,78 88.88,79.44 92.6,83.16
  BOTTOM w0.114: U27.AP5 95.93,86.22 v3(95.93,86.16)
  BOTTOM w0.127: JDIM1.45 87.25,58.88 87.42,58.72 87.42,58.61 86.83,58.01 86.83,56.58 86.67,56.43 86.14,56.43 86.03,56.53 v3(86.03,56.78)
M_B_DQSN3: length 41.4
  IN2 w0.089: 96,79.71 96,79.77 96.39,80.16 96.59,80.16 97.2,80.76 98.36,80.76 99.51,81.92 99.51,83.3 99.77,83.56 100.16,83.56 100.45,83.85 100.45,84.08 100.52,84.16 v3(100.93,84.16)
  IN2 w0.133: v3(90.61,54.86) 90.61,55.21 90.76,55.36 91.09,55.36 91.43,55.71 91.43,58.83 91.76,59.16 91.76,74.91 93.09,76.25 93.09,76.8 96,79.71
  BOTTOM w0.102: v3(100.93,84.16) 100.93,84.22 U27.AJ3
  BOTTOM w0.127: JDIM1.62 92.35,52.62 92.52,52.79 92.52,52.91 92.38,53.04 91.92,53.04 91.28,53.68 91.28,54.44 91.54,54.7 91.54,55 91.29,55.25 90.74,55.25 90.61,55.11 v3(90.61,54.86)
M_B_DQSN4: length 41.1
  IN2 w0.089: v3(119.93,84.16) 119.78,84.3 119.5,84.3 119.33,84.13 119.33,83.87 119.46,83.73 121.17,83.73 121.53,83.37 121.53,81.97 122.12,81.37 122.12,81.19 122.17,81.14 122.17,81.12
  IN2 w0.133: 122.17,81.12 122.17,80.29 123.23,79.23 123.23,67.83 117.53,62.13 117.53,59.78 115.75,58 115.75,56.16 115.94,55.97 116.1,55.97 116.29,56.16 v3(116.29,56.56)
  BOTTOM w0.114: v3(119.93,84.16) U27.L3
  BOTTOM w0.127: JDIM1.135 116.65,58.75 116.82,58.58 116.82,56.18 116.68,56.04 116.43,56.04 116.29,56.18 v3(116.29,56.56)
M_B_DQSN5: length 49.9
  IN2 w0.089: v3(122.93,91.16) 123.52,90.56 123.52,89.94 123.71,89.75 124.17,89.75 124.53,89.39 124.53,88.94 124.72,88.75 125.17,88.75 125.52,88.4 125.52,87.97 125.75,87.75 126.17,87.75 126.52,87.4 126.52,86.95 126.72,86.75 127.17,86.75 127.53,86.39 127.53,85.94 127.72,85.75 128.17,85.75 128.52,85.4 128.52,83.96 128.68,83.79 128.68,81.96 128.73,81.92 128.73,81.89
  IN2 w0.133: v3(120.81,54.88) 120.81,55.35 120.97,55.5 121.25,55.5 121.74,56 121.74,60.38 127.51,66.15 127.51,71.04 128.07,71.6 128.07,72.22 127.44,72.85 127.44,73.12 127.58,73.26 128.39,73.26 128.73,73.6 128.73,81.89
  BOTTOM w0.114: v3(122.93,91.16) 122.87,91.16 U27.H9
  BOTTOM w0.127: JDIM1.152 121.75,52.7 121.92,52.87 121.92,54.59 121.2,55.31 120.97,55.31 120.81,55.14 v3(120.81,54.88)
M_B_DQSN6: length 50.1
  IN2 w0.089: 130.95,89.56 130.94,89.57 130.94,89.64 130.71,89.86 130.71,90.19 130.34,90.56 128.55,90.56 128.36,90.75 127.73,90.75 127.65,90.68 127.65,90.43 v3(127.93,90.16)
  IN2 w0.133: v3(125.59,57.68) 125.59,57.22 125.72,57.1 126.04,57.1 126.17,57.23 126.17,58.88 132.8,65.51 132.8,70.51 133.18,70.89 133.18,87.33 130.95,89.56
  BOTTOM w0.114: U27.C8 127.87,90.16 v3(127.93,90.16)
  BOTTOM w0.127: JDIM1.169 126.85,59.01 127.19,58.68 127.19,55.92 127.02,55.76 126.73,55.76 126.6,55.89 126.6,56.84 126.32,57.12 125.73,57.12 125.59,57.26 v3(125.59,57.68)
M_B_DQSN7: length 58.5
  IN2 w0.089: 131.28,95.05 131.26,95.05 131.21,95.1 130.92,95.1 130.45,95.57 128.68,95.57 128.35,95.9 128.35,96.36 128.25,96.46 127.99,96.46 127.93,96.4 v3(127.93,96.16)
  IN2 w0.133: v3(131.4,54.08) 131.4,54.61 130.77,55.24 130.63,55.38 130.63,56.33 131.36,57.06 131.95,57.06 132.39,57.5 132.39,58.93 138.23,64.77 138.23,70.82 137.4,71.66 137.4,72.25 137.69,72.55 138.1,72.55 138.23,72.68 138.23,72.95 138.1,73.09 137.69,73.09 137.4,73.38 137.4,73.88 137.98,74.47 137.98,74.91 137.4,75.5 137.4,89.08 131.42,95.05 131.28,95.05
  BOTTOM w0.114: U27.C14 127.87,96.16 v3(127.93,96.16)
  BOTTOM w0.127: JDIM1.186 131.95,52.85 132.12,53.02 132.12,54.37 131.96,54.53 131.53,54.53 131.4,54.4 v3(131.4,54.08)
M_B_DQSP0: length 70
  IN2 w0.089: 92.6,95.25 92.62,95.27 92.62,95.33 92.92,95.64 92.92,96 93.48,96.57 94.16,96.57 94.52,96.93 94.52,97.31 94.78,97.57 95.16,97.57 95.52,97.93 95.52,98.49 95.65,98.62 95.84,98.62 95.93,98.53 v3(95.93,98.15)
  IN2 w0.133: v3(75.8,55.05) 75.8,55.05 75.8,54.65 75.64,54.5 75.39,54.5 75.27,54.62 75.27,59.13 74.54,59.86 74.54,71.05 72.9,72.69 72.9,72.94 73.38,73.42 73.38,73.86 73.03,74.21 72.4,74.21 72.22,74.39 72.22,74.72 72.34,74.84 73.16,74.84 73.45,75.13 73.45,75.63 73.16,75.93 72.35,75.93 72.22,76.06 72.22,83.3 83.03,94.12 91.46,94.12 92.6,95.25
  BOTTOM w0.114: U27.AP17 95.93,98.22 v3(95.93,98.15)
  BOTTOM w0.127: v3(75.8,55.05) 75.8,54.65 75.98,54.47 76.45,54.47 76.73,54.19 76.73,53.55 77.19,53.1 77.19,52.77 77.35,52.6 JDIM1.12
M_B_DQSP1: length 59.4
  IN2 w0.089: 92.41,89.91 92.42,89.91 92.46,89.86 92.64,89.86 93.53,90.75 94.09,90.75 94.34,91 94.34,91.39 94.7,91.74 95.08,91.74 95.34,92 95.34,92.57 v3(95.93,93.16)
  IN2 w0.133: 92.41,89.91 91.04,89.91 88.24,87.11 87.7,87.11 87.56,87.24 87.56,87.71 87.27,88 86.77,88 86.48,87.71 86.48,87.24 86.35,87.11 86.07,87.11 85.94,87.24 85.94,87.71 85.65,88 85.15,88 84.25,87.11 81.66,87.11 77.48,82.93 77.48,76.16 79.56,74.07 79.56,67.41 80.18,66.79 80.18,56.85 80.44,56.59 80.75,56.59 80.95,56.38 v3(80.95,56.13)
  BOTTOM w0.114: U27.AP12 95.93,93.22 v3(95.93,93.16)
  BOTTOM w0.127: JDIM1.29 82.45,58.9 82.29,58.73 82.29,58.48 81.87,58.07 81.87,57.05 81.57,56.75 81.15,56.75 80.95,56.56 v3(80.95,56.13)
M_B_DQSP2: length 42.9
  IN2 w0.089: 92.41,83.35 92.42,83.37 92.49,83.37 92.82,83.7 94.08,83.7 94.34,83.96 94.34,84.4 94.68,84.75 95.09,84.75 95.33,84.99 95.33,86.56 v5(95.93,87.16)
  IN2 w0.133: 92.41,83.35 88.61,79.55 88.61,78.11 86.41,75.91 86.41,73.35 85.38,72.32 85.38,58.25 85.15,58.02 85.15,56.5 85.47,56.19 85.87,56.19 v3(86.03,56.02)
  BOTTOM w0.114: U27.AP6 95.93,87.22 v5(95.93,87.16)
  BOTTOM w0.127: JDIM1.47 87.85,58.94 87.69,58.77 87.69,58.5 87.09,57.9 87.09,56.47 86.78,56.16 86.18,56.16 v3(86.03,56.02)
M_B_DQSP3: length 41.5
  IN2 w0.089: 95.81,79.9 95.82,79.92 95.89,79.92 96.32,80.34 96.52,80.34 97.12,80.94 98.28,80.94 99.33,81.99 99.33,83.37 99.7,83.74 100.09,83.74 100.27,83.92 100.27,84.07 100.19,84.16 v3(99.93,84.16)
  IN2 w0.133: 95.81,79.9 95.8,79.89 92.82,76.92 92.82,76.36 91.49,75.03 91.49,59.27 91.16,58.94 91.16,55.82 90.97,55.64 90.78,55.64 90.61,55.81 v3(90.61,56.16)
  BOTTOM w0.102: v3(99.93,84.16) 99.93,84.22 U27.AK3
  BOTTOM w0.127: v3(90.61,56.16) 90.61,55.65 90.74,55.51 91.4,55.51 91.8,55.11 91.8,54.59 91.54,54.33 91.54,53.79 92.03,53.31 92.49,53.31 92.79,53.02 92.79,52.86 92.95,52.69 JDIM1.64
M_B_DQSP4: length 41.2
  IN2 w0.089: 121.9,81.12 121.9,81.14 121.95,81.19 121.95,81.3 121.35,81.89 121.35,83.3 121.1,83.56 119.39,83.56 119.15,83.79 119.15,83.93 v3(118.93,84.16)
  IN2 w0.133: 121.9,81.12 121.9,80.18 122.95,79.12 122.95,67.94 117.25,62.24 117.25,59.89 115.48,58.12 115.48,56.04 115.82,55.7 116.08,55.7 116.29,55.5 v3(116.29,55.27)
  BOTTOM w0.114: v3(118.93,84.16) U27.M3
  BOTTOM w0.127: JDIM1.137 117.25,58.75 117.09,58.58 117.09,56.07 116.79,55.78 116.44,55.78 116.29,55.62 v3(116.29,55.27)
M_B_DQSP5: length 49.9
  IN2 w0.089: v3(122.93,90.16) 122.93,90.16 122.93,90.63 123.02,90.72 123.11,90.72 123.34,90.49 123.34,89.87 123.64,89.58 124.09,89.58 124.35,89.32 124.35,88.86 124.65,88.57 125.1,88.57 125.34,88.33 125.34,87.9 125.67,87.57 126.1,87.57 126.34,87.33 126.34,86.87 126.65,86.57 127.1,86.57 127.35,86.32 127.35,85.86 127.65,85.57 128.1,85.57 128.34,85.33 128.34,83.88 128.51,83.72 128.51,81.96 128.46,81.92 128.46,81.89
  IN2 w0.133: 128.46,81.89 128.46,73.72 128.27,73.53 127.46,73.53 127.17,73.24 127.17,72.74 127.8,72.11 127.8,71.71 127.24,71.15 127.24,66.26 121.47,60.49 121.47,56.11 121.14,55.78 120.96,55.78 120.81,55.92 v3(120.81,56.16)
  BOTTOM w0.114: U27.H8 122.87,90.16 v3(122.93,90.16)
  BOTTOM w0.127: v3(120.81,56.16) 120.81,55.72 120.96,55.57 121.31,55.57 122.19,54.7 122.19,52.89 122.35,52.73 JDIM1.154
M_B_DQSP6: length 50.1
  IN2 w0.089: v3(127.93,91.16) 128.15,90.93 128.43,90.93 128.63,90.74 130.42,90.74 130.89,90.26 130.89,89.94 131.06,89.76 131.13,89.76 131.15,89.75
  IN2 w0.133: v3(125.59,56.38) 125.59,56.61 125.8,56.82 126.15,56.82 126.45,57.12 126.45,58.77 133.07,65.4 133.07,70.4 133.45,70.78 133.45,87.44 131.15,89.75
  BOTTOM w0.114: v3(127.93,91.16) 127.87,91.16 U27.C9
  BOTTOM w0.127: JDIM1.171 127.45,55.81 127.13,55.49 126.62,55.49 126.33,55.78 126.33,56.73 126.21,56.85 125.7,56.85 125.59,56.74 v3(125.59,56.38)
M_B_DQSP7: length 58.5
  IN2 w0.089: v3(127.93,97.16) 127.93,96.76 128.05,96.64 128.32,96.64 128.53,96.43 128.53,95.98 128.76,95.75 130.52,95.75 130.99,95.28 131.21,95.28 131.26,95.33 131.28,95.33
  IN2 w0.133: 131.28,95.33 131.53,95.33 137.67,89.19 137.67,75.61 138.26,75.02 138.26,74.35 137.67,73.77 137.67,73.49 137.8,73.36 138.21,73.36 138.51,73.07 138.51,72.57 138.21,72.27 137.8,72.27 137.67,72.14 137.67,71.77 138.51,70.94 138.51,64.66 132.66,58.82 132.66,57.39 132.07,56.79 131.47,56.79 130.9,56.22 130.9,55.49 131.02,55.37 v3(131.4,55.37)
  BOTTOM w0.114: v3(127.93,97.16) 127.87,97.16 U27.C15
  BOTTOM w0.127: v3(131.4,55.37) 131.4,54.94 131.54,54.8 132.07,54.8 132.39,54.48 132.39,53.02 132.55,52.85 JDIM1.188
M_B_ODT0: length 48.6
  IN2 w0.216: v3(110.8,53.41) 110.8,51.91 110.6,51.71 110.15,51.71 109.95,51.91 109.95,53.65 111.06,54.77 112.26,54.77 112.6,55.11 112.6,59.67 114.04,61.11 114.04,64.85 119.46,70.27 119.46,70.55 119.33,70.68 118.68,70.68 118.5,70.87 118.5,71.13 118.68,71.32 119.43,71.32 119.64,71.52 119.64,71.77 119.45,71.95 118.68,71.95 118.5,72.13 118.5,72.39 118.68,72.57 119.45,72.57 119.64,72.76 119.64,78.01 119.45,78.19 118.76,78.19 118.48,78.47 118.48,80.02 117,81.5 117,84.43 116.3,85.13 v3(115.92,85.13)
  BOTTOM w0.178: v3(115.92,85.13) 115.92,85.16 U27.R4
  BOTTOM w0.191: JDIM1.116 110.95,52.95 110.8,53.1 v3(110.8,53.41)
M_B_ODT1: length 48.1
  IN2 w0.216: v3(115.93,84.16) 116.22,84.45 116.41,84.45 116.54,84.32 116.54,81.41 117.86,80.09 117.86,77.75 118.04,77.57 118.83,77.57 119.01,77.39 119.01,77.13 118.83,76.95 118.04,76.95 117.86,76.77 117.86,76.51 118.04,76.33 118.83,76.33 119.01,76.14 119.01,75.89 118.83,75.7 118.04,75.7 117.86,75.52 117.86,75.26 118.04,75.08 118.83,75.08 119.01,74.9 119.01,74.64 118.83,74.46 118.04,74.46 117.86,74.28 117.86,74.02 118.04,73.84 118.83,73.84 119.01,73.65 119.01,73.4 118.83,73.21 118.04,73.21 117.86,73.03 117.86,69.55 113.31,65.01 113.31,61.27 111.82,59.77 111.82,57.32 112.09,57.05 112.09,55.67 111.85,55.42 v3(111.57,55.42)
  BOTTOM w0.178: v3(115.93,84.16) U27.R3
  BOTTOM w0.191: JDIM1.120 112.15,54.51 112.42,54.78 113.31,54.78 113.49,54.96 113.49,55.26 113.33,55.42 v3(111.57,55.42)
M_B_RAS#: length 49.2
  IN2 w0.089: 113.6,82.43 113.62,82.44 113.62,83.79 113.52,83.89 113.52,84.39 113.89,84.75 114.1,84.75 114.33,84.99 114.33,85.39 114.68,85.75 115.15,85.75 115.28,85.88 115.34,85.94 115.34,86.4 115.72,86.78 115.72,86.95 v3(115.93,87.16)
  IN2 w0.216: 113.6,82.43 113.6,80.96 114.67,79.89 114.67,72.12 109.42,66.87 109.42,61.14 108.96,60.68 108.96,55.82 107.83,54.68 107.83,53.03 107.64,52.85 107.38,52.85 107.2,53.03 v3(107.2,54.28)
  BOTTOM w0.178: v3(115.93,87.16) U27.R6
  BOTTOM w0.191: v3(107.2,54.28) 107.92,54.28 108.44,53.76 108.77,53.76 108.94,53.94 108.94,55.1 109.11,55.26 109.44,55.26 109.61,55.1 109.61,53.56 109.15,53.1 JDIM1.110
M_B_WE#: length 51.5
  IN2 w0.089: v3(116.93,87.16) 117.33,87.56 118.3,87.56 118.53,87.78 118.53,89.59 118.64,89.7 119.65,89.7 119.74,89.61 119.74,89.43 119.65,89.35 119.42,89.35 119.33,89.26 119.33,89.08 119.42,88.99 119.65,88.99 119.74,88.9 119.74,88.72 119.65,88.63 119.43,88.63 119.33,88.53 119.33,86.99 118.97,86.63 117.76,86.63 117.35,86.23 117.35,85.92 117.05,85.62 116.34,85.62 116.28,85.55 115.76,85.55 115.52,85.31 115.52,83.53 115.37,83.38 115.37,81.93
  IN2 w0.216: 115.37,81.93 115.37,81.27 116.38,80.26 116.38,71.41 111.14,66.16 111.14,60.43 110.68,59.97 v3(110.68,58.22)
  BOTTOM w0.178: v3(116.93,87.16) U27.P6
  BOTTOM w0.191: v3(110.68,58.22) 110.62,58.22 109.68,57.28 109.68,56.13 109.5,55.95 109.15,55.95 108.97,56.13 108.97,57.43 110.05,58.51 JDIM1.113
MAIN_ONG: length 190.8
  TOP w0.127: PQ31.2 PQ28.2 32.95,57.09 31.65,55.8 29.67,55.8 29.24,56.23 PQ32.2 28.17,57.09 26.82,55.74 PQ30.3 27.97,54.78 29.24,53.51 PQ33.2 28.09,51.76 PR150.1 PR145.2 29.24,51.6 v3(29.29,51.66) ; 80.8,71.42 80.8,70.95 82.14,69.61 85.65,69.61 v3(86.16,70.12) ; Q33.2 109.32,71.97 111.22,71.97 v3(111.56,72.3)
  IN2 w0.133: v3(70.46,28.07) 70.04,28.07 65.84,23.87 52.08,23.87 45.9,30.05 45.9,30.31 40.62,35.59 40.62,37.28 36.53,41.37 36.53,42.74 34.27,45 33.43,45 29.29,49.14 v3(29.29,51.66)
  BOTTOM w0.127: v3(111.56,72.3) 111.56,72.29 109.95,70.68 99.29,70.68 98.73,70.12 v3(86.16,70.12) 85.71,70.12 85.02,70.81 85.02,72.87 83.72,74.17 81.23,74.17 78.57,76.83 78.57,77.26 76.41,79.42 73.18,79.42 72.17,78.41 72.17,69.53 72.57,69.13 72.57,67.91 70.44,65.78 70.44,57.42 65.81,52.79 65.81,40.59 69.19,37.2 69.19,29.34 v3(70.46,28.07)
MAIND: length 390.9
  TOP w0.127: Q31.4 98.7,76.56 98.61,76.65 97.65,76.65 C217.1 97.62,75.06 Q32.2 97.44,72.98 v3(97.73,72.69) ; v3(105.34,137.99) 106.02,138.68 111.03,138.68 v3(111.51,138.19) ; v3(179.6,116.41) 180.56,116.41 181.13,115.84 Q14.2 ; v3(58.83,44.9) 61.07,47.14 61.07,55.8 59.58,57.29 59.58,58.96 59.21,59.33 57.7,59.33 57.52,59.51 PQ15.4 57.52,59.53 57.9,59.91 58.58,59.91 59.88,61.22 59.88,67.29 v2(62.72,70.12) 63.86,71.27 v3(63.86,74.75) ; v3(40.21,54.78) 39.27,54.78 35.77,51.28 35.77,49.88 35.41,49.52 v3(34.57,49.52) 32.97,49.52 32.44,50.06 32.44,50.46 32.02,50.88 PR149.2 PC105.2 30.25,51 PQ33.3
  IN1 w0.133: v3(34.57,49.52) 35.17,50.12 35.17,51.26 34.15,52.27 34.15,62.24 34.98,63.06 34.98,64.66 35.39,65.07 35.39,71.61 36.21,72.43 36.21,80.82 37.11,81.72 37.11,84.42 34.95,86.58 34.95,98.3 35.28,98.63 35.82,98.63 36.59,99.4 36.59,100 37.88,101.3 37.88,101.43 38.32,101.87 39.83,101.87 44.56,106.6 58.98,106.6 62.06,103.52 67.89,103.52 68.41,104.05 68.41,108.61 80.04,120.24 85.09,120.24 102.85,137.99 v3(105.34,137.99) ; v3(83.09,97.25) 82.53,97.25 67.87,82.59 67.87,78.75 v3(63.86,74.75) ; v3(111.51,138.19) 111.51,137.94 115.93,133.52 128.6,133.52 131.36,136.28 163.88,136.28 163.93,136.23 163.97,136.23 164.02,136.19 164.04,136.19 165.26,134.96 165.26,134.94 165.26,134.72 165.26,134.72 165.26,131.74 166.17,130.83 v3(166.53,130.83) 167.47,129.89 167.75,129.89 168.21,129.43 168.71,128.93 169.95,128.93 171.17,127.71 171.17,126.43 173.25,124.35 173.25,120.67 173.67,120.25 173.67,118.22 173.94,117.95 174.54,117.95 175.43,117.06 177.51,117.06 178.16,116.41 v3(179.6,116.41)
  IN2 w0.133: v3(40.21,54.78) 40.21,51.43 39.63,50.84 39.63,48.56 40.39,47.8 42.45,47.8 42.45,47.81 42.46,47.81 45.73,44.54 49,44.54 49.76,45.31 58.42,45.31 v3(58.83,44.9)
  BOTTOM w0.127: 59.97,44.9 v3(58.83,44.9) ; v3(166.53,130.83) 167.91,129.44 PQ24.4 ; v3(97.73,72.69) 89.85,80.57 89.85,81.82 83.21,88.46 83.21,97.13 v3(83.09,97.25)
MAINON: length 330.3
  TOP w0.127: PQ30.2 26.16,51.94 26.7,51.41 PR152.1 26.15,50.55 26.15,49.13 v2(27.41,47.87) 27.42,47.87 29.8,45.48 32.01,45.48 32.7,46.18 37.95,46.18 v3(38.72,45.41) ; v3(175.83,49.43) 176.19,49.43 177,50.24 178,50.24 181.57,53.81 181.57,54.3 182,54.73 U13.80 184.8,54.73 184.87,54.66 R304.1
  IN1 w0.133: v3(175.83,49.43) 175.35,48.95 174.95,48.95 174.72,49.18 174.72,49.54 174.08,50.17 167.41,50.17 165.07,47.84 164.04,47.84 163.69,47.49 163.69,47.36 162.98,46.66 161.14,46.66 160.77,47.02 155.53,47.02 154.15,45.64 151.42,45.64 146.05,40.27 v3(146.05,38.92) 146.05,37.35 137.35,28.64 84.38,28.64 75.8,20.06 v3(61.93,20.06) 52.74,20.06 48.58,24.22 48.58,28.8 47.89,29.49 47.89,29.96 41.65,36.2 41.65,37.04 38.41,40.27 38.41,41.1 38.76,41.45 38.76,45.36 v3(38.72,45.41)
  BOTTOM w0.127: v3(61.93,20.06) 59.75,22.24 59.75,25.7 57.84,27.6 PR77.2 ; v3(146.05,38.92) 146.05,40.2 149.23,43.37 149.23,53.56 148.02,54.76 148.02,56.85 134.79,70.09 134.79,107.39 137.57,110.17 137.57,110.81 143.16,116.4 143.16,119.83 146.02,122.69 146.02,125.38 146.51,125.87 146.51,131.2 156.98,141.67 PR139.1
MBCLK: length 201.9
  TOP w0.127: U13.110 176.43,63.71 176.36,63.78 176.36,63.94 176.49,64.08 176.94,64.08 177.39,64.53 177.39,64.77 R332.1 177.42,65.89 177.42,67.34 177.62,67.54 177.62,69.28 v3(177.67,69.33) ; PU2.4 190.79,189.72 190.56,189.96 190.56,191.13 189.54,192.14 187.79,192.14 187.6,191.95 187.6,190.22 186.17,188.79 184.41,188.79 v3(183.82,189.38) 183.62,189.58 183.62,189.8 PR39.2
  IN1 w0.133: v3(183.82,189.38) 183.82,189.53 184.39,190.09 187.57,190.09 188.26,189.41 190.21,189.41 190.93,188.69 190.93,183.78 194.24,180.47 194.24,177.65 194.25,177.65 194.25,177.05 194.24,177.05 194.24,175.37 194.64,174.97 194.64,173.01 196.2,171.46 196.2,168.79 196.51,168.48 196.51,140.74 195.46,139.69 195.46,128.28 194.55,127.38 194.55,126.95 194.55,124.66 191.15,121.26 190.86,121.26 189.62,120.01 189.62,119.58 190.79,118.41 190.79,115.18 195.18,110.79 195.18,96.18 193.73,94.74 193.73,90.55 188.92,85.73 188.22,85.03 186.47,85.03 185.85,84.41 185.85,84.41 182.83,81.39 182.83,81.39 182.5,81.07 181.82,81.07 181.46,80.71 181.46,79.71 182.06,79.11 182.06,75 177.42,70.37 177.42,69.58 v3(177.67,69.33)
  IN2 w0.133: v3(154.54,189.93) 154.77,190.16 155.15,190.16 155.53,190.54 155.53,190.88 155.85,191.2 165.62,191.2 166.89,189.93 183.55,189.93 183.82,189.65 v3(183.82,189.38)
  BOTTOM w0.127: PR21.1 154.45,186.27 154.39,186.2 154,186.2 153.78,186.43 153.78,188.44 153.57,188.64 153.57,189.63 154.14,190.19 154.28,190.19 v3(154.54,189.93)
MBDATA: length 197
  TOP w0.127: v3(176.91,69.33) 176.91,69.31 177.37,68.85 177.37,67.64 177.17,67.44 177.17,65.94 R340.1 177.17,64.75 177.17,64.63 176.85,64.31 176.4,64.31 176.13,64.04 176.13,63.81 176.03,63.71 U13.111 ; PU2.6 190.42,191.62 189.65,192.4 187.69,192.4 187.34,192.05 187.34,190.32 187.2,190.18 PR38.2 186.19,189.73 v3(186.19,189.55)
  IN1 w0.133: v3(186.19,189.55) 186.48,189.83 187.47,189.83 188.15,189.15 190.1,189.15 190.67,188.58 190.67,183.68 193.98,180.36 193.98,177.54 193.99,177.54 193.99,177.16 193.98,177.16 193.98,175.27 194.38,174.87 194.38,172.91 195.94,171.35 195.94,168.68 196.24,168.37 196.24,140.85 195.2,139.8 195.2,128.39 194.29,127.49 194.29,126.85 194.29,124.77 191.04,121.52 190.75,121.52 189.35,120.12 189.35,119.48 190.53,118.3 190.53,115.07 194.92,110.68 194.92,96.29 193.47,94.84 193.47,90.66 188.81,85.99 188.11,85.29 186.36,85.29 185.59,84.52 185.59,84.52 182.72,81.65 182.72,81.65 182.4,81.33 181.71,81.33 181.2,80.82 181.2,79.6 181.8,79 181.8,75.11 177.16,70.47 177.16,69.58 v3(176.91,69.33)
  IN2 w0.133: v3(154.54,190.7) 154.81,190.42 155.05,190.42 155.27,190.65 155.27,190.99 155.74,191.46 165.73,191.46 167,190.19 185.49,190.19 186.13,189.55 v3(186.19,189.55)
  BOTTOM w0.127: v3(154.54,190.7) 154.28,190.44 154.03,190.44 153.32,189.73 153.32,188.54 153.52,188.33 153.52,186.32 153.9,185.95 154.28,185.95 154.45,185.78 PR19.1
