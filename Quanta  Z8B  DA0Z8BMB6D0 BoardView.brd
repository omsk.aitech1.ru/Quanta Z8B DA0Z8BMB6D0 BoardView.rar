# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VMA_DQ12: length 52.2
  TOP w0.127: VRAM1.H3 119.82,168.74 119.84,168.73 120.12,168.73 120.42,169.02 v3(120.42,169.86)
  IN1 w0.102: v3(120.42,169.86) 119.73,169.86 119.44,169.57 118.75,169.57
  IN1 w0.165: v3(147.93,167.84) 149.31,169.22 149.31,172.06 144.92,176.45 142.51,176.45 141.29,177.67 126.62,177.67 125.9,178.39 121.28,178.39 116.39,173.5 116.39,172.72 116.79,172.32 116.79,170.18 117.23,169.74 118.58,169.74 118.75,169.57
  BOTTOM w0.152: U19.C13 v3(147.93,167.84)
VMA_DQ13: length 48.7
  TOP w0.152: VRAM1.H7 v3(122.35,169.14)
  IN1 w0.165: v3(122.35,169.14) 121.73,169.14 121.52,169.36 121.52,170.32 121.7,170.5 121.7,171.32 121.47,171.54 121.47,174.99 122.7,176.22 124.96,176.22 126.76,174.42 140.24,174.42 140.6,174.06 140.97,174.06 141.23,174.32 141.52,174.32 141.71,174.13 141.71,173.88 141.38,173.55 141.38,173.29 141.56,173.1 141.82,173.1 142.62,173.9 142.9,173.9 143.09,173.7 143.09,173.43 142.3,172.63 142.3,172.36 142.49,172.17 142.77,172.17 143.48,172.88 143.75,172.88 143.95,172.69 143.95,172.41 143.24,171.7 143.24,171.43 143.43,171.23 143.7,171.23 144.42,171.95 144.68,171.95 144.87,171.76 144.87,171.5 144.14,170.78 144.14,170.52 144.32,170.34 144.58,170.34 146.12,171.87 146.38,171.87 v3(147.11,171.14)
  BOTTOM w0.152: v3(147.11,171.14) 147.11,170.03 147.93,169.21 147.93,168.64 U19.B13
VMA_DQ14: length 52.5
  TOP w0.152: VRAM1.F2 118.79,170.34 119.15,170.71 v3(119.15,170.74)
  IN1 w0.127: 118.77,171.89 118.77,171.13 v3(119.15,170.74)
  IN1 w0.165: 118.77,171.89 118.77,172.32 119.42,172.98 119.42,174.26 119.92,174.76 119.92,175.73 121.84,177.65 125.59,177.65 127.33,175.91 130.78,175.91 130.94,176.08 130.94,176.76 131.11,176.93 131.44,176.93 131.6,176.76 131.6,176.08 131.77,175.91 132.1,175.91 132.26,176.08 132.26,176.76 132.43,176.93 132.76,176.93 132.92,176.76 132.92,176.08 133.09,175.91 133.42,175.91 133.58,176.08 133.58,176.71 133.78,176.9 134.05,176.9 134.24,176.71 134.24,176.08 134.41,175.91 134.74,175.91 134.91,176.08 134.91,176.66 135.1,176.85 135.37,176.85 135.57,176.66 135.57,176.16 135.76,175.96 136.03,175.96 136.23,176.16 136.23,176.76 136.39,176.93 140.98,176.93 142.2,175.71 144.61,175.71 148.57,171.75 148.57,169.62 147.12,168.17 147.12,167.04 v3(147.93,166.23)
  BOTTOM w0.152: v3(147.93,166.23) 147.92,166.23 U19.E13
VMA_DQ15: length 50.3
  TOP w0.152: v3(118.35,170.74) 118.35,169.94 VRAM1.G2
  IN1 w0.165: v3(147.93,167.07) 147.49,167.51 147.49,168.02 148.94,169.47 148.94,171.9 144.76,176.08 142.35,176.08 141.13,177.3 130.74,177.3 130.57,177.13 130.57,176.69 130.38,176.5 130.11,176.5 129.91,176.69 129.91,177.13 129.75,177.3 129.42,177.3 129.25,177.13 129.25,176.67 129.06,176.47 128.78,176.47 128.59,176.67 128.59,177.13 128.43,177.3 128.1,177.3 127.93,177.13 127.93,176.69 127.74,176.5 127.46,176.5 127.27,176.69 127.27,177.13 127.1,177.3 126.47,177.3 125.74,178.02 121.43,178.02 119.5,176.09 119.5,174.86 119.01,174.38 119.01,173.54 117.91,172.43 117.91,170.91 118.08,170.74 v3(118.35,170.74)
  BOTTOM w0.152: U19.D13 147.93,167.04 v3(147.93,167.07)
VMA_DQ16: length 39.4
  BOTTOM w0.152: VRAM3.D7 119.93,171.57 120.12,171.57 120.25,171.7 120.25,171.89 119.84,172.3 119.31,172.3 119.15,172.47 119.15,173.69 119.4,173.94 119.67,173.94 122.8,177.07 125.27,177.07 125.47,177.27 127.38,177.27 127.58,177.48 127.58,178.6 127.92,178.94 v3(130,178.94) 138.18,178.94 145.31,171.81 145.31,169.52 145.45,169.38 145.45,168.65 U19.B15
VMA_DQ17: length 39.2
  BOTTOM w0.152: U19.C16 145.47,167.86 145.99,167.86 146.22,168.09 146.22,169.83 146.22,169.83 146.22,172.19 v3(145.75,172.65) 138.56,179.85 126.26,179.85 124.39,177.99 122.43,177.99 119.18,174.74 119.18,174.18 118.75,173.75 VRAM3.B8
VMA_DQ18: length 40.1
  BOTTOM w0.152: VRAM3.C8 118.75,172.97 118.3,173.41 118.3,174.54 118.28,174.57 118.28,175.06 121.66,178.44 124.2,178.44 126.07,180.31 v3(127,180.31) 138.75,180.31 146.68,172.38 146.68,169.9 U19.A13
VMA_DQ19: length 38.3
  BOTTOM w0.152: VRAM3.A7 119.55,174.46 122.61,177.53 124.58,177.53 125.08,178.02 125.33,178.02 125.62,177.73 125.86,177.73 126.04,177.91 126.04,178.15 125.76,178.43 125.76,178.71 126.09,179.04 126.36,179.04 126.51,178.89 126.51,177.91 126.69,177.73 126.94,177.73 127.12,177.91 127.12,179.18 127.33,179.39 138.37,179.39 v3(143.93,173.83) 145.76,172 145.76,171.07 145.97,170.87 145.97,170.24 145.67,169.94 145.67,169.79 145.96,169.5 145.96,169.4 145.85,169.28 U19.A15
VMA_DQ20: length 37.2
  BOTTOM w0.152: VRAM3.A3 122.98,174.34 123.14,174.5 123.14,175.05 123.41,175.32 125.89,175.32 126.11,175.1 131.99,175.1 132.25,175.36 132.25,176.61 132.4,176.76 132.73,176.76 132.88,176.61 132.88,175.28 133.06,175.1 133.31,175.1 133.49,175.28 133.49,176.59 133.67,176.76 133.92,176.76 134.1,176.59 134.1,175.28 134.28,175.1 134.53,175.1 134.71,175.28 134.71,176.61 134.86,176.76 v3(135.11,176.76) 135.28,176.59 135.28,175.42 135.46,175.25 135.7,175.25 135.87,175.42 135.87,176.51 136.12,176.76 137.28,176.76 141.99,172.05 141.99,171.39 142.73,170.66 142.73,169.41 142.96,169.18 142.96,167.91 143.08,167.79 143.25,167.79 143.37,167.91 U19.B18
VMA_DQ21: length 35
  BOTTOM w0.152: U19.A18 143.37,169.17 143.06,169.49 143.06,170.81 142.5,171.37 142.5,172.19 137.47,177.22 v3(136.31,177.22) 132.02,177.22 131.79,176.99 131.79,175.74 131.61,175.56 131.36,175.56 131.18,175.74 131.18,177.03 130.99,177.22 130.73,177.22 130.54,177.03 130.54,175.76 130.33,175.56 126.09,175.56 125.99,175.66 123.37,175.66 121.85,174.14 121.85,173.61 122.28,173.17 122.82,173.17 122.97,173.02 123.27,173.02 123.42,173.17 123.89,173.17 124.01,173.05 124.01,172.87 123.89,172.74 VRAM3.C2
VMA_DQ22: length 35.3
  BOTTOM w0.152: U19.A19 142.45,169.16 142.45,170.52 141.53,171.44 141.53,171.86 139.89,173.5 139.3,173.5 139.09,173.7 139.09,174.3 138.94,174.46 138.72,174.46 138.56,174.3 138.56,173.68 138.38,173.5 138.03,173.5 137.62,173.91 137.62,174.13 138.34,174.84 138.34,175.06 138.12,175.27 137.91,175.27 137.28,174.65 137.02,174.65 136.85,174.82 136.85,175.08 137.47,175.7 137.47,175.92 137.09,176.31 136.5,176.31 136.33,176.14 136.33,174.85 136.12,174.65 v3(134.74,174.65) 126.22,174.65 126.01,174.44 126.01,172.6 125.85,172.43 125.62,172.43 125.45,172.6 125.45,174.79 125.27,174.97 125,174.97 124.82,174.79 124.82,174.1 124.62,173.9 123.75,173.9 123.55,174.11 VRAM3.A2
VMA_DQ23: length 35.8
  BOTTOM w0.152: VRAM3.C3 123.1,172.39 124.54,172.39 124.9,172.03 126.24,172.03 v3(126.24,172.03) 127.55,172.03 127.72,172.19 127.72,172.42 127.55,172.59 126.42,172.59 126.27,172.74 126.27,172.96 126.42,173.12 128.23,173.12 128.38,173.27 128.38,173.49 128.23,173.64 126.43,173.64 126.27,173.8 126.27,174.03 126.43,174.19 128.33,174.19 128.68,173.83 128.93,173.83 129.29,174.19 136.7,174.19 137.84,173.04 139.7,173.04 140.64,172.1 140.64,171.66 140.34,171.36 140.34,171.14 140.51,170.97 140.73,170.97 140.95,171.19 141.33,171.19 141.85,170.66 141.85,170.44 141.7,170.29 141.7,170.08 141.81,169.97 142.07,169.97 142.2,169.84 142.2,168.9 142.35,168.75 142.35,168.57 142.2,168.42 142.2,168.19 141.93,167.92 141.93,167.76 142.05,167.65 142.21,167.65 142.43,167.87 142.6,167.87 142.72,167.76 142.72,167.59 U19.C19
VMA_DQ24: length 36.3
  IN2 w0.165: v3(126.21,169.7) 125.54,170.37 125.54,171.15 125.76,171.37 126.17,171.37 126.36,171.56 126.36,171.83 126.17,172.03 125.65,172.03 125.46,172.22 125.46,172.5 125.65,172.69 126.18,172.69 126.36,172.87 126.36,173.12 126.18,173.3 125.6,173.3 125.49,173.41 125.49,174.78 125.66,174.95 125.92,174.95 126.09,174.78 126.09,173.97 126.28,173.78 126.54,173.78 126.72,173.97 126.72,174.76 126.92,174.95 127.17,174.95 127.36,174.76 127.36,173.89 127.54,173.7 127.81,173.7 127.99,173.89 127.99,174.76 128.19,174.95 128.46,174.95 128.65,174.76 128.65,173.91 128.84,173.73 129.09,173.73 129.27,173.91 129.27,174.76 129.47,174.95 129.74,174.95 129.93,174.76 129.93,174.12 130.1,173.96 134.01,173.96 134.29,173.68 134.29,173.14 134.47,172.96 134.72,172.96 134.9,173.14 134.9,173.48 135.1,173.67 135.37,173.67 135.57,173.48 135.57,173.14 135.74,172.97 136.08,172.97 136.42,172.63 136.42,172.24 136.61,172.05 136.99,172.05 137.33,171.71 v3(137.33,171.56)
  BOTTOM w0.152: U19.B24 137.99,168.64 137.99,169.18 137.63,169.54 137.63,171.26 v3(137.33,171.56) ; v3(126.21,169.7) 125.96,169.95 125.25,169.95 125.06,169.77 124.74,169.77 124.56,169.95 123.69,169.95 123.55,169.81 VRAM3.G2
VMA_DQ25: length 37.4
  IN2 w0.165: v3(139.08,170.89) 138.87,170.68 138.66,170.68 138.51,170.83 138.51,171.04 138.89,171.41 139.35,171.41 139.52,171.25 139.72,171.25 139.84,171.37 139.84,171.76 139.74,171.86 138.23,171.86 135.81,174.28 135.81,174.88 135.66,175.03 135.43,175.03 135.28,174.89 135.28,174.53 135.16,174.41 134.73,174.41 134.45,174.69 132.45,174.69 132.27,174.87 132.27,175.5 132.09,175.69 124.62,175.69 124.5,175.57 124.5,175.33 124.76,175.07 124.76,174.68 124.38,174.3 124.17,174.3 124.01,174.46 123.79,174.46 123.63,174.3 123.63,174.08 123.83,173.88 123.83,173.58 123.64,173.38 123.26,173.38 123.05,173.17 122.79,173.17 122.53,173.43 122.28,173.43 122.11,173.26 122.11,172.78 122.31,172.58 122.55,172.58 122.67,172.46 122.67,170.74 122.81,170.6 123.01,170.6 v3(123.15,170.74)
  BOTTOM w0.102: 138.41,169.52 138.41,169.52 138.79,169.14 138.79,168.9 138.64,168.75 138.64,168.57 138.79,168.42 138.79,168.19 138.94,168.04 138.94,167.76 138.79,167.61 138.79,167.35 138.55,167.11 138.55,166.97 138.72,166.79 138.87,166.79 139.24,167.16 U19.C23
  BOTTOM w0.152: VRAM3.E3 122.56,170.96 122.56,170.82 122.64,170.74 v3(123.15,170.74) ; 138.41,169.52 138.28,169.65 138.28,170.43 138.74,170.89 v3(139.08,170.89)
VMA_DQ26: length 34
  IN2 w0.165: v3(125.83,167.83) 125.83,168.11 126.34,168.62 126.88,168.62 127.04,168.78 127.04,169 126.73,169.31 126.73,173.34 126.92,173.53 127.19,173.53 127.39,173.34 127.39,172.78 127.58,172.59 127.84,172.59 128.04,172.78 128.04,173.34 128.23,173.54 128.5,173.54 128.7,173.34 128.7,172.8 128.9,172.59 129.15,172.59 129.35,172.8 129.35,173.34 129.55,173.54 129.82,173.54 130.01,173.34 130.01,172.79 130.2,172.59 130.48,172.59 130.67,172.79 130.67,173.4 130.86,173.59 131.14,173.59 131.33,173.4 131.33,172.79 131.52,172.59 131.8,172.59 131.99,172.79 131.99,173.4 132.18,173.59 132.46,173.59 132.65,173.4 132.65,172.77 132.83,172.59 133.08,172.59 133.26,172.77 133.26,173.34 133.46,173.54 133.73,173.54 133.92,173.34 133.92,172.76 134.09,172.59 135.63,172.59 135.93,172.3 135.93,171.72 136.09,171.56 136.57,171.56 136.76,171.37 136.76,171.09 136.57,170.9 136.09,170.9 135.93,170.73 135.93,170.49 136.58,169.84 137.01,169.84 137.11,169.94 v3(137.11,170.24)
  BOTTOM w0.152: v3(137.11,170.24) 136.93,170.24 136.81,170.12 136.81,169.82 U19.A25 ; v3(125.83,167.83) 125.32,168.34 123.14,168.34 122.75,168.73 VRAM3.H3
VMA_DQ27: length 35.1
  IN2 w0.165: v3(123.95,170.74) 123.74,170.74 123.6,170.61 123.6,169.92 123.88,169.64 124.72,169.64 124.87,169.79 124.87,170.01 124.59,170.28 124.59,170.91 124.4,171.1 124.4,171.41 124.9,171.91 124.9,172.13 124.74,172.29 124.52,172.29 124.25,172.02 123.2,172.02 123.04,172.18 123.04,172.64 123.39,172.99 123.6,172.99 123.99,172.61 124.26,172.61 124.44,172.79 124.44,173.06 124.2,173.31 124.2,173.56 125.12,174.49 125.12,175.16 125.28,175.32 130.11,175.32 130.3,175.13 130.3,174.51 130.48,174.33 130.74,174.33 130.92,174.51 130.92,175.12 131.11,175.32 131.77,175.32 131.91,175.18 131.91,175 131.58,174.67 131.58,174.49 131.75,174.33 134.29,174.33 134.58,174.04 135.52,174.04 138.1,171.46 v3(138.1,171.34)
  BOTTOM w0.152: VRAM3.F2 123.55,170.34 v3(123.95,170.74) ; v3(138.1,171.34) 137.73,171.71 137.73,171.9 137.89,172.05 138.43,172.05 138.56,171.92 138.56,171.11 138.03,170.58 138.03,169.55 138.39,169.18 U19.A24
VMA_DQ28: length 36.2
  IN2 w0.165: v3(119.15,169.98) 119.34,169.98 119.98,170.62 119.98,171.16 119.67,171.47 119.67,171.74 119.39,172.02 118.6,172.02 118.39,172.22 118.39,172.51 118.6,172.71 118.88,172.71 119.02,172.85 119.02,173.31 123.17,177.47 136.34,177.47 140.95,172.86 140.95,170.89 140.7,170.64 140.7,170.25 v3(140.84,170.11)
  BOTTOM w0.152: VRAM3.F7 119.51,170.34 v3(119.15,169.98) ; v3(140.84,170.11) 141.16,170.11 141.31,169.96 141.31,169.74 141.18,169.61 140.9,169.61 140.77,169.49 140.77,169.16 U19.A21
VMA_DQ29: length 39.6
  IN2 w0.165: v3(116.35,171.71) 116.35,171.81 122.75,178.21 136.64,178.21 141.79,173.06 141.79,169.57 v3(141.76,169.54)
  BOTTOM w0.152: v3(116.35,171.71) 116.35,170.63 117.16,169.82 117.61,169.82 117.69,169.9 118.3,169.9 VRAM3.F8 ; v3(141.76,169.54) 141.29,169.06 141.29,168.64 U19.B21
VMA_DQ30: length 37.7
  IN2 w0.165: v3(141.32,167.84) 141.69,167.47 141.92,167.47 142.07,167.62 142.07,167.85 141.12,168.8 141.12,169.16 140.34,169.94 140.34,170.06 140.34,170.06 140.34,170.8 140.58,171.04 140.58,172.71 136.18,177.1 123.33,177.1 120.71,174.49 120.71,173.66 120.43,173.38 119.6,173.38 119.38,173.16 119.38,172.55 120.04,171.89 120.04,171.62 120.35,171.31 120.35,170.46 119.94,170.06 119.94,169.15 v3(119.95,169.14)
  BOTTOM w0.152: U19.C20 141.72,167.44 v3(141.32,167.84) ; v3(119.95,169.14) 119.55,168.75 VRAM3.H7
VMA_DQ31: length 40.4
  IN2 w0.165: v3(117.37,168.21) 117.37,169.61 117.87,170.11 117.87,171.82 118.01,171.96 118.01,172.82 123.02,177.84 136.49,177.84 141.32,173.01 v3(141.32,170.59)
  BOTTOM w0.152: v3(117.37,168.21) 117.5,168.34 118.1,168.34 118.39,168.63 118.64,168.63 VRAM3.H8 ; U19.C21 140.89,167.47 140.52,167.84 140.52,169.21 140.37,169.36 140.37,170.25 140.7,170.59 v3(141.32,170.59)
VMA_DQ32: length 42.1
  TOP w0.152: v3(140.43,157.1) 140.08,156.75 140.08,156.04 139.15,155.11 138.58,155.11 137.72,154.25 136.98,154.25 136.73,154 136.73,150.35 134.55,148.17 v3(134.55,145.99) 134.55,144.94 127.02,137.41 120.74,137.41 116.78,141.37 116.78,142.59 117.41,143.22 118.07,143.22 118.38,143.53 118.63,143.53 VRAM2.C8
  BOTTOM w0.152: U19.R22 v3(140.43,157.1)
VMA_DQ33: length 35.5
  TOP w0.152: v3(137.99,157.1) 137.99,156.83 137.85,156.69 137.49,156.69 137.32,156.86 136.99,156.86 136.73,156.61 136.73,155.74 135.04,154.05 134.41,154.05 134.24,153.87 134.24,153.62 134.41,153.44 135.19,153.44 135.36,153.27 135.36,153.02 135.19,152.85 134.7,152.85 134.5,152.65 134.5,150.06 133.18,148.74 133.18,145.51 126.45,138.79 v3(125.66,138.79) 122.08,138.79 120.37,140.49 120.37,141.6 120.24,141.73 119.63,141.73 119.55,141.82 VRAM2.A7
  BOTTOM w0.127: U19.R24 v3(137.99,157.1)
VMA_DQ34: length 38.7
  TOP w0.152: VRAM2.D7 119.14,144.04 119.14,143.48 118.91,143.25 118.64,143.25 118.35,142.96 118.35,141.17 121.65,137.87 126.83,137.87 v3(128.7,139.75) 134.09,145.13 134.09,148.36 136.28,150.54 136.28,153.99 136.87,154.58 137.4,154.58 138.31,155.49 138.84,155.49 v3(139.63,156.28)
  BOTTOM w0.152: v3(139.63,156.28) 140.03,156.68 U19.T22
VMA_DQ35: length 39.1
  TOP w0.152: VRAM2.B8 119.17,142.43 119.17,141.8 119.7,141.27 119.9,141.27 120.04,141.12 120.04,140.91 119.9,140.76 119.61,140.76 119.47,140.62 119.47,140.42 119.61,140.28 119.94,140.28 121.89,138.33 126.64,138.33 v3(133.43,145.12) 133.63,145.32 133.63,148.55 135.82,150.73 135.82,151.52 135.69,151.65 135.13,151.65 134.95,151.82 134.95,152.08 135.13,152.26 135.64,152.26 135.82,152.43 135.82,154.18 136.74,155.1 137,155.1 137.16,154.94 137.35,154.94 137.48,155.07 137.48,155.25 137.21,155.53 137.21,155.74 137.36,155.89 137.58,155.89 137.82,155.64 138,155.64 138.39,156.03 138.39,156.94 138.55,157.1 v3(138.79,157.1)
  BOTTOM w0.152: U19.R23 139.19,157.24 139.05,157.1 v3(138.79,157.1)
VMA_DQ36: length 41
  TOP w0.152: VRAM2.C3 123.07,143.65 123.19,143.53 123.19,143.36 123.07,143.24 122.34,143.24 121.85,142.75 121.85,141.45 122.79,140.5 125.74,140.5 129.57,144.33 v3(129.57,144.33) 130.26,145.02 130.26,145.2 129.9,145.56 129.9,145.82 130.08,145.99 130.33,145.99 130.64,145.69 130.93,145.69 131.36,146.12 131.36,146.4 131.21,146.55 130.08,146.55 129.9,146.73 129.9,146.98 130.08,147.16 131.28,147.16 131.46,147.34 131.46,147.59 131.28,147.77 130.08,147.77 129.9,147.95 129.9,148.2 130.08,148.38 131.31,148.38 131.46,148.53 131.46,154.7 131.77,155.01 131.77,155.22 131.53,155.46 131.53,155.71 131.71,155.89 131.97,155.89 132.19,155.66 132.41,155.66 132.63,155.88 132.63,156.1 132.38,156.34 132.38,156.56 133.5,157.68 134.95,157.68 135.16,157.89 136.2,157.89 136.58,158.27 136.58,158.72 136.65,158.79 v3(137.19,158.79)
  BOTTOM w0.152: U19.N25 137.59,158.97 137.41,158.79 v3(137.19,158.79)
VMA_DQ37: length 39.7
  TOP w0.152: VRAM2.A2 123.78,142.05 124.29,141.54 125.42,141.54 127.92,144.04 127.92,144.77 128.1,144.95 128.82,144.95 128.98,145.12 128.98,145.35 128.82,145.52 128.1,145.52 127.92,145.69 127.92,145.95 128.1,146.12 128.83,146.12 128.98,146.28 128.98,146.58 128.83,146.73 128.1,146.73 127.92,146.91 127.92,147.17 128.1,147.34 128.83,147.34 128.98,147.5 128.98,147.82 128.83,147.98 128.09,147.98 127.94,148.13 127.94,148.42 128.1,148.59 128.76,148.59 128.98,148.81 v3(128.98,150.6) 128.98,152.77 129.2,152.99 130.38,152.99 130.55,153.15 130.55,153.39 130.38,153.56 129.01,153.56 128.83,153.74 128.83,153.99 129.01,154.17 130.37,154.17 130.55,154.35 130.55,154.6 130.37,154.78 129.75,154.78 129.57,154.96 129.57,155.21 129.75,155.39 130.31,155.39 130.55,155.63 130.55,156.19 132.54,158.18 132.54,159.06 132.72,159.24 132.97,159.24 133.15,159.06 133.15,158.75 133.31,158.59 133.55,158.59 133.71,158.75 133.71,159.12 133.86,159.28 134.09,159.28 134.24,159.12 134.24,158.74 134.4,158.59 134.58,158.59 134.76,158.77 v3(134.81,158.77)
  BOTTOM w0.152: v3(134.81,158.77) 135.2,158.39 135.47,158.39 135.89,158.81 136.42,158.81 U19.N26
VMA_DQ38: length 41.8
  TOP w0.152: VRAM2.C2 123.55,143.4 123.7,143.26 124.45,143.26 125.2,142.51 125.75,142.51 127.46,144.23 v3(127.46,146.59) 127.46,147.24 127.21,147.49 127.21,148.02 127.48,148.29 127.48,148.84 127.68,149.04 128.35,149.04 128.53,149.22 128.53,149.47 128.35,149.65 127.34,149.65 127.16,149.83 127.16,150.08 127.34,150.26 128.35,150.26 128.53,150.44 128.53,150.69 128.35,150.87 127.39,150.87 127.21,151.05 127.21,151.3 127.39,151.48 128.35,151.48 128.53,151.66 128.53,151.91 128.35,152.09 127.36,152.09 127.18,152.27 127.18,152.52 127.36,152.7 128.36,152.7 128.54,152.88 128.54,153.13 128.36,153.31 127.31,153.31 127.11,153.51 127.11,154.32 127.28,154.5 127.54,154.5 127.72,154.32 127.72,154.06 127.91,153.87 128.18,153.87 128.38,154.06 128.38,154.66 131.95,158.24 131.95,159.11 132.57,159.73 137.32,159.73 137.53,159.95 138.63,159.95 138.92,159.66 138.92,158.89 v3(138.78,158.75)
  BOTTOM w0.152: v3(138.78,158.75) 139.19,159.16 U19.N23
VMA_DQ39: length 41.4
  TOP w0.152: VRAM2.A3 122.75,142.35 123.06,142.66 123.23,142.66 123.36,142.54 123.36,142.36 123.18,142.19 123.18,141.92 123,141.73 123,141.54 123.13,141.4 123.33,141.4 123.47,141.55 123.73,141.55 123.85,141.44 123.85,141.18 123.96,141.06 125.59,141.06 129.44,144.91 v3(129.44,147.66) 129.44,148.66 129.62,148.84 130.83,148.84 131,149.02 131,149.27 130.83,149.45 129.62,149.45 129.44,149.63 129.44,149.88 129.62,150.06 130.83,150.06 131,150.24 131,150.49 130.83,150.67 129.62,150.67 129.44,150.85 129.44,151.11 129.62,151.29 130.83,151.29 131,151.47 131,151.72 130.83,151.9 129.62,151.9 129.44,152.08 129.44,152.34 129.62,152.53 130.83,152.53 131,152.71 131,155.83 133.31,158.13 134.77,158.13 134.97,158.34 135.42,158.34 135.89,158.81 135.89,159.15 136.01,159.27 138.23,159.27 138.36,159.13 138.36,158.94 138.23,158.8 v3(137.99,158.8)
  BOTTOM w0.127: U19.N24 138.37,159.18 v3(137.99,158.8)
VMA_DQ40: length 35.3
  TOP w0.152: v3(122.22,144.27) 122.28,144.33 122.28,144.78 VRAM2.E3
  IN1 w0.165: v3(138.79,154.62) 138.54,154.37 138,154.37 137.75,154.62 137.33,154.62 136.64,153.93 136.64,153.67 136.88,153.44 136.88,153.17 136.7,152.99 136.44,152.99 136.19,153.24 135.95,153.24 134.04,151.33 134.04,150.96 134.7,150.3 134.7,149.99 134.5,149.79 134.27,149.79 133.5,150.55 133.27,150.55 133.04,150.32 133.04,150.09 133.8,149.32 133.8,149.09 126.28,141.57 125.47,141.57 125.29,141.75 125.29,142 125.47,142.18 125.89,142.18 127.02,143.31 127.02,143.69 126.2,144.51 125.1,144.51 124.87,144.27 124.18,144.27 124.02,144.1 124.02,143.72 123.83,143.52 123.55,143.52 123.36,143.72 123.36,144.1 123.19,144.27 v3(122.22,144.27)
  BOTTOM w0.152: U19.V23 v3(138.79,154.62)
VMA_DQ41: length 37
  TOP w0.152: v3(123.15,146.45) VRAM2.G2
  IN1 w0.165: v3(123.15,146.45) 122.8,146.45 122.67,146.32 122.67,146.03 123.41,145.29 123.7,145.29 123.89,145.48 123.89,145.78 124.06,145.94 124.39,145.94 124.55,145.78 124.55,145.49 124.72,145.33 124.97,145.33 125.42,144.87 126.75,144.87 127.77,143.86 128.04,143.86 129.29,145.11 129.29,145.34 128.54,146.09 128.54,146.36 128.74,146.56 129.01,146.56 129.76,145.81 129.99,145.81 130.23,146.04 130.23,146.27 129.48,147.02 129.48,147.3 129.67,147.49 129.94,147.49 130.69,146.74 130.93,146.74 131.16,146.97 131.16,147.21 130.4,147.96 130.4,148.2 130.64,148.43 130.87,148.43 131.63,147.67 131.86,147.67 132.09,147.91 132.09,148.14 131.34,148.89 131.34,149.17 131.54,149.36 131.81,149.36 132.54,148.64 132.82,148.64 133.06,148.87 133.06,149.16 132.36,149.85 132.36,150.19 137.29,155.11 139.12,155.11 v3(139.61,154.62)
  BOTTOM w0.152: v3(139.61,154.62) 140.01,155.02 U19.V22
VMA_DQ42: length 36.7
  TOP w0.152: v3(125.56,145.43) 124.92,145.43 124.73,145.62 123.98,145.62 VRAM2.F2
  IN1 w0.165: v3(125.56,145.43) 125.84,145.71 127.13,145.71 128.12,144.72 128.39,144.72 128.58,144.91 128.58,145.18 127.67,146.09 127.67,146.28 126.78,147.16 126.78,147.45 126.99,147.65 127.27,147.65 128.13,146.8 128.42,146.8 128.68,147.06 128.68,147.34 127.95,148.07 127.95,148.35 128.14,148.54 128.42,148.54 129.17,147.79 129.45,147.79 129.64,147.98 129.64,148.25 128.88,149.01 128.88,149.28 129.08,149.48 129.35,149.48 130.13,148.7 130.36,148.7 137.12,155.47 139.47,155.47 140.44,154.5 140.95,154.5 141.28,154.83 141.28,155.43 v3(139.61,157.1)
  BOTTOM w0.152: U19.T23 139.21,156.7 v3(139.61,157.1)
VMA_DQ43: length 36.9
  TOP w0.127: v3(123.17,148.05) 123.15,148.05 VRAM2.H3
  IN1 w0.165: v3(140.43,155.42) 140.03,155.82 136.96,155.82 136.32,155.19 136.09,155.19 135.72,155.55 135.45,155.55 135.25,155.36 135.25,155.09 135.62,154.72 135.62,154.49 134.14,153.01 133.91,153.01 133.38,153.54 133.11,153.54 132.91,153.34 132.91,153.07 133.44,152.54 133.44,152.31 133.18,152.04 132.95,152.04 131.77,153.22 131.49,153.22 131.3,153.03 131.3,152.76 132.48,151.58 132.48,151.34 132.25,151.11 132.01,151.11 130.91,152.21 130.64,152.21 130.44,152.02 130.44,151.75 131.55,150.64 131.55,150.41 131.31,150.18 131.08,150.18 129.9,151.36 129.62,151.36 129.43,151.16 129.43,150.89 130.61,149.71 130.61,149.48 130.38,149.24 130.11,149.24 129.39,149.95 129.04,149.95 127.17,148.09 126.76,148.09 125.89,147.22 124.01,147.22 v3(123.17,148.05)
  BOTTOM w0.152: U19.U22 140.03,155.82 v3(140.43,155.42)
VMA_DQ44: length 35.6
  TOP w0.152: v3(119.97,147.27) 119.59,147.65 VRAM2.H7
  IN1 w0.165: v3(137.99,152.14) 137.95,152.1 137.95,151.17 134.9,148.13 134.9,147.74 135.15,147.5 135.15,147.22 134.95,147.01 134.67,147.01 134.37,147.31 134.09,147.31 133.9,147.12 133.9,146.85 134.2,146.54 134.2,146.27 127.98,140.05 121.9,140.05 121.27,140.68 121.03,140.68 120.54,140.19 120.27,140.19 120.08,140.39 120.08,140.66 120.56,141.15 120.56,142.68 120.15,143.1 120.15,144.04 119.7,144.49 119.7,147 v3(119.97,147.27)
  BOTTOM w0.152: v3(137.99,152.14) 137.99,152.14 137.99,152.66 138.39,153.06 U19.Y24
VMA_DQ45: length 34.9
  TOP w0.152: VRAM2.F7 v3(119.16,145.67)
  IN1 w0.102: v3(119.16,145.67) 118.76,145.26 118.76,144.62
  IN1 w0.165: 118.76,144.62 118.76,144.53 119.59,143.7 119.59,140.35 120.32,139.62 128.07,139.62 135.6,147.14 135.6,148.3 135.96,148.66 136.25,148.66 136.54,148.36 136.82,148.36 137.01,148.56 137.01,148.83 136.75,149.09 136.75,149.36 136.95,149.56 137.22,149.56 137.48,149.3 137.75,149.3 137.95,149.49 137.95,149.77 137.7,150.01 137.7,150.4 138.32,151.02 138.32,151.67 v3(138.79,152.14)
  BOTTOM w0.152: U19.AA24 v3(138.79,152.14)
VMA_DQ46: length 36.7
  TOP w0.152: VRAM2.F8 118.7,146.05 v3(118.34,145.69)
  IN1 w0.102: 139.23,151.7 139.23,151.85 139.2,151.88 139.2,152.31 139.45,152.56 139.82,152.56 140.07,152.81 140.07,153.44 v3(140.43,153.8)
  IN1 w0.165: 139.23,151.7 139.23,151.08 138.67,150.52 138.67,149.69 128.19,139.21 120.21,139.21 118.34,141.08 118.34,143.1 117.83,143.61 117.83,145.18 v3(118.34,145.69)
  BOTTOM w0.152: U19.Y22 140.03,153.4 v3(140.43,153.8)
VMA_DQ47: length 37.3
  TOP w0.152: VRAM2.H8 v3(118.35,147.25)
  IN1 w0.165: v3(118.35,147.25) 117.87,146.77 117.87,146.29 117.45,145.87 117.45,143.43 118.01,142.87 118.01,140.89 120.06,138.84 128.34,138.84 139.04,149.54 139.04,150.37 139.61,150.94 v3(139.61,152.14)
  BOTTOM w0.152: U19.AA23 139.59,152.14 v3(139.61,152.14)
VMA_DQ48: length 31.3
  BOTTOM w0.152: U19.AD27 135.91,150.04 134.93,149.06 134.93,147.17 133.53,145.78 133.53,142.32 128.69,137.48 121.32,137.48 118.96,139.84 v3(118.96,139.84) 118.27,140.53 118.27,141.84 118.35,141.93 118.35,142.96 118.67,143.27 119.17,143.27 VRAM4.C3
VMA_DQ49: length 33.1
  BOTTOM w0.152: VRAM4.A3 119.55,142.05 120.61,140.98 120.61,140.77 120.15,140.3 120.15,140.05 120.33,139.87 120.58,139.87 121.02,140.32 121.28,140.32 121.46,140.14 121.46,139.89 121.01,139.44 121.01,139.19 121.19,139.01 121.44,139.01 121.89,139.46 122.14,139.46 122.32,139.28 122.32,139.02 122.12,138.83 122.12,138.58 122.3,138.4 122.55,138.4 122.77,138.61 122.98,138.61 v3(123.2,138.4) 128.32,138.4 132.62,142.7 132.62,146.16 134.01,147.56 134.01,149.23 134.94,150.16 135.23,150.16 135.73,150.67 136.36,150.67 136.55,150.48 136.91,150.48 137.16,150.73 137.16,151.06 137.36,151.26 137.73,151.26 137.88,151.4 137.88,151.6 137.73,151.74 U19.AB25
VMA_DQ50: length 30.6
  BOTTOM w0.152: VRAM4.A2 118.75,141.74 118.56,141.55 118.56,141 118.82,140.74 119.03,140.74 119.49,141.19 119.76,141.19 119.94,141.01 119.94,140.79 119.46,140.31 119.46,140.09 v2(120.42,139.13) 121.61,137.94 128.5,137.94 133.07,142.51 133.07,145.97 134.47,147.37 134.47,149.04 135.84,150.41 136.25,150.41 136.62,150.04 U19.AD26
VMA_DQ51: length 35.3
  BOTTOM w0.152: VRAM4.C2 118.58,143.65 118.18,143.26 117.72,143.26 116.93,142.46 116.93,141.22 v3(117.79,140.36) 121.13,137.03 128.88,137.03 133.99,142.13 133.99,145.59 135.39,146.98 135.39,149.16 135.86,149.64 136.91,149.64 137.22,149.95 137.22,150.21 137.59,150.59 U19.AC25
VMA_DQ52: length 31.3
  BOTTOM w0.152: VRAM4.B8 123.55,142.61 123.34,142.41 122.41,142.41 122.31,142.31 122.31,141.8 122.41,141.69 122.63,141.69 122.64,141.69 123,141.69 123.47,141.22 123.47,140.55 123.65,140.38 123.89,140.38 124.06,140.55 124.06,141.11 124.24,141.29 124.52,141.29 124.67,141.14 124.67,140.29 124.85,140.11 125.1,140.11 125.28,140.29 125.28,141.06 125.46,141.24 125.71,141.24 125.89,141.06 125.89,140.29 126.07,140.11 126.32,140.11 126.5,140.29 126.5,141.08 126.65,141.24 126.96,141.24 127.11,141.08 127.11,140.3 127.29,140.11 127.56,140.11 127.74,140.3 127.74,141.06 127.91,141.24 128.15,141.24 128.33,141.06 128.56,141.06 v3(129.11,141.62) 129.82,142.33 129.82,143.76 130.87,144.8 130.87,146.83 132.29,148.25 132.29,150.23 134.88,152.82 135.71,152.82 U19.AA27
VMA_DQ53: length 31.7
  BOTTOM w0.152: U19.AA26 136.79,152.21 136.67,152.09 136.49,152.09 136.37,152.21 136.37,152.74 135.97,153.14 134.54,153.14 131.83,150.42 131.83,148.44 130.41,147.02 130.41,144.99 v3(130.12,144.7) 129.3,143.88 128.5,143.88 128.33,143.71 128.33,143.47 128.5,143.3 129.21,143.3 129.37,143.14 129.37,142.54 129.24,142.41 129.06,142.41 128.71,142.77 125.91,142.77 125.73,142.6 125.73,142.35 125.91,142.18 128.54,142.18 128.68,142.04 128.68,141.84 128.54,141.69 125.77,141.69 125.48,141.98 125.3,141.98 125.02,141.69 123.4,141.69 123.04,142.05 VRAM4.A7
VMA_DQ54: length 33.2
  BOTTOM w0.152: VRAM4.D7 122.75,144.15 122.9,144.01 123.63,144.01 123.81,144.19 124.11,144.19 124.29,144.01 125.02,144.01 125.23,144.21 125.23,144.83 125.39,145 125.61,145 125.73,144.87 125.73,144.09 125.89,143.94 126.14,143.94 126.34,144.14 126.34,145.36 126.95,145.97 127.39,145.97 127.55,146.13 127.55,146.39 126.98,146.96 125.38,146.96 125.05,147.29 125.05,147.52 125.15,147.62 125.51,147.62 125.71,147.41 127.18,147.41 127.39,147.21 128.16,147.21 128.36,147.41 128.36,148.51 128.57,148.71 128.81,148.71 129.01,148.51 129.01,147.55 129.2,147.37 129.46,147.37 130.03,147.94 130.03,148.28 129.36,148.95 129.36,149.21 129.54,149.39 129.8,149.39 130.48,148.71 130.74,148.71 130.91,148.89 130.91,149.15 130.46,149.6 130.46,149.77 130.91,150.23 130.91,150.8 v3(131.33,151.22) 133.1,152.99 133.1,153.28 133.56,153.74 136.57,153.74 136.79,153.97 U19.W26
VMA_DQ55: length 33.7
  BOTTOM w0.152: VRAM4.C8 123.55,143.33 123.65,143.23 124.76,143.23 124.91,143.08 124.91,142.74 125.07,142.58 125.29,142.58 125.44,142.74 125.44,143.08 125.6,143.23 127.71,143.23 127.87,143.39 127.87,143.62 127.71,143.78 126.96,143.78 126.8,143.95 126.8,144.18 126.96,144.34 129.11,144.34 129.28,144.5 129.28,144.74 129.11,144.9 127.14,144.9 126.96,145.08 126.96,145.33 127.14,145.51 129.77,145.51 129.95,145.69 129.95,145.94 129.77,146.12 128.24,146.12 128.06,146.31 128.06,146.57 128.24,146.76 v3(129.06,146.76) 129.5,146.76 131.37,148.63 131.37,150.61 133.63,152.88 133.63,153.17 133.91,153.44 136.1,153.44 136.56,152.98 136.92,152.98 137.04,153.1 137.27,153.1 137.39,152.98 137.89,152.98 138.01,153.1 138.01,153.27 137.89,153.38 U19.Y25
VMA_DQ56: length 38.3
  IN2 w0.165: v3(126.85,146.42) 126.49,146.78 126.49,147.02 126.66,147.19 126.9,147.19 127.22,146.87 127.45,146.87 127.61,147.03 127.61,147.26 127.34,147.54 127.34,147.76 127.49,147.92 127.72,147.92 128.02,147.62 128.2,147.62 128.38,147.8 128.38,148.05 127.87,148.56 127.87,149.04 128.21,149.38 129.02,149.38 129.21,149.58 129.21,149.85 129.02,150.04 128.1,150.04 127.89,150.25 127.89,150.53 128.1,150.74 130.29,150.74 130.46,150.9 130.46,151.23 130.29,151.4 128.11,151.4 127.92,151.59 127.92,151.87 128.11,152.06 130.29,152.06 130.48,152.26 130.48,152.53 130.29,152.72 128.68,152.72 128.48,152.93 128.48,153.22 128.68,153.43 130.31,153.43 130.48,153.6 130.48,153.85 130.31,154.02 129.83,154.02 129.65,154.2 129.65,154.46 129.83,154.65 130.22,154.65 130.41,154.83 130.41,155.26 133.43,158.29 135.16,158.29 135.36,158.08 v3(135.36,157.43)
  BOTTOM w0.127: v3(135.36,157.43) 135.68,157.12 136.4,157.12 U19.R26
  BOTTOM w0.152: VRAM4.F8 123.55,146.04 123.92,145.67 124.65,145.67 124.94,145.96 126.29,145.96 126.76,146.42 v3(126.85,146.42)
VMA_DQ57: length 36.4
  IN2 w0.165: v3(122.38,147.25) 122.57,147.06 122.57,146.27 122.89,145.95 127.05,145.95 128.88,147.78 129.68,147.78 130.09,147.38 130.32,147.38 130.85,147.9 130.85,148.17 130.66,148.36 128.59,148.36 128.4,148.55 128.4,148.82 128.59,149.02 130.66,149.02 130.85,149.21 130.85,149.46 130.66,149.65 129.84,149.65 129.65,149.85 129.65,150.12 129.84,150.31 130.66,150.31 130.85,150.5 130.85,155.19 133.37,157.7 134.52,157.7 134.7,157.52 134.7,156.91 134.86,156.76 135.67,156.76 135.84,156.92 135.84,157.71 136,157.88 136.33,157.88 136.5,157.71 136.5,156.92 136.66,156.76 137.47,156.76 137.96,156.27 v3(137.96,156.27)
  BOTTOM w0.127: U19.T25 137.59,156.63 v3(137.96,156.27)
  BOTTOM w0.152: v3(122.38,147.25) 122.75,147.62 VRAM4.H7
VMA_DQ58: length 36
  IN2 w0.165: v3(125.47,146.5) 125.47,146.73 125.26,146.93 123.81,146.93 123.62,147.12 123.62,147.37 123.81,147.56 126.61,147.56 126.88,147.83 126.88,148.11 126.38,148.61 124.39,148.61 124.21,148.79 124.21,149.04 124.39,149.22 127.52,149.22 127.72,149.41 127.72,149.69 127.52,149.89 125.53,149.89 125.34,150.08 125.34,150.35 125.53,150.55 126.09,150.55 126.27,150.72 126.27,151.47 126.45,151.65 126.7,151.65 126.88,151.47 126.88,150.75 127.06,150.56 127.32,150.56 127.5,150.75 127.5,152.87 133.45,158.83 134.12,158.83 134.55,159.25 135.23,159.25 v3(135.4,159.08)
  BOTTOM w0.152: U19.N27 135.5,159.18 v3(135.4,159.08) ; v3(125.47,146.5) 125.4,146.5 124.67,147.23 123.96,147.23 VRAM4.H8
VMA_DQ59: length 36.5
  IN2 w0.165: v3(134.16,157.22) 133.81,156.86 133.05,156.86 131.22,155.03 131.22,147.75 130.31,146.84 130.08,146.84 129.64,147.29 129.36,147.29 129.17,147.09 129.17,146.82 129.59,146.4 129.59,146.12 129.4,145.93 129.13,145.93 128.47,146.58 128.2,146.58 128.01,146.39 128.01,146.11 128.67,145.46 128.67,145.19 128.48,145.01 128.22,145.01 127.56,145.67 127.29,145.67 127.09,145.48 127.09,145.2 127.77,144.53 127.77,144.3 127.53,144.06 127.3,144.06 126.21,145.15 125.95,145.15 125.76,144.96 125.76,144.69 126.83,143.62 126.83,143.36 126.29,142.82 124.46,142.82 122.48,144.8 122.48,145.54 v3(122.37,145.65)
  BOTTOM w0.152: VRAM4.F7 122.93,146.05 123.09,145.88 123.09,145.74 122.96,145.6 122.42,145.6 v3(122.37,145.65) ; U19.R27 135.61,157.88 135.2,157.88 134.54,157.22 v3(134.16,157.22)
VMA_DQ60: length 36.5
  IN2 w0.165: v3(134.98,154.63) 134.98,154.15 133.73,152.9 133.73,146.49 125.89,138.65 121.03,138.65 117.9,141.78 117.9,143.36 117.85,143.41 117.85,145.95 v3(118.35,146.45)
  BOTTOM w0.127: v3(134.98,154.63) 136.4,154.63 U19.V26
  BOTTOM w0.152: VRAM4.F2 v3(118.35,146.45)
VMA_DQ61: length 34.9
  IN2 w0.102: v3(119.15,148.05) 119.55,147.64 119.55,146.91
  IN2 w0.165: v3(133.81,154.18) 133.41,154.58 132.87,154.58 132.62,154.33 132.62,147.11 125.31,139.79 122.57,139.79 120.76,141.61 120.76,142.19 119.94,143 119.94,144.5 119.85,144.6 119.85,146.61 119.55,146.91
  BOTTOM w0.127: U19.V27 135.9,155.11 134.19,155.11 133.81,154.73 v3(133.81,154.18)
  BOTTOM w0.152: v3(119.15,148.05) VRAM4.H3
VMA_DQ62: length 35.2
  IN2 w0.165: v3(119.17,144.83) 119.17,142.68 119,142.5 118.53,142.5 118.37,142.34 118.37,142.01 118.53,141.84 119.24,141.84 120.03,141.05 120.03,140.81 119.85,140.63 119.85,140.4 120.08,140.16 120.32,140.16 120.5,140.35 120.73,140.35 120.97,140.11 120.97,139.88 120.78,139.7 120.78,139.46 121.02,139.23 121.25,139.23 121.43,139.41 121.67,139.41 122.05,139.03 125.63,139.03 133.36,146.77 133.36,153.05 134.31,154 v3(134.31,154.63)
  BOTTOM w0.127: VRAM4.E3 119.55,145.21 v3(119.17,144.83) ; U19.W27 135.89,154.13 134.82,154.13 v3(134.31,154.63)
VMA_DQ63: length 36
  IN2 w0.102: v3(119.15,146.45) 119.58,146.02 119.58,144.35
  IN2 w0.165: v3(133.1,154.01) 132.99,153.91 132.99,146.95 125.45,139.41 122.19,139.41 119.58,142.02 119.58,144.35
  BOTTOM w0.152: VRAM4.G2 v3(119.15,146.45) ; U19.W25 137.19,154.63 137.19,155.24 137.03,155.4 134.14,155.4 133.1,154.36 v3(133.1,154.01)
VMA_RDQS0: length 36.6
  TOP w0.127: v3(142.18,165.42) 141.75,165.84 141.75,166.46 141.51,166.7 141.51,167.44 142.33,168.26 142.33,170.8 143.02,171.49 143.02,172.37 139.51,175.88 127.33,175.88 126.83,175.38 126.69,175.38 v3(126.1,174.79) 125.59,175.3 125.15,175.3 124.57,175.88 122.76,175.88 121.54,174.67 121.54,174.34 121.8,174.08 121.8,173.47 121.49,173.17 121.49,172.92 121.67,172.74 121.92,172.74 122.33,173.14 122.58,173.14 122.75,173.31 VRAM1.B7
  BOTTOM w0.127: U19.F19 142.18,165.4 v3(142.18,165.42)
VMA_RDQS1: length 47.3
  TOP w0.127: v3(120.82,170.37) 120.65,170.54 120.49,170.54 119.55,169.6 VRAM1.G3
  IN1 w0.133: v3(120.82,170.37) 120.59,170.6 120.3,170.6 119.87,171.04 119.87,171.93 120.82,172.88 120.82,175.23 122.44,176.85 125.24,176.85 127.04,175.05 141.68,175.05 142.04,174.69 143.02,174.69 143.2,174.52 143.42,174.52 143.84,174.94 144.29,174.94 144.61,174.62 144.61,174.17 144.09,173.66 144.09,173.43 144.25,173.28 144.47,173.28 145.02,173.83 145.4,173.83 145.72,173.51 145.72,173.12 145.17,172.57 145.17,172.36 145.33,172.2 145.55,172.2 146.01,172.66 146.57,172.66 147.8,171.43 147.8,170.8 146.08,169.08 146.08,167.26 v3(146.27,167.07)
  BOTTOM w0.127: v3(146.27,167.07) 146.32,167.07 U19.C14
VMA_RDQS2: length 36.9
  BOTTOM w0.127: VRAM3.B7 119.43,173.42 119.43,173.2 119.5,173.13 120.08,173.13 120.77,172.45 121.2,172.45 121.33,172.57 121.33,172.8 120.68,173.45 120.68,174.21 123.02,176.55 125.48,176.55 125.68,176.75 127.82,176.75 128.1,177.04 128.1,178.13 128.39,178.42 137.96,178.42 144.26,172.11 144.26,171.95 v3(144.78,171.43) 144.29,170.94 144.29,170.85 144.78,170.35 144.78,169.31 U19.A16
VMA_RDQS3: length 35.7
  IN2 w0.133: v3(139.57,172.41) 139.36,172.62 139.36,172.84 138.59,173.6 138.22,173.6 137.89,173.28 137.71,173.28 137.52,173.47 137.52,173.66 137.84,173.98 137.84,174.36 137.51,174.68 137.14,174.68 136.82,174.36 136.63,174.36 136.44,174.55 136.44,174.74 136.76,175.06 136.76,175.44 135.88,176.32 135.23,176.32 134.96,176.05 134.96,175.46 134.83,175.33 134.56,175.33 134.43,175.46 134.43,176.05 134.16,176.32 133.71,176.32 133.44,176.05 133.44,175.46 133.31,175.33 133.04,175.33 132.91,175.46 132.91,176.05 132.64,176.32 124.36,176.32 123.62,175.58 122.9,175.58 121.48,174.17 121.48,171.31 121.31,171.14 121.31,170.37 121.64,170.04 121.97,170.04 122.19,169.81 v3(122.19,169.81)
  BOTTOM w0.127: v3(139.57,172.41) 139.3,172.13 139.3,171.64 140.01,170.93 140.01,169.13 U19.A22 ; VRAM3.G3 122.48,169.81 v3(122.19,169.81)
VMA_RDQS4: length 38.6
  TOP w0.127: VRAM2.B7 119.78,143.08 120.16,143.08 120.49,143.41 120.66,143.41 120.81,143.26 120.81,140.79 122.3,139.31 126.24,139.31 132.66,145.73 132.66,148.95 133.33,149.63 133.33,149.8 v3(133.88,150.35) 133.4,150.84 133.4,150.99 133.76,151.35 133.76,151.66 133.51,151.91 133.14,151.91 132.97,152.08 132.97,152.32 133.14,152.49 133.65,152.49 133.94,152.78 133.94,153.18 133.65,153.46 132.95,153.46 132.66,153.75 132.66,154.21 133.56,155.11 135.37,155.11 135.77,155.51 135.77,156.05 136.94,157.22 137.47,157.22 137.77,157.52 137.77,157.69 v3(137.99,157.91)
  BOTTOM w0.127: v3(137.99,157.91) 137.59,158.31 U19.P25
VMA_RDQS5: length 36.6
  TOP w0.127: VRAM2.G3 122.73,146.83 121.97,146.83 v3(121.29,146.15)
  IN1 w0.133: v3(121.29,146.15) 121.29,145.82 120.92,145.46 120.92,143.13 121.27,142.78 121.27,141.46 122.17,140.57 127.93,140.57 130.18,142.82 130.18,143.2 129.86,143.52 129.86,143.74 130.02,143.9 130.24,143.9 130.56,143.58 130.94,143.58 131.26,143.9 131.26,144.28 130.94,144.6 130.94,144.82 131.1,144.98 131.32,144.98 131.62,144.67 132.03,144.67 132.32,144.96 132.32,145.37 132.03,145.67 132.03,145.89 132.19,146.04 132.41,146.04 132.72,145.73 133.1,145.73 133.46,146.09 133.46,147.25 137.53,151.32 137.53,152.33 137.85,152.65 138.61,152.65 139.42,153.46 139.42,153.56 v3(139.65,153.79)
  BOTTOM w0.127: U19.W22 139.65,153.84 v3(139.65,153.79)
VMA_RDQS6: length 31.7
  BOTTOM w0.127: VRAM4.B7 122.91,142.69 123.09,142.69 123.19,142.79 123.19,143.12 123.04,143.28 122.41,143.28 122.13,142.99 121.57,142.99 121.06,143.5 120.48,143.5 120.37,143.4 120.37,143.17 121.07,142.47 121.76,142.47 122,142.23 122,141.9 121.76,141.66 121.76,141.53 123.69,139.59 127.82,139.59 130.95,142.72 130.95,142.79 v3(130.35,143.4) 130.95,144 130.95,144.15 131.42,144.62 131.42,146.66 132.81,148.04 132.81,150.02 134.99,152.2 135.3,152.2 135.51,151.99 135.51,151.63 135.59,151.55 135.8,151.55 U19.AB27
VMA_RDQS7: length 36
  IN2 w0.133: v3(120.39,146.12) 120.39,146.01 120.71,145.69 120.86,145.69 121.24,145.3 121.24,144.71 120.58,144.04 120.58,143.27 121.39,142.45 121.39,141.87 122.81,140.45 123.15,140.45 123.29,140.58 123.29,141.28 123.58,141.57 123.99,141.57 124.28,141.28 124.28,140.59 124.44,140.43 124.68,140.43 124.85,140.59 124.85,141.03 125.13,141.32 125.91,141.32 131.99,147.4 131.99,154.71 132.9,155.62 133.32,155.62 133.62,155.32 134.56,155.32 134.66,155.42 134.66,155.69 134.49,155.87 v3(134.32,155.87)
  BOTTOM w0.127: v3(134.32,155.87) 134.57,155.87 134.68,155.97 134.68,156.23 135,156.55 135.84,156.55 U19.T27 ; VRAM4.G3 119.55,146.61 120.04,146.12 v3(120.39,146.12)
VMA_WDQS0: length 36.6
  TOP w0.127: v3(142.18,166.24) 142.18,166.34 142.02,166.5 141.72,166.79 141.72,167.35 142.55,168.17 142.55,170.71 143.23,171.4 143.23,172.46 139.6,176.1 127.24,176.1 126.74,175.6 126.64,175.6 126.14,176.09 v3(126.12,176.09) 125.55,175.52 125.24,175.52 124.66,176.1 122.67,176.1 121.33,174.76 121.33,174.25 121.58,173.99 121.58,173.56 121.28,173.26 121.28,172.83 121.58,172.52 122.01,172.52 122.42,172.93 122.56,172.93 VRAM1.C7
  BOTTOM w0.127: v3(142.18,166.24) 142.18,165.98 142.32,165.84 U19.E19
VMA_WDQS1: length 47.3
  TOP w0.127: VRAM1.F3 119.72,170.17 119.82,170.17 120.4,170.75 120.6,170.75 120.82,170.98 v3(120.82,171.03)
  IN1 w0.133: v3(120.82,171.03) 120.82,170.94 120.72,170.83 120.39,170.83 120.1,171.13 120.1,171.83 121.05,172.78 121.05,175.14 122.53,176.62 125.15,176.62 126.95,174.82 141.59,174.82 141.95,174.47 142.93,174.47 143.11,174.29 143.51,174.29 143.94,174.71 144.2,174.71 144.38,174.53 144.38,174.27 143.86,173.75 143.86,173.34 144.15,173.05 144.57,173.05 145.12,173.6 145.3,173.6 145.49,173.41 145.49,173.21 144.94,172.66 144.94,172.26 145.23,171.97 145.64,171.97 146.11,172.43 146.47,172.43 147.57,171.34 147.57,170.89 145.85,169.17 145.85,168.06 145.72,167.93 145.51,167.93 145.41,167.83 145.41,167.64 145.52,167.53 145.72,167.53 145.85,167.4 145.85,167.26 145.66,167.07 v3(145.45,167.07)
  BOTTOM w0.127: U19.C15 145.69,167.61 145.56,167.61 145.45,167.5 v3(145.45,167.07)
VMA_WDQS2: length 37
  BOTTOM w0.127: VRAM3.C7 119.72,172.92 119.99,172.92 120.68,172.23 121.29,172.23 121.54,172.48 121.54,172.89 120.89,173.54 120.89,174.12 123.11,176.34 125.57,176.34 125.77,176.54 127.91,176.54 128.32,176.95 128.32,178.04 128.48,178.2 137.87,178.2 144.05,172.02 144.05,171.99 143.51,171.45 v3(143.51,171.45) 144.07,170.89 144.07,170.76 144.57,170.26 144.57,169.22 144.65,169.13 144.65,168.64 U19.B16
VMA_WDQS3: length 35.9
  IN2 w0.133: v3(138.81,172.41) 139,172.41 139.13,172.54 139.13,172.74 138.5,173.38 138.31,173.38 137.99,173.05 137.61,173.05 137.29,173.38 137.29,173.76 137.61,174.08 137.61,174.26 137.42,174.45 137.23,174.45 136.91,174.13 136.53,174.13 136.21,174.46 136.21,174.83 136.53,175.15 136.53,175.34 135.78,176.09 135.33,176.09 135.19,175.96 135.19,175.37 134.93,175.1 134.47,175.1 134.2,175.37 134.2,175.96 134.07,176.09 133.8,176.09 133.67,175.96 133.67,175.37 133.4,175.1 132.95,175.1 132.68,175.37 132.68,175.96 132.54,176.09 124.45,176.09 123.71,175.35 122.99,175.35 121.71,174.07 121.71,171.21 121.54,171.04 121.54,170.47 121.74,170.27 122.12,170.27 122.19,170.34 v3(122.19,170.47)
  BOTTOM w0.127: VRAM3.F3 122.6,170.2 122.47,170.2 v3(122.19,170.47) ; v3(138.81,172.41) 139,172.41 139.08,172.32 139.08,171.55 139.79,170.84 139.79,169.4 139.71,169.32 139.71,168.89 140.09,168.5 U19.B22
VMA_WDQS4: length 38.5
  TOP w0.127: VRAM2.C7 119.55,143.39 119.64,143.3 120.07,143.3 120.4,143.63 120.74,143.63 121.02,143.35 121.02,140.88 122.39,139.52 126.15,139.52 132.44,145.82 132.44,149.04 133.12,149.72 133.12,149.86 v3(132.61,150.36) 133.18,150.93 133.18,151.08 133.54,151.44 133.54,151.57 133.42,151.69 133.05,151.69 132.76,151.99 132.76,152.41 133.05,152.71 133.56,152.71 133.72,152.87 133.72,153.09 133.56,153.24 132.86,153.24 132.44,153.66 132.44,154.3 133.47,155.33 135.28,155.33 135.55,155.6 135.55,156.14 136.85,157.43 137.38,157.43 137.54,157.6 137.54,157.78 137.42,157.9 v3(137.19,157.9)
  BOTTOM w0.127: U19.R25 137.59,157.5 v3(137.19,157.9)
VMA_WDQS5: length 36.6
  TOP w0.127: v3(121.97,146.18) 121.9,146.25 121.9,146.46 122.05,146.61 122.46,146.61 122.75,146.32 VRAM2.F3
  IN1 w0.133: v3(121.97,146.18) 121.15,145.36 121.15,143.23 121.5,142.88 121.5,141.55 122.26,140.8 127.84,140.8 129.96,142.92 129.96,143.1 129.63,143.42 129.63,143.84 129.92,144.13 130.34,144.13 130.66,143.8 130.84,143.8 131.03,143.99 131.03,144.18 130.71,144.5 130.71,144.91 131,145.2 131.41,145.2 131.72,144.9 131.94,144.9 132.1,145.06 132.1,145.28 131.8,145.57 131.8,145.98 132.09,146.27 132.5,146.27 132.81,145.96 133,145.96 133.23,146.19 133.23,147.34 137.3,151.42 137.3,152.43 137.75,152.88 138.52,152.88 139.19,153.55 139.19,153.79 139.07,153.92 138.9,153.92 v3(138.79,153.8)
  BOTTOM w0.127: U19.W23 139.22,154.19 139.22,153.82 139.14,153.74 138.85,153.74 v3(138.79,153.8)
VMA_WDQS6: length 31.8
  BOTTOM w0.127: U19.AB26 136.56,151.74 136.16,151.34 135.5,151.34 135.3,151.54 135.3,151.9 135.21,151.99 135.08,151.99 133.02,149.93 133.02,147.95 131.64,146.57 131.64,144.53 131.16,144.06 131.16,143.85 v3(131.63,143.39) 131.17,142.93 131.17,142.64 127.91,139.38 123.6,139.38 121.54,141.44 121.54,141.75 121.78,141.99 121.78,142.14 121.67,142.26 120.98,142.26 120.16,143.08 120.16,143.49 120.39,143.72 121.15,143.72 121.66,143.21 122.04,143.21 122.32,143.5 122.59,143.5 VRAM4.C7
VMA_WDQS7: length 36.2
  IN2 w0.133: v3(135.09,155.87) 134.89,155.67 134.89,155.32 134.66,155.09 133.52,155.09 133.23,155.39 132.99,155.39 132.22,154.62 132.22,147.31 126.01,141.09 125.23,141.09 125.07,140.94 125.07,140.5 124.77,140.2 124.35,140.2 124.05,140.5 124.05,141.19 123.89,141.34 123.67,141.34 123.51,141.19 123.51,140.49 123.25,140.22 122.72,140.22 121.16,141.78 121.16,142.36 120.35,143.17 120.35,144.13 121.02,144.8 121.02,145.21 120.76,145.46 v3(120.29,145.46)
  BOTTOM w0.127: U19.T26 136.58,156.7 136.19,156.32 135.09,156.32 134.91,156.13 134.91,156.05 v3(135.09,155.87) ; v3(120.29,145.46) 120.29,145.57 119.81,146.05 VRAM4.F3
VMA_ZQ1: length 5.1
  TOP w0.127: R22.2 127.1,167.4 v2(126.87,167.4) 126.44,166.97 125.26,166.97 124.98,166.69 124.2,166.69 123.86,166.34 VRAM1.L8
VMA_ZQ2: length 5.4
  BOTTOM w0.127: VRAM3.L8 118.36,165.96 117.74,165.96 117.64,166.06 116.77,166.06 v2(115.63,164.92) 114.99,164.28 R419.2
VMA_ZQ3: length 5.2
  TOP w0.127: R41.2 115.35,151.33 v2(115.37,151.3) 116.51,150.16 117.48,150.16
  TOP w0.133: 117.48,150.16 117.78,150.45 118.34,150.45 VRAM2.L8
VMA_ZQ4: length 5
  BOTTOM w0.127: 126.37,148.61 126.88,148.1 127.43,148.1 R443.2
  BOTTOM w0.14: 126.37,148.61 125.61,149.37 124.82,149.37 124.54,149.65 124.21,149.65 123.81,150.05 VRAM4.L8
VR_SVID_ALERT#: length 49.1
  BOTTOM w0.127: R521.2 88.13,103.62 R520.2 86.48,103.62 86.16,103.29 86.16,102.51 85.37,101.71 81.62,101.71 79.66,103.68 69.78,103.68 63.89,97.78 53.95,97.78 50.52,101.21 v2(50.17,101.21) 48.82,99.86 48.82,98.98 48.24,98.4 PR111.2 PR116.2
VR_SVID_CLK: length 47.5
  BOTTOM w0.127: PR115.2 PR112.2 46.78,98.45 47.25,98.93 47.25,100.3 v2(48.05,101.1) 48.79,101.83 50.74,101.83 54.21,98.37 63.64,98.37 69.54,104.26 79.91,104.26 81.87,102.3 85.12,102.3 R524.2
VR_SVID_DATA: length 50.4
  BOTTOM w0.127: PR110.2 50.19,97.02 PR117.2 49.21,98.32 50.23,99.33 v2(50.75,99.33) 51.57,99.33 54.06,96.84 54.06,96.02 54.25,95.83 54.52,95.83 54.72,96.02 54.72,97.03 54.89,97.2 55.13,97.2 55.3,97.03 55.3,95.95 55.48,95.78 55.73,95.78 55.91,95.95 55.91,96.99 56.1,97.17 56.36,97.17 56.54,96.99 56.54,96.33 56.74,96.13 57.01,96.13 57.21,96.33 57.21,97 57.41,97.2 64.13,97.2 70.02,103.09 79.38,103.09 81.34,101.13 84.75,101.13 85.46,100.42 R534.2
VREFC_VMA1: length 18.5
  TOP w0.127: 124.87,165.94 125.03,165.94
  TOP w0.178: VRAM1.M8 123.95,165.94 124.87,165.94
  TOP w0.508: 125.03,165.94 125.78,165.94 126.27,165.46 v2(126.27,164.41) 126.27,163.54 125.59,162.86 v3(125.59,162.69)
  BOTTOM w0.203: 115.98,164.3 116.82,165.14 118.33,165.14 118.73,165.54 VRAM3.M8
  BOTTOM w0.508: 115.98,164.3 115.85,164.17 115.85,162.88 115.08,162.11 R424.2 C364.1 114.34,161.21 R428.1 115.7,160.72 116.21,161.23 v3(117.2,161.23)
VREFC_VMA3: length 18.1
  TOP w0.203: VRAM2.M8 118.49,150.85 118.08,151.26 117.01,151.26
  TOP w0.508: 117.01,151.26 116.48,151.26 v3(116.26,151.48) 115.63,152.11 115.63,152.67 v2(115.37,152.93) 114.8,153.49 C70.1 R40.2 113.44,154.66 R37.1
  IN1 w0.191: 119.76,150.8 119.76,150.06 120.06,149.76 121.58,149.76 121.6,149.78 121.94,149.78 121.95,149.77 122.36,149.77 123.84,151.25 v3(123.95,151.25)
  IN1 w0.508: v3(116.26,151.48) 116.44,151.29 119.27,151.29 119.76,150.8
  BOTTOM w0.254: v3(123.95,151.25) VRAM4.M8
VREFD_VMA1: length 11.8
  TOP w0.305: v3(116.61,169.23) 117.47,169.23 VRAM1.H1
  TOP w0.508: v2(115.76,169.23) v3(116.61,169.23)
  IN1 w0.254: v3(124.77,169.17) 124.07,168.47 122.73,168.47 122.59,168.61 118.12,168.61 117.72,169 116.83,169 v3(116.61,169.23)
  BOTTOM w0.305: VRAM3.H1 v3(124.77,169.17)
VREFD_VMA3: length 20
  TOP w0.254: v3(125.43,148.05) 125.43,147.9 125.08,147.54 124.45,147.54 VRAM2.H1
  IN1 w0.191: 118.93,150.12 119.2,150.12 120,149.32 120,148.68 120.8,147.87 121.26,147.87 121.47,147.67 121.99,147.67 122.89,148.57 125.01,148.57 125.43,148.14 v3(125.43,148.05)
  IN1 w0.508: v3(117.41,148.16) 117.41,149.46 118.07,150.12 118.93,150.12
  BOTTOM w0.305: VRAM4.H1 117.92,147.65 v3(117.41,148.16)
  BOTTOM w0.508: R442.2 C376.1 114.34,147.74 R447.1 115.27,146.5 v3(115.37,146.6) 116.93,148.16 v3(117.41,148.16)
VRON: length 244.5
  TOP w0.127: v3(177.64,48.82) 177.93,48.54 180.71,48.54 182.51,50.33 U13.69 ; PR131.2 47.37,87.39 42.75,87.39 42.47,87.67 41.91,87.67 41.56,87.32 41.56,86.33 41,85.77 38.66,85.77 v2(37.04,84.14) v3(36.05,83.15)
  IN1 w0.133: v3(36.05,83.15) 34.67,81.77 34.67,73.07 33.85,72.25 33.85,65.71 33.43,65.3 33.43,63.71 32.15,62.43 32.15,50.8 32.88,50.07 32.88,41.59 38.71,35.76 38.71,35.11 45.03,28.8 45.03,28.24 45.74,27.53 45.74,23.04 46.1,22.68 46.1,20.46 51.01,15.55 76.11,15.55 84.4,23.83 135.45,23.83 148.37,36.75 148.37,39.67 151.1,42.41 152.79,42.41 154.35,43.98 154.67,43.98 155.83,45.14 157.94,45.14 158.87,44.21 163.83,44.21 165.01,45.39 166.2,45.39 166.63,45.83 166.63,46.38 167.11,46.85 176.26,46.85 177.64,48.24 v3(177.64,48.82)
  BOTTOM w0.127: v3(177.64,48.82) 175.05,48.82 R681.1
VSYNC: length 182.5
  IN2 w0.133: v3(165.4,122.9) 164.05,124.25 161.74,124.25 160.61,125.38 155.47,125.38 153.6,127.25 150.83,127.25 145.64,132.43 138.33,132.43 136.02,134.74 132.26,134.74 131.5,133.98 120.34,133.98 119.77,133.42 115.44,133.42 113.26,135.6 102.47,135.6 99.82,132.95 97.1,132.95 95,130.85 93.11,130.85 83.47,121.22 82.36,121.22 69.14,107.99 60.17,107.99 59.44,108.72 57.23,108.72 55.09,110.87 52.67,110.87 52.11,110.3 45.01,110.3 44.41,109.7 24.64,109.7 23.46,110.88 23.25,110.88 21.59,109.23 20.44,109.23 19.89,108.68 19.89,108.45 20.19,108.15 20.19,107.94 20.05,107.79 19.84,107.79 19.56,108.07 19.33,108.07 19.17,107.9 19.17,107.67 19.5,107.34 19.5,107.12 19.34,106.96 19.12,106.96 18.83,107.25 18.61,107.25 18.46,107.09 18.46,106.87 18.81,106.52 18.81,106.3 18.65,106.14 18.43,106.14 17.99,106.59 17.8,106.59 17.45,106.24 v3(17.45,106.01)
  BOTTOM w0.102: R472.1 167.93,119.04 167.93,120.41 165.74,122.6 165.69,122.6
  BOTTOM w0.127: v3(17.45,106.01) 14.81,106.01 14.8,106 14.62,106 14.38,106.24 U22.2 ; 165.69,122.6 165.4,122.89 v3(165.4,122.9)
WLAN#: length 7.3
  BOTTOM w0.127: TP156.1 170.63,62.04 170.03,61.44 168.85,61.44 168.29,60.88 168.29,60.62 ; 168.29,60.62 168.7,60.21 CN10.42 ; 168.29,60.62 167.9,60.23 CN10.44
