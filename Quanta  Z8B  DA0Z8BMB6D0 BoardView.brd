# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCC_SENSE: length 86
  IN2 w0.133: v3(99.37,125.8) 99.44,125.73 99.58,125.59 99.58,125.31 99.25,124.99 98.44,124.99 97.36,123.9 96.41,123.9 91.35,118.84 90.53,118.84 85.89,114.2 84.75,114.2 71.31,100.76 54.83,100.76 53.3,102.29 47.66,102.29 47.41,102.04 40.42,102.04 38.43,100.05 37.36,100.05 35.42,98.11 v3(35.41,98.11)
  BOTTOM w0.127: PR130.1 37.73,98.6 PC91.1 ; PC91.1 38.03,97.15 38.03,96.9 38.72,96.21 PR125.2 ; PC91.1 37.27,97 36.33,97 36,97.33 36,97.53 v3(35.41,98.11) ; v3(99.37,125.8) 99.32,125.75 99.32,125.11 99.25,125.05 R455.1
VCC_SENSE_R: length 8.6
  BOTTOM w0.127: R455.2 99.05,123.8 99.05,123.1 R460.1 99.12,122.09 99.12,120.62 99.79,119.95 99.79,117.08 U27.AL35
VCC_XD: length 7.8
  TOP w0.508: v3(30.36,20.37) 30.87,19.86 CN1.4 34.08,15.79 v3(34.83,15.79)
  BOTTOM w0.508: v3(30.36,20.37) 30.8,19.93 C539.1
VCCRTC_3: length 3.3
  TOP w0.635: R243.2 170.36,78.18 v2(170.39,78.2) 171.4,79.22 Q30.3
VCCRTC_4: length 1.4
  TOP w0.635: R242.2 168.17,77.26 R243.1
VDD10: length 1
  TOP w0.203: U7.30 25.03,97.74 24.92,97.63 v3(24.89,97.63)
  vias: v2(25.81,96.59) v3(27.41,101.54) v3(27.36,95.09) v3(29.85,95.69)
VDD18: length 3.8
  BOTTOM w0.127: U32.18 28.24,13.94 28,14.19 27.16,14.19 26.98,14.01 C551.2 26.73,14.39 C547.1
VDDREG/VDD33:
  vias: v2(30.15,103.02) v3(27.41,102.2)
VIN: length 277.4
  TOP w0.127: PR2.1 193.23,179.55 195.53,179.55 195.86,179.22 PR1.2
  TOP w0.254: PR163.1 178.34,133.6 v3(178.34,133.78)
  TOP w0.508: 40.31,46.63 32.52,46.63 31.82,45.93 29.99,45.93 28.27,47.64 28.27,48.61 29.24,49.57 PR145.1 ; PR197.1 110.61,134.81 107.24,138.17 v3(107.24,138.17) ; PR43.1 46.82,57.45 46.33,56.97 v3(45.98,56.97) ; v3(171.19,145.53) 169.48,145.53 168.54,146.47 167.75,146.47 165.97,148.25 164.38,148.25 PR203.1
  TOP w5.08: 100.74,140.4 100.74,134.97 96.78,131.01 95.06,131.01 75.89,111.83 70.51,111.83 70.51,111.84
  IN1 w0.508: v3(44.3,50.01) 44.3,55.29 v3(45.98,56.97)
  IN2 w0.254: v3(176.2,142.79) 176.97,142.03 176.97,140.12 178.34,138.76 178.34,133.79 v3(178.34,133.78)
  IN2 w0.508: 41.99,41.88 41.99,34.87 46.36,30.5 46.36,30.24 52.27,24.33 53.77,24.33 55.69,26.24 67.56,26.24 70.1,28.78 71.49,28.78 73.22,27.05 77.1,27.05 78.21,28.16 113.35,28.16 114.46,27.05 122.1,27.05 v3(122.33,27.28)
  BOTTOM w0.508: 122.66,18.89 122.21,19.34 122.21,27.16 v3(122.33,27.28) ; 123.25,17.75 129.24,11.76 PR213.1 130.46,11.16 PR215.1 ; PR61.1 122.45,8.39 PR65.1 120.58,10.25 119.49,10.25 119.18,10.56 119.18,11.58 120.58,12.97 121.87,12.97 122.32,13.42 122.32,16.01 120.68,17.65
  BOTTOM w5.08: 70.01,111.58 74.2,111.58 93.54,130.92 96.34,130.92 100.64,135.22 100.64,139.11
  vias: v1(41.15,44.93) v1(41.23,43.43) v1(41.41,42.36) v1(43.38,44.95) v1(43.38,43.5) v1(44.45,41.83) v1(45.04,83.46) v1(45.06,84.37) v1(45.09,82.37) v1(45.09,81.35) v1(45.06,80.38) v1(46,84.42) v1(45.98,83.51) v1(46.03,82.42) v1(46.03,81.4) v1(46,80.43) v1(50.78,44.44) v1(50.8,43.58) v1(54.11,44.37) v1(54.92,44.42) v1(55.81,44.39) v1(61.52,110.46) v1(62.28,110.46) v1(63.04,110.46) v1(63.8,110.46) v1(64.57,110.49) v1(65.07,111.19) v1(65.43,110.46) v1(65.83,111.19) v1(66.22,112.08) v1(66.19,110.46) v1(97.56,142.69) v1(97.56,141.93) v1(97.56,141.17) v1(98.07,144.21) v1(98.07,143.45) v1(98.45,142.69) v1(98.45,141.93) v1(98.45,141.17) v1(98.96,144.21) v1(98.96,143.45) v1(168.66,183.61) v1(168.71,182.85) v1(169.85,183.99) v1(171.02,183.69) v1(172.67,183.18) v1(180.65,145.81) v1(180.76,185.47) v1(180.81,184.68) v1(180.81,183.89) v1(180.81,183.13) v1(181.41,148.81) v1(181.41,145.13) v1(181.51,146.7) v1(181.58,185.98) v1(181.63,185.19) v1(181.63,184.4) v1(181.63,183.64) v1(181.63,182.85) v1(181.56,145.92) v1(183.19,150.01) v1(184.26,150.01) v1(186.01,149.12) v1(186.01,144.7) v1(186.8,144.67) v1(187.58,144.67) v1(188.37,144.67) v1(193.39,178.59) v1(195.58,177.87) v1(196.28,177.57) v1(196.97,177.89) v1(197.95,178.73) v1(197.95,177.95) v2(40.29,43.88) v3(38.03,110.61) v3(38.69,110.58) v3(39.37,110.58) v3(40.03,110.58) v3(108.84,166.67) v3(108.87,166.01) v3(108.89,165.35) v3(108.89,164.58) v3(138.46,187.95) v3(138.84,188.49) v3(138.84,187.39) v3(191.06,133.01) v3(191.06,132.35) v3(191.72,133.01) v3(191.75,132.35) v3(192.43,133.04) v3(192.49,132.35)
VSS_SENSE: length 85.6
  IN2 w0.133: v3(100.13,125.8) 99.97,125.64 99.97,125.15 99.41,124.6 98.6,124.6 97.52,123.52 96.57,123.52 91.51,118.46 90.69,118.46 86.05,113.81 84.91,113.81 71.47,100.37 54.67,100.37 53.14,101.91 47.82,101.91 47.57,101.65 40.58,101.65 38.59,99.66 37.52,99.66 35.91,98.05 35.91,97.85 v3(35.41,97.35)
  BOTTOM w0.127: v3(100.13,125.8) 100.01,125.8 99.72,125.52 99.72,125.17 R456.2 ; PR123.2 37.98,95.09 PC94.1 37.75,94.86 37.75,96.03 PR134.2 37.17,96.61 36.17,96.61 35.82,96.96 35.8,96.96 v3(35.41,97.35)
VSS_SENSE_R: length 8.6
  BOTTOM w0.127: U27.AK35 100.02,117.06 100.02,120.04 99.35,120.72 99.35,122.13 R461.2 99.43,123.05 99.43,123.85 R456.1
1.5GFX_DRVH: length 15.2
  IN2 w0.762: v1(136.81,184.78) 136.81,189.07 135.95,189.93 127.48,189.93 v1(127.18,190.24)
  BOTTOM w0.127: v2(127.16,191.03) 127.18,191 v1(127.18,190.24)
1.5GFX_DRVL: length 4.4
  IN2 w0.762: v1(125.84,187.88) 126.29,187.42 128.07,187.42 v1(128.88,188.23)
  BOTTOM w0.127: v2(126.57,187.62) 126.32,187.88 v1(125.84,187.88)
1.5GFX_EN: length 3.3
  TOP w0.254: PU11.3 121.27,189.58 PC139.2 120.99,189.22 120.05,188.28 PR32.2
1.5GFX_FB: length 3.9
  TOP w0.254: PU11.4 122.13,189.08 PR87.1 120.87,188.16 119.92,187.22 PR97.2
1.5GFX_SW:
  vias: v1(133.74,183.79) v1(133.76,182.9) v1(134.5,183.76) v1(134.55,182.9) v1(135.28,183.74) v1(135.31,182.87) v2(131.02,182.34)
1.5GFX_TRIP: length 1.9
  TOP w0.254: PU11.2 121.2,190.08 PR31.2
1.5GFX_TST: length 3.2
  TOP w0.254: PU11.5 122.25,188.58 121.98,188.31 v3(121.98,187.9)
  BOTTOM w0.254: PR96.2 v3(121.98,187.9)
1.5GFX_VBST:
  vias: v3(127.11,191.03)
2ND_MBCLK: length 197.6
  TOP w0.127: v3(169.08,70.66) 169.27,70.47 169.68,70.47 170.84,69.31 172.62,69.31 172.86,69.55 173.62,69.55 174.04,69.13 174.04,67.84 R331.1 174.35,67.27 174.35,63.7 174.43,63.62 U13.115 ; v3(156.7,173.53) 156.06,172.89 Q3.3 ; U1.8 165.33,176.77 165.48,176.91 165.58,176.91 v3(165.83,176.66) ; Q27.1 178.2,88.31 178.79,87.72 178.79,87.6 178.83,87.55 179.48,86.91 179.48,85.88 179.21,85.61 v3(179.21,85.61)
  IN1 w0.133: v3(169.08,70.66) 169.26,70.47 169.54,70.47 169.64,70.57 169.64,70.89 168.93,71.59 168.93,72.16 169.24,72.46 169.24,77.42 177.25,85.44 178.63,85.44 178.8,85.61 v3(179.21,85.61) 179.78,86.18 179.78,87.38 180.18,87.78 181.32,87.78 184.61,91.08 186,91.08 188.8,93.87 188.8,97.8 189.35,98.36 189.35,106.86 190.32,107.84 190.32,110.78 187.35,113.75 187.35,115.65 186.21,116.79 186.21,118.24 185.47,118.98 185.47,121.87 185.77,122.17 185.77,122.3 v3(185.55,122.52)
  IN2 w0.133: v3(156.7,173.53) 157.43,172.79 161.51,172.79 164.54,175.82 165.78,175.82 166.42,176.45 166.42,176.85 166.35,176.91 166.08,176.91 v3(165.83,176.66) 165.59,176.9 165.23,176.9 164.85,177.28 164.85,178.03 165.96,179.15 167.38,179.15 168.15,178.38 171.68,178.38 173.51,176.55 178.19,176.55 178.6,176.14 180.42,176.14 180.83,176.55 190.36,176.55 194.26,172.65 194.26,168.8 194.95,168.12 194.95,164.42 195.54,163.83 195.54,123.33 192.76,120.55 192.76,120.21 191.62,119.06 189.5,119.06 189.29,119.27 187.21,119.27 185.8,120.68 185.8,122.27 v3(185.55,122.52)
2ND_MBDATA: length 197.6
  TOP w0.127: Q29.1 178.39,84.55 178.84,84.99 v3(178.84,85.03) ; v3(169.08,69.99) 169.31,70.22 169.57,70.22 170.73,69.06 172.73,69.06 172.96,69.29 173.51,69.29 173.78,69.02 173.78,67.84 R330.1 174.12,66.61 174.12,63.67 174.03,63.58 U13.116 ; Q3.6 154.26,171.59 154.59,171.27 v4(154.59,170.66) ; v3(165.83,177.42) 165.58,177.17 165.5,177.17 165.25,177.42 U1.7
  IN1 w0.133: v3(169.08,69.99) 169.3,70.21 169.65,70.21 169.9,70.46 169.9,71 169.19,71.71 169.19,72.05 169.5,72.35 169.5,77.31 177.36,85.18 178.68,85.18 v3(178.84,85.03) 178.84,85.03 178.95,85.15 179.4,85.15 179.67,85.42 179.67,85.51 180.04,85.88 180.04,87.27 180.28,87.52 181.43,87.52 184.72,90.82 186.11,90.82 189.06,93.77 189.06,97.7 189.61,98.25 189.61,106.75 190.58,107.73 190.58,110.89 187.61,113.86 187.61,115.76 186.47,116.9 186.47,118.35 185.73,119.09 185.73,121.77 186.03,122.07 186.03,122.25 v3(186.31,122.52)
  IN2 w0.133: v4(154.59,170.66) 154.66,170.66 156.54,172.53 161.62,172.53 164.64,175.56 165.89,175.56 166.68,176.35 166.68,176.95 166.46,177.17 166.08,177.17 v3(165.83,177.42) 165.57,177.16 165.34,177.16 165.11,177.39 165.11,177.93 166.07,178.89 167.28,178.89 168.04,178.12 171.57,178.12 173.4,176.29 178.09,176.29 178.5,175.88 180.53,175.88 180.94,176.29 190.25,176.29 194,172.54 194,168.69 194.69,168.01 194.69,164.31 195.28,163.72 195.28,123.44 192.5,120.66 192.5,120.32 191.51,119.32 189.61,119.32 189.4,119.53 187.32,119.53 186.06,120.79 186.06,122.27 v3(186.31,122.52)
27M_XTAL_IN_R: length 12.7
  BOTTOM w0.127: Y2.3 153.21,176.61 153.21,175.55 152.63,174.97 152.33,174.97 152.08,174.72 C353.2 152.08,173.3 v3(151.72,172.94) 151.72,172.93 149.41,170.61 149.41,168.54 149.53,168.42 149.53,167.81 U19.C11
27M_XTAL_OUT: length 10
  BOTTOM w0.127: Y2.1 154.32,175.87 153.33,174.88 C354.2 153.33,173.84 v3(153.32,173.83) 153.32,173.81 149.64,170.12 149.64,168.78 150.01,168.41 U19.B10
1658R-BOOT1: length 1
  BOTTOM w0.127: PR160.2 187.81,141.9 v3(187.56,142.16)
1658R-BOOT2: length 1.5
  BOTTOM w0.127: v3(180.14,142.44) 181.06,141.52 PR175.2
1658R-COMP: length 4.7
  TOP w0.127: PC123.1 179.97,138.91 v3(180.55,138.91)
  BOTTOM w0.127: v3(180.55,138.91) 179.97,138.91 PC123.1 180.23,139.37 PU10.12
1658R-EN: length 4.4
  TOP w0.127: PR121.2 v3(188.99,139.91)
  BOTTOM w0.127: v3(188.99,139.91) PR121.2 188.45,139.26 v3(188.02,139.69) 187.94,139.77 PU10.3
1658R-FB: length 4.7
  BOTTOM w0.203: PU10.11 182.06,138.97
  BOTTOM w0.254: 182.06,138.97 v3(181.44,138.35) 180.84,137.75 PC130.1 179.99,137.74 179.94,137.69 179.15,137.69 179.09,137.75 PR180.2
1658R-FBRTN: length 5.6
  BOTTOM w0.127: PR181.2 180.75,136.59 180.75,136.98 v3(180.83,137.05) 181.23,137.46 183.6,137.46 183.73,137.59 PU10.10
1658R-LGATE1: length 14.1
  IN2 w0.762: v1(187.73,155.59) 187.74,155.59 187.74,152.14 185.14,149.55 185.14,143.91 185.5,143.55 v1(185.5,142.74)
  vias: v3(186.21,142.84)
1658R-LGATE2: length 10.9
  IN2 w0.762: v1(179.27,150.61) 181.28,150.61 183.29,148.61 183.29,142.99 v1(183.62,142.66)
1658R-OCS/CB: length 8.1
  TOP w0.127: v3(181.1,136.21) 180.9,136.02 PR165.2 ; PR165.2 v2(179.98,135.38) ; PR165.2 PR159.1
  BOTTOM w0.127: PU10.9 184.13,137.61 183.6,137.08 181.61,137.08 181.1,136.56 v3(181.1,136.21) PR161.2
1658R-PG: length 4.8
  TOP w0.127: PR169.1 180.24,140.15 v3(180.55,140.45)
  BOTTOM w0.127: v3(180.55,140.45) 180.15,140.45 PR171.1 180.22,139.82 v3(180.83,139.82) 180.88,139.77 PU10.13
1658R-PHASE1: length 13.8
  TOP w0.508: PR168.1 v1(191.24,160.77) ; v1(185.9,141.8) 187.35,141.8 PC114.2
  IN2 w0.762: v1(185.9,141.8) 187.61,141.8 189.89,144.09 189.89,148.38 v1(191.11,149.6)
  vias: v2(194.52,156.13)
1658R-PHASE2: length 21
  TOP w0.508: PR183.1 v1(175.49,160.77) ; v1(180.82,142.66) 181.33,142.16 PC125.2
  IN2 w0.762: v1(180.82,142.66) 177.65,142.66 173.79,146.53 173.79,150.08 173.33,150.54 v1(173.33,156.3)
  vias: v2(172.7,149.12)
1658R-PSI: length 3.4
  BOTTOM w0.127: PU10.4 187.08,139.37 187.08,139.36 v3(188.02,138.42) 188.32,138.12 PR166.2
1658R-PVCC:
  vias: v3(184.51,142.87)
1658R-REFADJ: length 3.6
  BOTTOM w0.127: v3(186.39,136.92) 185.45,135.98 PR172.1 185.33,136.08 PU10.6
1658R-REFIN: length 6
  TOP w0.127: PR178.1 183.06,136.04 v2(183.06,137) 183.21,137.15 184.23,137.15 v3(184.56,136.82) 184.56,136.1 PR174.2
  BOTTOM w0.127: PC121.2 184.3,136.57 v3(184.56,136.82) 184.93,137.19 PU10.7
1658R-UGATE1: length 11.5
  IN2 w0.762: v3(193.02,149.52) 191.25,147.75 191.25,143.46 188.17,140.38 v1(187.78,140.38)
1658R-UGATE2: length 9.9
  IN2 w0.762: v1(179,148.89) 179,146.22 181.84,143.37 181.84,140.84 v1(181.38,140.38)
1658R-VID: length 4.2
  BOTTOM w0.127: PU10.5 187,138.97 187.46,138.51 187.46,137.71 v3(188.02,137.15) 188.19,136.98 PR167.2
1658R-VREF: length 7.1
  TOP w0.127: v3(183.7,136.62) 183.7,135.8 PR170.1
  BOTTOM w0.127: v3(181.89,136.34) 181.88,136.32 PR161.1 182.15,135.5 182.61,135.97 PC119.2 183.16,136.08 v3(183.7,136.62) 184.53,137.46 PU10.8
24707_LX: length 3
  TOP w0.508: v1(163.55,185.74) 163.55,186.68 163.81,186.94 163.81,187.78
  BOTTOM w0.254: PU1.19 161.45,186.11
  vias: v1(167.62,186.68) v1(168.38,187.42) v1(168.36,186.4) v1(168.74,185.72) v1(169.4,185.36) v2(170.16,185.29)
24737_ACDET: length 4.7
  TOP w0.254: PR10.2 155.96,184.35 v3(156.29,184.68)
  BOTTOM w0.254: v3(156.29,184.68) 155.88,184.27 155.28,184.27 PR11.2 155.23,184.61 155.88,185.26 156.29,185.26 156.64,185.61 PU1.6
24737_ACN: length 38.8
  TOP w0.254: v3(160.57,183.31) 160.79,183.09 PC8.1 ; v3(191.64,179.63) 192.06,179.63 PR2.2
  IN2 w0.254: v3(191.64,179.63) 191.64,179.45 190.78,178.59 175.07,178.59 172.49,181.17 164.97,181.17 163.78,182.37 161.08,182.37 160.49,182.96 160.49,183.22 v3(160.57,183.31)
  BOTTOM w0.254: PU1.1 159.9,184.02 160.43,183.49 160.43,183.45 v3(160.57,183.31) 160.57,183.22 160.86,182.93 PC11.2
24737_ACP: length 42.8
  TOP w0.254: PC7.2 159.44,182.79 v3(159.92,183.28) ; PR5.2 191.96,180.2 191.59,180.2 v3(191.52,180.27)
  IN2 w0.254: v3(159.92,183.28) 159.82,183.18 159.82,182.75 160.59,181.97 163.61,181.97 164.81,180.78 172.33,180.78 174.91,178.2 190.94,178.2 192.16,179.42 192.16,179.85 191.74,180.27 v3(191.52,180.27)
  BOTTOM w0.127: PC11.1 v3(159.39,181.27)
  BOTTOM w0.254: PU1.2 159.4,183.67 159.79,183.28 v3(159.92,183.28) 159.81,183.17 159.81,182.66 PC11.1
24737_BM#: length 51
  TOP w0.254: v3(157.13,188.33) 157.13,188.31 157.74,187.7 v3(157.76,187.7) 159.97,187.7 160.38,187.29 PQ8.2 ; PR25.1 191.73,188.54 v3(191.24,189.02)
  IN2 w0.254: v3(157.13,188.33) 157.13,185.89 157.73,185.3 161.51,185.3 163.22,183.58 164.06,183.58 165.41,182.23 172.93,182.23 174.63,180.54 176.05,180.54 176.31,180.79 181.64,180.79 183.24,182.39 183.24,187.83 184.15,188.74 187.1,188.74 188.01,189.65 190.62,189.65 v3(191.24,189.02)
24737_BST: length 3.5
  BOTTOM w0.254: PU1.17 161.16,187.11 161.85,187.8 v3(162.95,187.8) PR16.2
24737_CMPIN: length 47.5
  TOP w0.254: v3(196.11,174.31) 196.01,174.31 195.65,173.95 PR41.2 ; PR36.2 157.02,182.49 157.55,183.02 v3(157.55,183.21)
  IN2 w0.254: v3(157.55,183.21) 159.18,181.58 163.45,181.58 164.66,180.37 167.89,180.37 168.62,179.63 172.92,179.63 174.74,177.81 191.71,177.81 193.36,176.16 194.26,176.16 v3(196.11,174.31)
  BOTTOM w0.254: PR42.1 157.27,182.86 157.55,183.14 v3(157.55,183.21) 157.55,183.27 158.4,184.12 PU1.4
24737_CMPOUT: length 20.8
  TOP w0.254: v3(158.35,183.29) 158.35,182.79 158.17,182.61 PR26.1
  IN2 w0.254: v3(158.35,183.29) 157.89,183.75 156.23,183.75 155.43,182.95 149.71,182.95 148.72,181.96 v3(148.72,181.91)
  BOTTOM w0.254: PU1.3 158.9,183.85 158.62,183.56 158.62,183.55 v3(158.35,183.29) 158.05,182.99 PR42.2 ; PQ9.2 147.81,181.91 v3(148.72,181.91) 148.72,181.81 149.19,181.34 149.74,181.34 150.64,180.43 PR191.2
24737_DH: length 0.7
  BOTTOM w0.254: 161.29,186.61 PU1.18
  vias: v1(164.7,186.35) v3(161.98,186.81)
24737_DL: length 5.6
  IN2 w0.762: v1(164.8,190.06) 164.8,189.86 163.45,188.51 160.96,188.51 v1(160.23,189.25)
  vias: v3(164.47,191.15)
24737_ILIM: length 15
  TOP w0.254: v3(152.09,181.5) 151.62,181.98 151.62,182.54 155.4,186.33 155.4,187.79 PR33.2 155.52,189.49 v3(155.73,189.71)
  BOTTOM w0.254: v3(155.73,189.71) 155.74,189.7 PR34.2 155.74,188.72 155.23,188.21 PC25.2 155.45,187.61 PU1.10 ; PR28.1 151.89,181.3 v3(152.09,181.5)
24737_REGN: length 4.8
  TOP w0.254: PD4.2 v3(160.73,190.12)
  BOTTOM w0.254: v3(160.73,190.12) 160.82,190.12 162.06,188.89 PC12.1 161.1,187.61 PU1.16
24737_SRN: length 33.5
  TOP w0.254: v3(156.21,190.71) 156.72,190.2 PC24.2 157.15,189.87 PC23.1
  IN1 w0.254: v3(156.21,190.71) 156.81,191.31 165.89,191.31 167.11,190.09 174.83,190.09 176,188.92 176,181.58 v3(176.13,181.45)
  BOTTOM w0.127: v3(176.13,181.45) 175.9,181.68 175.9,182.03 176.04,182.18 PR24.1
  BOTTOM w0.254: v3(156.21,190.71) 156.71,191.2 PR210.1
24737_SRP: length 30.1
  TOP w0.127: v3(159.01,190.47) 159.26,190.21 v3(159.26,189.88)
  TOP w0.254: PC23.2 158.79,189.14 158.32,189.6 PC21.2 158.75,190.2 v3(159.01,190.47)
  IN1 w0.254: v3(159.01,190.47) 159.45,190.91 165.73,190.91 167.09,189.55 174.81,189.55 175.61,188.75 175.61,181.56 v3(175.47,181.43)
  BOTTOM w0.127: v3(175.47,181.43) 175.59,181.55 175.59,182.03 175.45,182.18 PR23.1
  BOTTOM w0.254: v3(159.01,190.47) 158.37,191.11 PR209.1
24737_VCC: length 14
  TOP w0.254: PR13.2 153.69,186.44 v3(152.99,187.14)
  IN2 w0.254: v3(160.56,184.07) 160.45,184.07 160.38,184.14 155.99,184.14 v3(152.99,187.14)
  BOTTOM w0.254: v3(160.56,184.07) 160.56,184.12 161.12,184.68 PC10.2 162.08,184.96 161.7,185.34 161.35,185.34 161.08,185.61 PU1.20
51216_DRVH: length 10.7
  IN2 w0.762: v1(55.07,34.82) 55.07,41.25 v1(52.02,44.29)
  vias: v3(55.76,34.64)
51216_DRVL: length 6.9
  TOP w0.127: v2(53.37,32.43) v1(52.58,32.43)
  IN2 w0.762: v1(52.58,32.43) 52.1,32.43 51.28,33.24 v1(51.28,37.71)
51216_MODE: length 6
  TOP w0.127: v3(57.94,29.53) 58.58,30.17 58.58,30.91 PR80.2
  BOTTOM w0.127: v3(57.94,29.53) 57.81,29.53 57.18,28.9 v3(56.95,28.9) 56.72,29.13 56.72,29.86 56.18,30.4 PU5.19
51216_REF: length 6
  TOP w0.203: v3(48.45,30.79) 49.05,30.79 PC68.1
  BOTTOM w0.203: PU5.6 v2(50.66,30) 50.02,30 PR84.1 49.46,30.57 49.24,30.79 v3(48.45,30.79)
51216_REFIN: length 7.7
  TOP w0.203: PR86.1 49.5,31.51 v3(48.46,31.51) 48.36,31.62 48.36,31.94 49.03,32.61 PC69.1
  BOTTOM w0.203: PU5.8 50,30.8 PR84.2 48.63,31.35 v3(48.46,31.51)
51216_S3: length 4.5
  BOTTOM w0.127: PU5.17 56.67,31.2 PR85.2 57.54,30.69 58.44,29.8 58.44,29.38 PR77.1
51216_S5: length 5.2
  BOTTOM w0.127: PR78.1 59.08,30.04 57.65,31.47 PR85.1 57.05,31.6 PU5.16
51216_SW: length 11.2
  TOP w0.508: PR82.1 59.97,40.68 v1(59.97,40.15) ; PC64.2 56.08,34.25 v1(56.08,35.35)
  IN2 w0.762: v1(59.97,40.15) 57.48,40.15 56.08,38.75 v1(56.08,35.35)
  vias: v3(54.51,35.4)
51216_TRIP: length 3.5
  TOP w0.127: v3(57.17,29.52) 57.29,29.52 58,30.23 PR81.2
  BOTTOM w0.127: PU5.18 56.28,30.8 57.17,29.91 v3(57.17,29.52)
51216_VBST: length 1.1
  BOTTOM w0.127: v3(56.04,32.81) 56.04,33.24 PR79.1
51225_CS1: length 2.1
  TOP w0.127: PU3.1 40.03,61.08 v3(39.81,61.31)
  BOTTOM w0.127: PR57.2 39.43,61.69 v3(39.81,61.31)
51225_CS2: length 2.2
  TOP w0.127: v3(39.45,58.39) 39.83,58.39 40.03,58.59 PU3.5
  BOTTOM w0.127: PR58.2 38.77,58.39 v3(39.45,58.39)
51225_DH1: length 14
  IN2 w0.762: v1(43.28,61.79) 43.28,67.71 46.23,70.66 v1(49.3,70.66)
  BOTTOM w0.127: v1(43.28,61.79) 42.52,61.79 v2(42.5,61.82)
51225_DH2: length 15.6
  TOP w0.127: v1(48.36,46.14) 48.36,46.9 v2(48.37,46.91)
  IN2 w0.762: v1(48.36,46.14) 46.74,46.14 43.26,49.63 v1(43.26,57.93)
51225_DL1: length 7.4
  IN2 w0.762: v1(44.07,60.85) 44.07,60.93 46.2,63.06 v1(46.2,66.54)
  BOTTOM w0.127: v1(44.07,60.85) 43.54,60.85 v2(43.31,60.62)
51225_DL2: length 9.1
  TOP w0.127: v2(49.51,53.23) v1(49.51,54.02)
  IN2 w0.762: v1(44.07,58.87) 44.4,58.87 45.04,58.24 45.04,56.79 47.81,54.02 v1(49.51,54.02)
51225_EN1: length 3
  TOP w0.127: v2(38.69,63.06) 38.85,62.9 PR45.1 40.73,61.77 PU3.20
51225_FB1: length 4.3
  TOP w0.127: PR50.1 37.98,61.11 v2(37.98,61.44)
  TOP w0.203: PU3.2 38.83,60.26 PR50.1 38.85,60.8 v3(39.22,60.8)
  BOTTOM w0.127: PR54.1 38.85,60.8 v3(39.22,60.8)
51225_FB2: length 2.8
  TOP w0.203: PU3.4 39.43,59.46 39.32,59.35
  TOP w0.254: PR52.2 38.57,58.09 PR55.1 39.32,59.35
51225_SW1: length 21.5
  TOP w0.508: PR53.1 53.78,71.65 v2(53.78,72.76) 53.78,73.75 v3(53.7,73.83)
  IN2 w0.762: v1(42.24,63.85) 42.24,68.19 47.88,73.83 v3(53.7,73.83)
  BOTTOM w0.508: v1(42.24,63.85) 42.24,62.96 PC38.2
51225_SW2: length 23.5
  TOP w0.508: PR51.1 52.5,47.41 v3(52.73,47.19)
  IN2 w0.762: v3(52.73,47.19) 51.49,45.94 49.46,45.94 48.65,45.13 46.44,45.13 42.27,49.3 v1(42.27,55.85)
  BOTTOM w0.508: PC37.1 42.27,56.86 v1(42.27,55.85)
  vias: v3(41.56,56)
51225_VBST1: length 2.9
  TOP w0.127: v2(43.03,63.8) 43.03,63.44 PR49.2
  TOP w0.203: PU3.17 41.93,62.34 PR49.2
51225_VBST2: length 2.9
  TOP w0.127: PR48.1 43.06,56.28 v2(43.06,55.97)
  TOP w0.203: PR48.1 41.93,57.4 PU3.9
51225_VCLK: length 1.9
  TOP w0.127: PU3.19 41.13,62.24 40.8,62.58 PR56.1
51225_VIN: length 4.2
  TOP w0.203: PU3.12 44.71,59.46 v3(44.96,59.71) 45.04,59.71 45.36,59.39 PC33.2
  TOP w0.508: PC33.2 45.36,57.74 PR43.2
51631_ALERT#: length 2.8
  BOTTOM w0.127: PU7.32 46.21,94.88 46.59,95.27 v3(47.27,95.27) 47.27,95.5 PR116.1
51631_B-RAMP: length 5.3
  TOP w0.127: v2(45.7,87.95) 45.7,88.46 v3(45.9,88.66)
  TOP w0.191: PR101.1 46.31,89.07 v3(45.9,88.66)
  BOTTOM w0.191: PU7.11 45.41,88.05 PR91.2 45.71,88.04 45.9,88.23 v3(45.9,88.66)
51631_CLK: length 2
  BOTTOM w0.127: PR115.1 46.52,95.73 45.81,95.02 PU7.31
51631_COMP: length 6.8
  BOTTOM w0.191: PU7.26 43.81,95.32
  BOTTOM w0.254: 43.81,95.32 43.81,95.53 43.49,95.85 v3(43.49,96) 43.29,96.21 PR192.2 43.09,96.99 42.29,97.79 PR128.2 41.64,98.22 PC90.2 40.9,99.49 PR132.1
51631_CSN1: length 34.6
  TOP w0.127: PR107.2 63.7,86.1 62.71,87.09 v3(62.71,87.67)
  IN2 w0.133: v3(62.71,87.67) 62.53,87.86 62.53,88.19 62.29,88.44 55.84,88.44 55,87.6 49.06,87.6 48.13,88.53 48.13,88.75 46.75,90.14 41.03,90.14 v3(40.09,91.08)
  BOTTOM w0.127: PR114.1 64.74,86.84 PR109.2 63.55,86.84 v3(62.71,87.67)
  BOTTOM w0.191: PU7.18 42.08,91.63 41.31,90.86 41.3,90.86 PC87.2 40.56,90.43 40.47,90.52 PC89.1 39.59,90.58 v3(40.09,91.08)
51631_CSN2: length 37.9
  TOP w0.127: PR184.2 66.18,89.28 v3(66.17,89.27)
  IN2 w0.133: v3(40.31,91.69) 40.31,92.19 40.49,92.37 40.92,92.37 42.65,90.65 48.47,90.65 51.24,87.88 54.89,87.88 55.72,88.71 65.83,88.71 66.17,89.05 v3(66.17,89.27)
  BOTTOM w0.127: v3(40.31,91.69) PC158.1 ; PR212.1 67.28,88.33 PR211.2 66.85,87.9 66.67,87.9 66.53,88.05 66.53,88.59 66.17,88.95 v3(66.17,89.27)
  BOTTOM w0.191: PU7.19 41.74,92.03 41.46,91.75 PC157.2 40.48,92.22 40.15,92.22 PC158.1
51631_CSN3: length 3
  TOP w0.127: PR135.1 v2(42.29,94.33)
  TOP w0.191: v3(41.56,93.41) PR135.1
  BOTTOM w0.191: v3(41.56,93.41) 41.99,93.41 42.18,93.23 PU7.22
51631_CSP1: length 35.3
  TOP w0.127: PR106.2 62.56,86.53 62.03,87.06 v3(62.03,87.67)
  IN2 w0.133: v3(40.09,89.99) 40.21,89.86 46.64,89.86 47.86,88.64 47.86,88.41 48.95,87.32 55.1,87.32 55.94,88.16 62.16,88.16 62.26,88.05 62.26,87.9 v3(62.03,87.67)
  BOTTOM w0.127: v3(62.03,87.67) 62.03,87.98 62.23,88.18 62.97,88.18 63.53,87.62 PR109.1 64.66,87.62 PR108.1
  BOTTOM w0.191: PU7.17 42.14,91.23 41.41,90.49 41.41,89.91 41.14,89.65 PC87.1 40.58,89.35 PC86.1 39.59,89.49 v3(40.09,89.99)
51631_CSP2: length 37.6
  TOP w0.127: PR127.2 65.46,89.82 v3(65.46,89.3)
  IN2 w0.133: v3(40.21,93.24) 40.21,92.78 40.35,92.65 41.04,92.65 42.76,90.92 48.58,90.92 51.34,88.16 54.78,88.16 55.61,88.98 65.14,88.98 v3(65.46,89.3)
  BOTTOM w0.127: PC156.1 39.61,92.98 39.87,93.24 v3(40.21,93.24) ; PR196.1 67.23,87.17 PR211.1 66.74,87.65 66.57,87.65 66.27,87.94 66.27,88.49 v3(65.46,89.3)
  BOTTOM w0.191: PU7.20 42.19,92.43 42.11,92.34 41.14,92.34 PC157.1 40.81,92.68 39.79,92.68 PC156.1
51631_CSP3: length 3
  TOP w0.127: PR136.2 40.92,91.46 v2(41,91.38)
  TOP w0.191: PR136.2 41.25,92.24 v3(41.84,92.83)
  BOTTOM w0.191: PU7.21 v3(41.84,92.83)
51631_DATA: length 3.6
  BOTTOM w0.127: PU7.1 47.43,94.03 v3(48.54,95.14) 49.21,95.81 PR117.1
51631_DROOP: length 6.3
  BOTTOM w0.127: v3(38.92,97.43) 38.93,97.44 PC93.1
  BOTTOM w0.191: PU7.25 43.41,95.17
  BOTTOM w0.254: PC93.1 PC90.1 41.33,97.01 PR128.1 42.07,96.51 43.41,95.17
51631_F-IMAX: length 4.1
  TOP w0.191: v3(46.61,88.66) 47.34,89.39 PR100.1
  BOTTOM w0.191: PU7.10 45.81,89.65 v3(46.21,89.25) ; v3(46.61,88.66) 46.54,88.59 PR90.2
  BOTTOM w0.203: v3(46.21,89.25) 46.61,88.84 v3(46.61,88.66)
51631_GFB: length 2.9
  BOTTOM w0.127: PU7.23 42.23,93.63 41.63,94.23 v3(41.43,94.23) 41.43,94.76 41.11,95.09 PR123.1
51631_IMON: length 5.7
  TOP w0.127: v3(43.68,88.56) 43.16,88.04 v2(43.16,88)
  TOP w0.191: PC92.1 43.68,89.13 v3(43.68,88.56)
  BOTTOM w0.191: PR129.1 43.68,87.85 v3(43.68,88.56) 43.68,88.89 44.61,89.81 PU7.13
51631_O-USR: length 6
  TOP w0.191: PR99.1 48.38,89.37 47.51,88.5 v3(47.35,88.5)
  BOTTOM w0.127: v2(48.65,87.88) 48.63,87.86 PR89.2
  BOTTOM w0.178: v3(47.35,88.5) 47.73,88.11 PR89.2
  BOTTOM w0.191: PU7.9 46.21,90.21 47.35,89.07 v3(47.35,88.5)
51631_OCP-I: length 5.6
  TOP w0.127: v3(44.86,88.61) 44.43,88.18 v2(44.43,88)
  TOP w0.191: v3(44.86,88.61) 45.14,88.9 PR133.1
  BOTTOM w0.191: v3(44.86,88.61) 44.86,88.61 44.86,88.28 44.59,88.01 PR129.2 44.3,88.9 45.01,89.6 PU7.12
51631_PWM1: length 11.9
  BOTTOM w0.191: PU7.6 48.61,92.03 v3(48.95,91.69) 49.13,91.5 51.22,91.5 51.73,90.99 51.73,85.22 51.95,85.01 PU6.8
51631_PWM2: length 11.3
  BOTTOM w0.191: PU7.5 49.07,92.43 49.51,91.99 51.59,91.99 52,92.4 ; PU12.8 54.23,93.85 v3(53.78,94.3)
  BOTTOM w0.203: 52,92.4 52,94.4 52.35,94.76 53.32,94.76 v3(53.78,94.3)
51631_PWM3: length 3.4
  BOTTOM w0.178: PU7.4 47.48,92.83
  BOTTOM w0.254: 47.48,92.83 48.85,92.83 v3(49,92.98) 49.58,92.98 PR193.1
51631_SKIP#: length 28.8
  TOP w0.191: PR119.1 48.01,91.48 v3(47.96,91.43)
  IN1 w0.508: v3(56.11,85.51) 56.11,87.16 58.35,89.4 58.35,92.85 v3(59.42,93.93)
  IN2 w0.508: v3(47.96,91.43) 48.83,91.43 51.62,88.64 54.61,88.64 55.71,89.73 58.7,89.73 59.31,90.34 59.31,93.82 v3(59.42,93.93)
  BOTTOM w0.191: v3(47.96,91.43) 47.77,91.63 PU7.7
51631_SLEWA: length 6.4
  TOP w0.127: PR102.1 41.46,88.38 v2(41.41,88.33)
  TOP w0.191: PR102.1 42.13,89.37 v3(42.14,89.38)
  BOTTOM w0.191: PR92.2 40.82,88.31 41.89,89.38 v3(42.14,89.38) 43.24,89.38 43.81,89.95 PU7.15
51631_THERM: length 28.9
  TOP w0.191: PC78.1 42.72,89.31 v3(42.72,88.62)
  IN2 w0.254: v3(42.72,88.62) 43.37,87.97 46.14,87.97 48.84,85.27 48.84,83.34 51.59,80.59 54.69,80.59 56.71,78.57 58.06,78.57 59.31,79.83 v3(59.49,79.83)
  BOTTOM w0.191: PU7.14 44.21,89.87 42.97,88.62 v3(42.72,88.62) 43.13,88.21 PR103.2
  BOTTOM w0.254: PR93.1 58.9,79.36 59.36,79.83 v3(59.49,79.83)
51631_V5A: length 1.3
  TOP w0.127: v2(43.16,95.32) 43.82,95.98 PC79.1
  vias: v3(44.89,96.13)
51631_VBAT: length 5.3
  BOTTOM w0.191: PU7.16 43.41,90.08 43.18,89.86 42.83,89.86 42.7,89.99 v3(41.91,89.99) 41.91,89.86 40.02,87.96 PR95.2
51631_VDD: length 6.8
  BOTTOM w0.127: v3(51.72,95.19) 51.34,95.19 PR88.1
  BOTTOM w0.178: PU7.2 47.51,93.63
  BOTTOM w0.254: 47.51,93.63 47.77,93.63 49.04,94.9 PC154.1 49.96,95.65 PR88.1
51631_VFB: length 3.5
  BOTTOM w0.127: PR125.1 41.03,96.21 v3(41.76,95.47) 42.16,95.08 42.16,94.06 42.19,94.03 PU7.24
51631_VREF: length 51.3
  TOP w0.254: v3(40.82,86.43) v2(39.96,86.43) 39.17,86.43 38.17,87.43 38.17,93.51 43.87,99.21 v3(43.9,99.21)
  IN2 w0.254: v3(46.79,86.43) 48.44,84.78 48.44,83.18 51.43,80.19 54.53,80.19 56.55,78.17 58.22,78.17 59.2,79.16 v3(59.45,79.16)
  BOTTOM w0.178: 44.02,95.9 44.21,95.72 PU7.27
  BOTTOM w0.254: 44.02,95.9 44.02,97.4 43.66,97.77 PR192.1 43.28,97.77 43.07,97.98 PC77.1 43.27,99.21 v3(43.9,99.21) ; v3(40.82,86.43) PR92.1 41.29,87.21 41.81,86.68 45.04,86.68 45.42,87.06 PR91.1 PR90.1 46.8,87.26 46.98,87.08 PR89.1 47.73,86.89 47.27,86.43 v3(46.79,86.43) ; v3(59.45,79.16) 59.68,78.93 PR93.2
51631_VRON: length 7.8
  TOP w0.191: PR98.2 49.92,89.32 49.92,88.51 v2(49.56,88.16) 49.08,87.67 PR131.1 48.43,88.29 v3(48.72,88.59)
  BOTTOM w0.178: PR120.1 47.69,90.71 47.17,91.23 PU7.8
  BOTTOM w0.191: v3(48.72,88.59) 48.72,89.26 PR195.2 48.44,89.56 PR120.1
+AZA_VDD: length 19.7
  TOP w0.203: 32.5,32.96 32.2,32.66 U15.1
  TOP w0.508: 32.5,32.96 32.96,33.42 C302.1 C303.1 34.48,34.23 34.79,34.53 R346.1 v3(35.31,35.27)
  BOTTOM w0.508: v3(33,25.01) 33,25.78 32.11,26.66 31.68,26.66 31.07,27.27 31.07,29.46 31.65,30.04 32.52,30.04 33.74,31.26 v2(33.74,33.65) 33.74,34.47 R690.1 34.75,34.71 v3(35.31,35.27)
+DDR_VTT_RUN: length 80.3
  IN1 w1.524: 60.07,24.69 68.82,24.69 78.35,34.22 84,34.22 84.86,33.37 95.07,33.37 96.04,32.4 112.66,32.4 113.48,33.22 115.55,33.22 116.27,32.5 131.78,32.5 134.09,34.82
  vias: v2(56.49,25.55) v3(56.45,24.57) v3(57.16,24.56) v3(57.55,25.19) v3(57.85,24.55) v3(137.65,60.17) v3(137.68,59.51) v3(137.83,47.58) v3(137.85,46.46) v3(138.03,37.97) v3(138.06,52) v3(138.06,51.11) v3(138.09,39.36) v3(138.09,38.67)
+FB_PLLAVDD: length 1.8
  BOTTOM w0.305: U19.P22 140.03,158.32 v3(140.43,157.92)
  BOTTOM w0.381: v3(144.62,164.58) 145.04,165 U19.F16 ; U19.H22 140.04,163.3 v3(140.48,163.74)
  vias: v2(133.96,141.75) v3(133.79,139.08) v3(134.42,139.52) v3(134.4,138.83)
+G_SEN_PW: length 8.3
  TOP w0.254: U16.14 113.68,15.86 R365.2 ; 115.47,9.18 113.68,10.96 U16.8 ; U16.1 110.25,13.9 v2(110.06,13.71) 109.59,13.71 R366.2
  vias: v2(116.99,8.12) v3(109.2,15.13) v3(114.58,15.87) v3(117.64,10.31)
+PCH_VCCDSW: length 12.8
  TOP w0.254: v3(162.47,90.96) 162.47,90.68 161.99,90.21 R210.2
  IN1 w0.254: v3(162.47,90.96) 162.51,91.01 162.51,92.6 163.9,93.99 163.9,94.93 164.47,95.5 164.47,100.93 v3(164.34,101.06)
  BOTTOM w0.254: U24.U14 164.34,100.98 v3(164.34,101.06)
+SM_VREF: length 7.1
  TOP w0.381: 98.39,81.27 94.57,77.45 R246.2
  BOTTOM w0.254: v3(97.93,84.16) 97.93,84.22 U27.AM3
  vias: v2(95,68.17)
+SMDDR_VREF_DIMM:
  vias: v2(94.44,37.99) v3(94.21,37.15) v3(94.87,37.13) v3(114.1,40.22) v3(114.35,49.48) v3(114.35,50.14)
+SMDDR_VREF_DQ0:
  vias: v2(75.03,46.63) v3(72.17,46.32) v3(72.57,45.76)
+SMDDR_VREF_DQ1:
  vias: v2(75.9,59.1) v3(73.99,58.47)
+TPVDD:
  vias: v2(166.48,18.2)
+VGPU_CORE: length 29.1
  TOP w0.254: 173.49,164.46 172.06,163.03 172.06,142.26 v3(173.31,141.01)
  BOTTOM w0.254: PR185.2 176.46,137.86 v3(173.31,141.01)
  vias: v1(173.82,168.17) v1(174.43,167) v1(174.83,168.17) v1(174.91,162.96) v1(174.88,162.2) v1(175.34,166.97) v1(175.75,162.98) v1(175.72,162.17) v1(175.85,168.37) v1(176.36,167) v1(176.74,168.34) v1(177.8,166.06) v1(177.78,164.81) v1(178.03,168.39) v1(178.72,166.06) v1(178.74,164.86) v1(179.07,168.37) v1(179.73,162.5) v1(179.79,163.42) v1(180.16,169.28) v1(180.16,167.91) v1(181.03,162.43) v1(181.06,163.34) v1(181.76,169.21) v1(181.76,167.91) v1(182.93,167.91) v1(182.98,169.26) v1(184.35,170.17) v1(184.35,169.23) v1(184.35,167.96) v1(185.02,163.39) v1(184.97,162.48) v1(185.65,170.17) v1(185.65,169.28) v1(185.75,167.99) v1(186.24,163.39) v1(186.21,162.48) v1(187.05,169.31) v1(187.1,167.91) v1(188.09,166.31) v1(188.09,165.32) v1(188.07,164.36) v2(190.68,164.71) v3(142.37,162.83) v3(143.13,160.72) v3(143.19,156.84) v3(143.19,154.84) v3(143.25,158.92) v3(144.22,161.82) v3(144.25,153.92) v3(145.11,154.83) v3(145.19,160.84) v3(145.21,158.86) v3(145.19,156.84) v3(146.28,153.89) v3(147.12,158.79) v3(147.14,156.81) v3(148.19,161.79) v3(148.19,159.84) v3(148.24,157.88) v3(148.26,155.87) v3(148.58,153.71) v3(149.1,156.75) v3(151.38,160.34) v3(151.39,158.21) v3(151.36,156.38) v3(151.39,154.53)
+VREF_CA_CPU: length 33
  TOP w0.508: R335.1 91.94,39.35 92.33,39.74 92.33,51.66 91.6,52.39 v2(91.6,63.34) 91.6,64.79 92.54,65.73 Q39.3 92.54,69.44 92.26,69.72 R267.2
+VREFDQ_SA_CPU: length 32.5
  TOP w0.508: Q36.1 130.3,71.82 132.01,71.82 132.69,71.14 R269.1 132.95,74.75 132.36,75.33 v2(132.36,76.9) 132.36,76.91 132.36,96.52 131.09,97.79
  BOTTOM w0.254: v3(124.93,98.15) 124.46,97.69 U27.F16
+VREFDQ_SA_M3: length 126.3
  TOP w0.508: v3(141.35,72.4) 140.39,71.44 v2(138.33,71.44) 134.72,71.44 R269.2 132.06,68.78 Q36.3 ; R309.1 73.38,52.72 v3(72.98,53.13)
  IN2 w0.508: v3(141.35,72.4) 141.2,72.25 141.2,60.24 139.7,58.74 139.55,58.74 136.74,55.93 136.74,45.89 137.3,45.33 137.3,44.63 136.28,43.6 136.28,41.04 134.8,39.56 121.66,39.56 116.93,34.83 112.85,34.83 112.35,34.33 92.57,34.33 92.14,34.76 84.55,34.76 81.82,37.49 80.43,37.49 78.24,39.69 78.24,45.65 72.98,50.91 v3(72.98,53.13)
+VREFDQ_SB_CPU: length 29.4
  TOP w0.508: Q35.1 124.21,70.81 R268.1 123.85,71.72 v2(129.32,77.18) 131.73,79.59 131.73,93.6 130.89,94.44
  BOTTOM w0.254: v3(124.93,95.16) 124.46,94.69 U27.F13
+VREFDQ_SB_M3: length 161.5
  TOP w0.508: v3(142.09,71.68) 140.97,70.55 135.74,70.55 v2(134.73,69.54) 132.9,67.71 129.49,67.71 128.43,68.78 Q35.3 124.77,68.78 R268.2 ; R286.2 75.13,66.8 72.06,69.87 v3(71.56,69.87)
  IN2 w0.508: v3(142.09,71.68) 142.09,50.74 139.08,47.73 139.08,45.14 137.16,43.22 137.16,40.67 135.16,38.67 122.03,38.67 117.3,33.94 113.21,33.94 112.72,33.44 92.2,33.44 91.77,33.87 84.18,33.87 81.45,36.6 80.06,36.6 78.25,38.42 77.42,38.42 75.03,40.82 75.03,44.83 67.73,52.13 67.73,59.23 69.14,60.64 69.14,67.78 71.24,69.87 v3(71.56,69.87)
+WL_VDD: length 10.3
  IN1 w1.016: 171.2,45.76 171.28,45.84 181.09,45.84 181.35,46.1
  vias: v2(188.75,61.54) v3(164.06,62.63) v3(164.09,61.97) v3(169.66,45.79) v3(170.31,45.84) v3(176.2,61.31) v3(176.2,60.65) v3(184.1,46.11) v3(184.59,45.66) v3(188.76,60.57)
A_LAD0_R: length 4.6
  BOTTOM w0.127: R665.1 186.37,63.27 185.91,62.81 185.91,62.23 185.53,61.84 v3(185.53,61) 185.5,60.98 CN10.8
A_LAD1_R: length 5.7
  BOTTOM w0.127: v3(184.87,64.15) 184.87,62.71 185.16,62.41 R670.1 184.99,62.07 184.92,62.07 184.45,61.6 184.45,60.41 184.7,60.16 CN10.10
A_LAD2_R: length 3.3
  BOTTOM w0.127: R669.1 183.9,62.12 v3(183.9,61.44) CN10.12
A_LAD3_R: length 5.3
  BOTTOM w0.127: v3(182.45,64.18) 182.58,64.05 182.58,62.73 182.9,62.41 R668.1 183.05,61.8 183.1,61.75 CN10.14
A_LFRAME#_R: length 3.4
  BOTTOM w0.127: CN10.16 v3(182.3,61.44) 182.3,62.02 R667.1
AC_PROTECT: length 204
  TOP w0.127: v3(181.58,56.89) 181.74,56.73 U13.85
  IN1 w0.133: v3(159,183.21) 159,182.8 159.9,181.9 170.08,181.9 170.09,181.89 172.61,181.89 174.15,180.35 176.95,180.35 178.61,182.01 182.88,182.01 183.51,182.64 183.51,188.82 183.22,189.11 183.22,189.65 184.18,190.61 187.95,190.61 188.64,189.92 191.18,189.92 192.13,188.97 192.13,183.41 194.77,180.77 194.77,175.57 195.16,175.19 195.16,173.23 197.35,171.03 197.35,140.47 196.24,139.36 196.24,127.94 195.47,127.17 195.47,124.46 191.85,120.84 191.85,119.85 191.85,115.62 196.27,111.19 196.27,89.48 195.17,88.37 193.58,88.37 188.91,83.7 187.02,83.7 183.45,80.13 183.45,73.76 182.83,73.13 182.83,68.52 183.4,67.96 183.4,65.36 181.98,63.94 181.98,63.69 182.79,62.88 182.79,58.1 v3(181.58,56.89)
  BOTTOM w0.127: v3(159,183.21) 158.65,182.86 158.65,180.09 158.4,179.84 PR191.1
ACCEL_INTA: length 126.1
  TOP w0.127: U13.68 184.12,49.93 184.79,50.6 186.93,50.6 v3(187.96,49.57) ; v3(123.75,15) 122.05,16.71 D18.1 117.81,16.71 117.12,16.02 C334.2
  IN1 w0.133: v3(187.96,49.57) 190.23,47.31 190.23,18.44 185.92,14.13 185.34,14.13 184.15,12.95 180.01,12.95 176.09,9.04 173.11,9.04 171.69,10.45 171.69,12.57 170.33,13.94 169.12,13.94 166.03,17.03 159.09,17.03 153.52,22.59 151.25,22.59 150.8,22.14 148.81,22.14 147.3,20.64 136.45,20.64 130.74,14.93 123.83,14.93 v3(123.75,15)
ACCEL_INTA_R: length 5.2
  TOP w0.127: U16.11 v2(118.42,12.9) 118.83,13.3 D18.2
ACIN: length 211.2
  TOP w0.127: PR12.1 192.56,185.9 192.91,185.54 v3(192.96,185.54) ; U13.72 184.13,51.53 184.51,51.15 187.71,51.15 188.24,51.69 188.24,52.97 v3(188.35,53.08)
  IN1 w0.133: v3(156.89,183.21) 157.44,183.76 159.13,183.76 159.39,183.5 159.46,183.43 159.46,182.74 159.62,182.58 160.03,182.17 170.2,182.17 170.2,182.17 172.89,182.17 174.41,180.64 176.76,180.64 178.41,182.28 182.75,182.28 183.24,182.76 183.24,188.62 182.9,188.96 182.9,189.72 184.06,190.88 188.09,190.88 188.78,190.19 191.44,190.19 192.52,189.11 192.52,185.98 v3(192.96,185.54) 192.96,182.97 195.04,180.88 195.04,175.69 195.43,175.3 195.43,173.34 197.66,171.11 197.66,140.02 196.61,138.97 196.61,127.54 196.5,127.42 196.5,127.41 195.8,126.71 195.8,124.4 192.12,120.72 192.12,119.97 192.12,119.97 192.12,115.73 196.56,111.3 196.56,89.38 195.22,88.04 193.72,88.04 189.08,83.39 187.1,83.39 184.29,80.58 184.29,76.41 187.43,73.27 187.43,65.55 188.18,64.8 188.18,64.06 190.45,61.79 190.45,53.92 189.61,53.08 v3(188.35,53.08)
  BOTTOM w0.127: PQ6.3 156.2,181.66 156.65,182.11 156.65,182.97 156.89,183.21 v3(156.89,183.21)
ACPRESENT: length 142.9
  TOP w0.127: R200.1 171.9,89.57 v3(171.99,89.48) 171.99,89.48 v3(173.14,88.33)
  IN1 w0.133: v3(173.14,88.33) 173.8,87.67 176.54,87.67 179.74,90.87 180.8,90.87 182.76,92.84 183.99,92.84 184.72,92.11 185.56,92.11 187.38,93.92 187.38,101.14 188.31,102.07 188.31,107.14 186.14,109.32 186.14,111.8 185.66,112.28 185.66,114.65 183.9,116.41 183.9,118.27 182.78,119.39 181.24,119.39 180.45,118.6 178.78,118.6 178.4,118.98 177.4,118.98 176.24,120.14 176.24,121.46 175.88,121.82 175.88,125.44 174.3,127.03 174.3,135.65 172.21,137.74 171.33,137.74 168.31,140.76 168.13,140.76 167.75,141.13 167.75,144.4 169.19,145.83 169.19,149.36 168.3,150.25 168.3,156.79 169.4,157.89 169.4,158.91 169.67,159.17 169.67,161.87 168.82,162.72 168.82,168.2 168.46,168.56 168.46,172.18 168.71,172.43 168.71,173.81 168.36,174.16 167.26,174.16 165.86,175.56 163.75,175.56 161.88,177.43 159.52,177.43 155.47,181.48 153.65,181.48 152.48,182.65 150.76,182.65 150.04,181.92 v3(150.04,181.91)
  BOTTOM w0.127: PR18.2 151.34,185.53 PR17.1 150.14,184.33 150.14,182.03 150.04,181.92 v3(150.04,181.91)
ACZ_SDIN: length 2.3
  TOP w0.127: U15.8 29.4,32.66 29.57,32.84 29.57,33.57 29.24,33.9 R345.2
ADOGND: length 24.3
  TOP w0.203: v3(34.55,26.05) 34.55,26.36 33.68,27.22 U15.38 ; U15.25 27.49,25.93 27.4,26.02 v3(27.13,26.02)
  TOP w0.254: v3(25.05,28.17) 24.72,27.84 Q44.1 ; v3(22.86,24.28) 23.25,24.28 23.42,24.45 Q44.4
  TOP w0.381: v3(38.76,23.51) 39.09,23.18 R361.2 ; v3(14.79,10.19) 15.2,10.6 R370.2 ; v3(4.31,11.14) 4.04,11.4 C371.2 ; C319.2 R353.2 v3(23.39,30.17) ; C324.1 35.08,25.36 34.55,25.9 v3(34.55,26.05) ; R359.1 35.58,24.2 35.58,24.21 v3(35.94,24.56) ; R350.1 25.25,32.32 v3(25.31,32.26) ; v3(36.88,25.94) 36.98,26.04 C322.2 ; R356.1 38.97,25.47 v3(38.84,25.34) ; R360.2 22.58,24.01 v3(22.86,24.28)
  TOP w0.508: v3(15.83,9.61) 15.83,9.61 16.55,9.61 R375.1 ; v3(12.96,9.54) 12.64,9.23 12.17,9.23 C340.1 ; v3(22.79,22.34) 22.55,22.34 R363.1 ; R364.1 35.46,22.44 v3(35.56,22.55) ; C316.1 v3(17.05,29.15) ; C329.2 D17.2 18.19,21.82 v3(18.18,21.81) ; v3(15.31,26.87) C344.2
  BOTTOM w0.381: v3(35.94,24.56) 35.96,24.59 C534.2 ; C532.2 36.61,26.21 v3(36.88,25.94)
  BOTTOM w0.508: R696.1 37.82,26.87 v3(37.52,27.17) ; v3(35.56,22.55) 36.25,22.55 C537.1
  vias: v1(1.24,13.54) v1(1.5,11.59) v1(5.87,14.12) v1(13.9,14.85) v1(14.33,21.13) v1(14.33,18.03) v1(14.38,23.89) v2(15.07,16.35) v3(7.86,12.67) v3(12.36,12.78) v3(26.5,21.86) v3(27.17,21.83) v3(27.85,21.84) v3(28.61,21.84) v3(29.43,21.84)
AMP_MUTE#: length 178.9
  TOP w0.127: v3(39.73,40.1) 38.89,40.1 v2(38.26,39.46) 36.83,38.04 D13.1 ; U13.108 v3(177.23,61.51)
  IN1 w0.133: v3(39.73,40.1) 39.73,39.75 42.31,37.16 42.31,36.35 44.76,33.9 45.72,33.9 47.63,32 48.65,32 49.13,31.51 49.13,24.71 52.51,21.33 75.93,21.33 83.78,29.18 137.12,29.18 145.18,37.25 145.18,40.19 151.18,46.19 153.92,46.19 155.31,47.57 160.77,47.57 161.08,47.87 162.91,47.87 163.7,48.66 164.74,48.66 167.07,50.99 173.84,50.99 177.26,54.41 177.26,56.7 177.01,56.95 177.01,61.29 v3(177.23,61.51)
BAT-V: length 3.3
  BOTTOM w0.127: PR20.2 176.31,185.62 176.05,185.36 176.05,183.24 PR24.2
  vias: v1(178.39,188.03) v1(178.79,187.32) v1(178.77,186.56) v1(178.77,185.79) v1(178.77,184.98) v1(178.79,184.19) v2(178.62,189.02)
BATLED0#: length 126.8
  TOP w0.203: U13.29 166.56,49.93 166.22,49.6
  TOP w0.254: 166.22,49.6 165.48,48.86 165.48,46.68 164.94,46.14 146.93,46.14 144.9,44.1 144.9,32.9 136.53,24.53 82.51,24.53 68.23,10.25 v2(68.23,9.7) 68.23,8.56 v3(68.23,8.55)
  BOTTOM w0.254: R719.1 v3(68.23,8.55) R724.1
BATLED1#: length 129.3
  TOP w0.203: 165.56,51.48 165.61,51.53 U13.25
  TOP w0.254: 165.56,51.48 165.31,51.23 152.51,51.23 150.14,48.86 148.09,48.86 v2(146.38,47.16) 144.12,44.9 144.12,33.2 136.21,25.29 82.19,25.29 66.45,9.55 66.45,8.88 v3(66.04,8.48)
  BOTTOM w0.254: v3(66.04,8.48) 66.77,9.2 R718.1 R723.1
BBS_BIT0: length 7.7
  BOTTOM w0.102: U24.AU2 156.62,95.51 156.62,95.01 156.65,94.98 156.65,91.53 155.33,90.21 R572.1 154.64,90.21 154.63,90.21 153.76,90.21 R571.1
BBS_BIT1: length 4.9
  TOP w0.102: v3(172.76,99.17) 172.81,99.22 173.36,99.22
  TOP w0.127: R146.1 174.74,99.85 174.11,99.22 173.36,99.22
  BOTTOM w0.102: U24.C10 171.08,99.17 171.39,99.47 171.71,99.47 171.91,99.27 172.65,99.27 v3(172.76,99.17)
BEEP_1: length 5.5
  TOP w0.127: C305.2 C304.1 R338.1 26.07,36.51 26.32,36.26 v3(26.32,35.65)
  BOTTOM w0.127: C304.1 26.32,35.51 v3(26.32,35.65) 25.86,36.11 v2(25.73,36.11)
BIOS_REC: length 4.7
  TOP w0.127: v3(154.57,96.14) 154.57,95.75 v2(154.18,95.37) 153.08,94.26 R175.1 R178.1
  BOTTOM w0.102: v3(154.57,96.14) 154.21,96.5 U24.BB4
BIOS_RESP: length 19.5
  BOTTOM w0.079: 158.25,95.26 158.25,95.26 158.47,95.48 158.47,95.7 158.14,96.03 U24.AN4
  BOTTOM w0.089: 158.25,95.26 158.25,92.85
  BOTTOM w0.102: 155.68,86.03 155.8,86.03 155.88,85.95 156.48,85.95 157.06,86.53 157.06,88.07 157.28,88.29 157.99,88.29 159.36,89.66 159.36,91.75 158.25,92.85
  BOTTOM w0.127: 155.68,86.03 155.34,86.03 155.1,85.79 155.1,85.25 R628.1 154.82,84.02 154.82,82.8 R637.1 153.9,81.88 v3(153.5,81.88)
BL#: length 5.6
  TOP w0.127: Q8.2 111.84,158.57 111.94,158.67 111.94,159.05 111.77,159.22 Q8.3 110.3,159.22 110.16,159.35 110.16,159.6 R30.1 111.03,161.38 v2(111.03,161.38)
BL_ON: length 35.5
  TOP w0.127: D1.2 109.29,155.79 109.1,155.59 108.03,155.59 107.95,155.52 107.06,155.52 Q9.3 106.83,157.16 R34.1 107.59,157.92 Q8.6 109.71,157.92 109.91,158.11 109.91,159.41 109.76,159.56 109.4,159.56 109.12,159.84 109.12,160.65 109.66,161.18 109.66,161.84 109.07,162.43 106.61,162.43 v2(106.25,162.78) 105.77,163.26 v3(105.72,163.26)
  BOTTOM w0.127: CN2.26 109.53,178.08 108.08,176.63 108.08,173.68 105.23,170.83 105.23,163.75 v3(105.72,163.26)
BOARD_ID0: length 24.6
  IN2 w0.089: v3(167.44,100.72) 167.84,101.12 168.98,101.12 168.99,101.12 169.66,101.12 169.97,100.81 170.44,100.81 170.76,101.14 170.76,101.41 172.29,102.94 176.29,102.94
  IN2 w0.133: 176.29,102.94 176.94,102.94 176.97,102.96 179.54,102.96 179.89,102.61 181.56,102.61 181.97,103.02 181.97,104.43 182.22,104.69 182.24,104.69 v3(182.24,104.69)
  BOTTOM w0.102: v3(167.44,100.72) 167.19,100.97 U24.L15
  BOTTOM w0.127: R508.1 185.16,107.05 183.94,107.05 R507.1 182.23,106.6 R509.1 182.55,106.02 182.55,105 182.24,104.69 v3(182.24,104.69)
BOARD_ID1: length 21
  IN2 w0.089: v3(166.79,100.72) 167.22,101.15 167.47,101.15 167.62,101.3 168.91,101.3 168.92,101.31 169.56,101.31 169.97,101.72 170.54,101.72 171.93,103.12 175.44,103.12 175.53,103.21 176.29,103.21
  IN2 w0.133: v3(181.56,104.69) 181.26,104.69 179.81,103.24 176.86,103.24 176.83,103.21 176.29,103.21
  BOTTOM w0.102: U24.M15 166.6,100.92 166.79,100.72 v3(166.79,100.72)
  BOTTOM w0.127: R515.1 183.38,104.77 R519.1 v3(181.74,104.08) 181.56,104.26 v3(181.56,104.69) 182.1,105.23 R514.1
BT_POWERON: length 28.7
  TOP w0.127: U13.104 v3(178.83,61.53)
  IN1 w0.133: v3(178.83,61.53) 178.83,57.65 177.71,56.53 177.71,54.47 173.95,50.72 167.18,50.72 164.85,48.39 163.81,48.39 162.81,47.39 v3(162.11,47.39)
  BOTTOM w0.127: R682.1 163.33,47.39 v3(162.11,47.39)
BT_PWRON_R: length 4.1
  BOTTOM w0.127: CN10.51 165.1,49.94 164.29,49.13 v3(164.29,48.15) 163.59,48.15 R682.2
BXTALOUT: length 11.1
  BOTTOM w0.127: U19.C10 150.42,167.85 150.42,168.35 150.75,168.69 150.96,168.69 151.17,168.9 151.17,169.46 151.99,170.28 151.99,170.65 154.26,172.92 155.25,172.92 v3(155.48,173.14) 155.48,173.32 157.05,174.9 R395.1
C_PEG_TX0: length 6
  BOTTOM w0.102: 121.8,119.14 121.8,116.79 121.7,116.69 U27.J35
  BOTTOM w0.127: C392.2 121.08,121.45 121.08,120.36 121.8,119.65 121.8,119.14
C_PEG_TX1: length 7.3
  BOTTOM w0.102: U27.G34 123.1,115.69 123,115.79 123,119.14
  BOTTOM w0.127: 123,119.14 123,119.31 123.55,119.86 123.55,120.16 v2(124.06,120.67) 123.55,121.18 123.55,121.42 C395.2
C_PEG_TX2: length 9.2
  IN2 w0.133: v3(126.12,120.66) 125.85,120.39 125.85,119.85 122.61,116.61 122.61,115.47 v3(122.9,115.19)
  BOTTOM w0.102: U27.H33 v3(122.9,115.19)
  BOTTOM w0.127: v3(126.12,120.66) 125.86,120.92 125.86,121.45 C397.2
C_PEG_TX3: length 11.6
  IN2 w0.102: v3(123.94,114.25) 123.64,114.25 123.54,114.35 123.54,114.5 123.7,114.67 124.54,114.67 124.82,114.95 124.84,114.95 124.86,114.97
  IN2 w0.133: 124.86,114.97 125.55,115.66 125.63,115.74 125.63,117.35 128.2,119.91 128.2,120.36 v3(128.45,120.61)
  BOTTOM w0.102: v3(123.94,114.25) 123.4,113.71 U27.G32
  BOTTOM w0.127: v3(128.45,120.61) 128.15,120.91 128.15,121.45 C399.2
C_PEG_TX4: length 15.2
  IN2 w0.102: v3(122.9,113.19) 122.7,113.19 122.48,113.4 122.48,113.53 122.57,113.62 124.61,113.62 124.72,113.52 125.19,113.52 125.2,113.51 125.22,113.51
  IN2 w0.133: 125.22,113.51 125.5,113.51 126.42,114.43 126.42,115.52 130.42,119.52 130.42,120.34 v3(130.68,120.61)
  BOTTOM w0.102: U27.H31 v3(122.9,113.19)
  BOTTOM w0.127: v3(130.68,120.61) 130.44,120.86 130.44,121.45 C401.2
C_PEG_TX5: length 16.1
  IN2 w0.102: v3(122.84,112.18) 123.08,112.18 123.26,112.37 123.26,112.61 123.45,112.79 124.56,112.79 124.69,112.92 125.22,112.92
  IN2 w0.133: v4(132.08,120.66) 132.35,120.4 132.35,119.91 129.29,116.85 129.29,116.52 127.49,114.72 125.69,112.92 125.22,112.92
  BOTTOM w0.102: U27.H30 122.4,111.75 v3(122.84,112.18)
  BOTTOM w0.127: C402.2 132.45,121.51 132.45,121.03 v4(132.08,120.66)
C_PEG_TX6: length 12.8
  BOTTOM w0.102: U27.B33 128.39,114.7 128.05,114.7 127.99,114.75 127.99,114.88 128.2,115.08 129.67,115.08 130.02,115.43 130.02,116.14 130.03,116.14 130.03,116.17
  BOTTOM w0.127: C405.2 135.03,121.45 135.03,120.99 134.73,120.68 134.13,120.68 133.1,119.65 131.5,119.65 130.03,118.18 130.03,116.17
C_PEG_TX7: length 11.8
  BOTTOM w0.102: U27.A32 128.96,113.69 128.89,113.76 128.89,113.93 129.04,114.09 131.12,114.09 131.13,114.08 131.15,114.08
  BOTTOM w0.127: 131.15,114.08 131.37,114.08 131.65,114.37 131.65,115.66 131.17,116.15 131.17,118.3 131.8,118.93 133.4,118.93 133.92,119.45 134.05,119.45 C411.2
C_PEG_TX#0: length 6
  BOTTOM w0.102: 122.01,119.14 122.01,119.13 122,119.12 122,116.79 122.1,116.69 U27.H35
  BOTTOM w0.127: C393.1 121.3,121.46 121.3,120.45 122.01,119.74 122.01,119.14
C_PEG_TX#1: length 7.3
  BOTTOM w0.102: 122.78,119.14 122.78,119.13 122.8,119.12 122.8,115.79 122.7,115.69 U27.H34
  BOTTOM w0.127: C394.2 123.33,121.48 123.33,121.21 v2(122.79,120.67) 123.33,120.12 123.33,119.95 122.78,119.4 122.78,119.14
C_PEG_TX#2: length 9.3
  IN2 w0.133: v3(121.9,115.19) 122.38,115.67 122.38,116.7 125.62,119.94 125.62,120.39 v4(125.36,120.66)
  BOTTOM w0.102: U27.J33 v3(121.9,115.19)
  BOTTOM w0.127: C396.2 125.65,121.46 125.65,120.95 v4(125.36,120.66)
C_PEG_TX#3: length 11.5
  IN2 w0.102: 124.7,115.13 124.68,115.11 124.68,115.1 124.46,114.87 123.62,114.87 123.34,114.59 123.34,114.43 123.15,114.25 v3(122.94,114.25)
  IN2 w0.133: 124.7,115.13 125.4,115.84 125.4,117.44 127.97,120.01 127.97,120.33 127.69,120.61 v4(127.69,120.62)
  BOTTOM w0.102: v3(122.94,114.25) 122.4,113.71 U27.H32
  BOTTOM w0.127: C398.2 127.94,121.45 127.94,120.86 v4(127.69,120.62)
C_PEG_TX#4: length 15.2
  IN2 w0.102: 125.22,113.73 125.2,113.73 125.19,113.72 124.8,113.72 124.69,113.83 122.49,113.83 122.28,113.62 122.28,113.4 122.06,113.19 v3(121.9,113.19)
  IN2 w0.133: 125.22,113.73 125.4,113.73 126.19,114.52 126.19,115.61 130.19,119.61 130.19,120.34 v4(129.92,120.61)
  BOTTOM w0.102: U27.J31 v3(121.9,113.19)
  BOTTOM w0.127: C400.2 130.22,121.45 130.22,120.91 v4(129.92,120.61)
C_PEG_TX#5: length 16.1
  IN2 w0.102: 125.22,112.69 125.21,112.69 125.2,112.71 125.14,112.71 125.13,112.72 124.77,112.72 124.65,112.59 123.55,112.59 123.47,112.51 123.47,112.37 123.65,112.18 v3(123.85,112.18)
  IN2 w0.133: v3(132.84,120.66) 132.58,120.4 132.58,119.81 129.52,116.75 129.52,116.42 125.79,112.69 125.22,112.69
  BOTTOM w0.102: U27.G30 123.4,111.73 v3(123.85,112.18)
  BOTTOM w0.127: C403.2 132.67,121.4 132.67,120.84 v3(132.84,120.66)
C_PEG_TX#6: length 12.8
  BOTTOM w0.102: U27.C33 127.78,114.69 127.79,114.7 127.79,114.96 128.11,115.28 129.59,115.28 129.82,115.51 129.82,116.21 129.81,116.22 129.81,116.23
  BOTTOM w0.127: 129.81,116.23 129.81,118.27 131.41,119.87 133.01,119.87 134.04,120.9 134.64,120.9 134.82,121.08 134.82,121.45 C404.2
C_PEG_TX#7: length 11.8
  BOTTOM w0.102: 131.15,114.3 131.13,114.3 131.12,114.29 128.96,114.29 128.68,114.02 128.68,113.83 128.54,113.69 U27.B32
  BOTTOM w0.127: 131.15,114.3 131.28,114.3 131.44,114.46 131.44,115.57 130.95,116.06 130.95,118.39 131.71,119.14 133.31,119.14 133.83,119.66 134.22,119.66 C410.2
CATERR#: length 9.6
  TOP w0.127: v3(96.92,114.27) 96.92,114.45 95.48,115.88 95.48,116.23 95.21,116.51 95.21,121.5 TP15.1
  BOTTOM w0.127: v3(96.92,114.27) 97.4,113.79 U27.AN32
CCD_PWR:
  vias: v3(112.15,174.92)
CFG0: length 18.4
  BOTTOM w0.102: 92.51,99.69 94.4,101.58 U27.AT20
  BOTTOM w0.127: v3(85.09,89.73) 85.13,89.69 R567.1 86.22,89.69 86.6,90.07 89.88,90.07 92.1,92.3 92.1,99.29 92.51,99.69
CFG1: length 15
  BOTTOM w0.102: U27.AR20 95.02,102.07 94.24,102.07 92.51,100.34
  BOTTOM w0.127: 92.51,100.34 91.75,99.58 91.75,92.68 v3(90.25,91.18) 89.81,90.74 R563.1
CFG2: length 10.5
  TOP w0.127: v3(95.95,102.13) v2(95.17,102.13) 94.14,102.13 91.7,99.69 R147.1 88.67,99.27 R152.1
  BOTTOM w0.102: v3(95.95,102.13) U27.AP20
CFG3: length 16.8
  BOTTOM w0.102: U27.AP22 96.02,104.07 94.2,104.07 93.38,103.25 93.38,101.57 92.51,100.69
  BOTTOM w0.127: 92.51,100.69 91.5,99.68 91.5,93.69 v3(90.25,92.45) 89.73,91.93 R561.1
CFG4: length 9.9
  TOP w0.127: v3(93.94,103.23) 93.59,103.23 91.4,101.04 90.46,101.04 v2(90.45,101.03) 90.45,101.04 R140.1 88.6,100.36 86.74,100.36 86.46,100.09 R148.1
  BOTTOM w0.127: U27.AT22 v3(93.94,103.23)
CFG5: length 12.6
  TOP w0.127: R141.1 87.07,101.43 88.31,102.67 88.91,102.67 R135.1 89.36,102.32 90.15,103.12 91.85,103.12 92.89,104.15 v2(94.44,104.15) v3(96.93,104.15)
  BOTTOM w0.127: U27.AN22 v3(96.93,104.15)
CFG6: length 6.7
  TOP w0.127: R115.1 88.53,106.07 89.31,106.85 R110.1 89.31,107.03 90.71,107.03 v2(90.71,107.03) 90.71,107.03 v3(93.79,107.03)
  BOTTOM w0.127: v3(93.79,107.03) 94.14,106.69 U27.AT25
CFG7: length 11.5
  TOP w0.127: R132.1 87.42,103.03 88.88,103.03 R131.1 91.49,103.47 93.18,105.15 95.76,105.15 v2(95.76,105.15) 95.77,105.15 v3(96.93,105.15)
  BOTTOM w0.127: U27.AN23 v3(96.93,105.15)
CFG8: length 6.8
  BOTTOM w0.102: 92.51,105.58 92.94,105.58 93.46,106.1 94.99,106.1 U27.AR24
  BOTTOM w0.127: R516.2 89.35,105.12 v3(89.95,105.12) 90.4,105.58 92.51,105.58
