# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ55: length 57.6
  IN1 w0.089: v3(129.93,88.16) 131.17,88.16 131.6,87.72
  IN1 w0.133: v3(129.07,43.69) 129.22,43.85 129.22,46.04 131.44,48.26 131.44,48.68 131.58,48.82 131.97,48.82 132.1,48.95 132.1,49.22 131.97,49.36 131.58,49.36 131.44,49.49 131.44,49.87 134.49,52.91 134.49,75.38 134.36,75.51 133.86,75.51 133.72,75.64 133.72,75.92 133.86,76.05 134.25,76.05 134.39,76.18 134.39,76.46 134.25,76.59 133.86,76.59 133.72,76.72 133.72,77 133.86,77.13 134.23,77.13 134.36,77.26 134.36,77.54 134.23,77.67 133.86,77.67 133.72,77.8 133.72,78.07 133.86,78.21 134.23,78.21 134.36,78.34 134.36,78.61 134.21,78.76 133.86,78.76 133.72,78.9 133.72,85.6 131.6,87.72
  BOTTOM w0.114: v3(129.93,88.16) 129.87,88.16 U27.A6
  BOTTOM w0.127: v3(129.07,43.69) 129.25,43.88 JDIM2.177
M_A_DQ56: length 65.3
  IN1 w0.089: v3(125.93,94.16) 126.52,93.56 127.1,93.56 127.34,93.33 127.34,92.61 127.52,92.43 127.52,92 127.76,91.75 128.17,91.75 128.52,91.4 128.52,91 128.76,90.75 129.17,90.75 129.36,90.56 130.32,90.56 130.74,90.13 131.6,90.13
  IN1 w0.133: 131.6,90.13 131.79,90.13 135.43,86.5 135.43,80.07 136.19,79.31 136.19,65.13 136.78,64.54 136.78,53.06 136.4,52.68 136.4,52.41 133.83,49.85 133.83,48.24 131.52,45.93 131.52,44.73 131,44.21 131,42.08 v3(130.66,41.75)
  BOTTOM w0.114: v3(125.93,94.16) 125.87,94.16 U27.E12
  BOTTOM w0.127: JDIM2.180 130.15,39.8 130.31,39.96 130.31,41.39 v3(130.66,41.75)
M_A_DQ57: length 64.8
  IN1 w0.089: v3(126.93,94.16) 127.46,94.16 127.53,94.08 127.53,92.86 127.81,92.58 128.25,92.58 128.47,92.35 128.47,91.87 128.73,91.61 130.86,91.61 131.6,90.87
  IN1 w0.133: 131.6,90.87 135.81,86.66 135.81,80.24 136.58,79.47 136.58,65.29 137.17,64.7 137.17,52.9 136.78,52.52 136.78,51.5 134.22,48.93 134.22,48.08 131.91,45.77 131.91,44.57 131.39,44.05 131.39,40.87 v3(130.93,40.42)
  BOTTOM w0.114: U27.D12 126.87,94.16 v3(126.93,94.16)
  BOTTOM w0.127: JDIM2.182 130.75,40.24 v3(130.93,40.42)
M_A_DQ58: length 65.1
  IN1 w0.089: 131.56,93.38 130.72,93.38 ; v3(128.93,93.16) 129.33,93.56 130.55,93.56
  IN1 w0.102: 130.72,93.38 130.55,93.56
  IN1 w0.133: 131.56,93.38 137.55,87.38 137.55,82.38 138.32,81.62 138.32,66.01 140.24,64.09 140.24,58.15 140.52,57.88 140.52,54.55 138.94,52.98 138.94,50.79 136.96,48.81 136.96,48.36 134.14,45.54 134.14,43.11 v3(134.96,42.29)
  BOTTOM w0.114: v3(128.93,93.16) 128.87,93.16 U27.B11
  BOTTOM w0.127: JDIM2.194 134.35,41.69 v3(134.96,42.29)
M_A_DQ59: length 64
  IN1 w0.102: 131.15,92.99 130.09,92.99 v3(129.93,93.16)
  IN1 w0.133: v3(133.66,42.47) 133.75,42.56 133.75,45.7 136.5,48.45 136.5,48.9 138.52,50.92 138.52,53.29 140.11,54.89 140.11,56.53 138.95,57.69 138.95,64.83 137.93,65.85 137.93,80.38 137.8,80.51 137.45,80.51 137.32,80.64 137.32,80.92 137.45,81.05 137.8,81.05 137.93,81.18 137.93,81.46 137.8,81.59 137.3,81.59 137.17,81.72 137.17,87.22 131.39,92.99 131.15,92.99
  BOTTOM w0.114: U27.A11 129.87,93.16 v3(129.93,93.16)
  BOTTOM w0.127: v3(133.66,42.47) 133.75,42.37 JDIM2.192
M_A_DQ60: length 64.9
  IN1 w0.089: 131.6,89.23 131.27,89.56 128.96,89.56 128.53,89.99 128.53,90.13 127.9,90.75 127.76,90.75 127.53,90.99 127.53,91.21 127.13,91.61 126.82,91.61 126.47,91.96 126.47,92.61 v3(125.93,93.16)
  IN1 w0.133: 131.6,89.23 134.65,86.17 134.65,79.75 135.42,78.99 135.42,59.06 135.88,58.6 135.88,55.65 135.74,55.52 135.55,55.52 135.42,55.38 135.42,55.11 135.55,54.98 135.74,54.98 135.88,54.84 135.88,54.45 135.74,54.32 135.55,54.32 135.42,54.18 135.42,53.91 135.55,53.78 135.87,53.78 136,53.65 136,53.39 135.42,52.8 135.42,52.53 133.06,50.17 133.06,48.56 130.48,45.99 130.48,45.65 130.03,45.2 130.03,43.54 v3(130.54,43.03)
  BOTTOM w0.114: U27.E11 125.87,93.16 v3(125.93,93.16)
  BOTTOM w0.127: v3(130.54,43.03) 131.03,43.52 131.03,43.99 131.2,44.16 131.2,45.7 131.05,45.84 JDIM2.183
M_A_DQ61: length 64.5
  IN1 w0.089: v3(126.93,93.16) 126.93,92.75 127.33,92.35 127.33,91.92 127.69,91.56 128.1,91.56 128.33,91.32 128.33,90.92 128.68,90.56 129.09,90.56 129.33,90.32 129.33,90.07 129.65,89.75 131.6,89.75
  IN1 w0.133: v3(130.54,44.38) 131.13,44.97 131.13,46.09 133.44,48.4 133.44,50.01 136.01,52.57 136.01,52.84 136.39,53.23 136.39,58.94 136.25,59.08 135.95,59.08 135.8,59.22 135.8,59.51 135.94,59.64 136.26,59.64 136.39,59.77 136.39,60.05 136.26,60.18 135.94,60.18 135.8,60.31 135.8,60.59 135.94,60.72 136.26,60.72 136.39,60.85 136.39,61.13 136.26,61.26 135.94,61.26 135.8,61.39 135.8,61.67 135.94,61.8 136.26,61.8 136.39,61.93 136.39,62.21 136.26,62.34 135.94,62.34 135.8,62.47 135.8,62.75 135.94,62.88 136.26,62.88 136.39,63.01 136.39,63.29 136.26,63.42 135.94,63.42 135.8,63.55 135.8,63.84 135.94,63.97 136.11,63.97 136.26,64.13 136.26,64.51 135.8,64.97 135.8,79.15 135.04,79.91 135.04,86.33 131.63,89.75 131.6,89.75
  BOTTOM w0.114: v3(126.93,93.16) 126.87,93.16 U27.D11
  BOTTOM w0.127: v3(130.54,44.38) 130.89,44.73 130.89,45.31 130.45,45.76 JDIM2.181
M_A_DQ62: length 65.2
  IN1 w0.089: v3(128.93,94.16) 129.34,93.75 131.2,93.75 131.22,93.77 131.6,93.77
  IN1 w0.133: 131.6,93.77 131.72,93.77 137.95,87.53 137.95,83.38 138.09,83.25 138.57,83.25 138.71,83.12 138.71,82.84 138.57,82.71 138.31,82.71 138.18,82.58 138.18,82.3 138.31,82.17 138.57,82.17 138.71,82.04 138.71,66.17 140.68,64.19 140.68,58.26 140.92,58.02 140.92,54.41 139.33,52.82 139.33,50.63 137.35,48.65 137.35,48.2 134.52,45.38 134.52,44.22 v3(134.95,43.79)
  BOTTOM w0.114: v3(128.93,94.16) 128.87,94.16 U27.B12
  BOTTOM w0.127: v3(134.95,43.79) 133.45,45.29 JDIM2.191
M_A_DQ63: length 65.3
  IN1 w0.133: v3(136.05,44.47) 135.46,45.06 135.46,45.77 136.81,47.11 138.2,47.11 141.07,49.99 141.07,52.62 141.33,52.88 141.33,58.3 141.07,58.57 141.07,64.35 139.09,66.33 139.09,83.64 138.96,83.77 138.47,83.77 138.34,83.91 138.34,84.18 138.47,84.31 138.86,84.31 138.99,84.44 138.99,84.72 138.86,84.85 138.47,84.85 138.34,84.98 138.34,85.29 138.71,85.67 138.71,87.32 131.88,94.16 v3(129.93,94.16)
  BOTTOM w0.114: U27.A12 129.87,94.16 v3(129.93,94.16)
  BOTTOM w0.127: v3(136.05,44.47) 135.05,44.47 134.05,45.47 JDIM2.193
M_A_DQSN0: length 82.7
  IN1 w0.089: v3(95.93,96.16) 95.93,96.14 95.34,95.55 95.34,94.89 95.19,94.74 93.59,94.74 93.35,94.51 91.89,94.51 91.84,94.55 91.82,94.55
  IN1 w0.133: 91.82,94.55 91.21,94.55 88.73,92.07 80.98,92.07 71.44,82.54 71.44,76.29 70.88,75.72 70.88,70.99 69.3,69.41 69.3,60.14 67.63,58.46 67.63,52.64 68.73,51.54 69.67,51.54 75.18,46.02 75.18,42.42 75.46,42.14 75.66,42.14 v3(76,41.81)
  BOTTOM w0.114: U27.AP15 95.93,96.22 v3(95.93,96.16)
  BOTTOM w0.127: JDIM2.10 76.75,39.76 76.92,39.93 76.92,40.1 76.56,40.46 76.56,42.29 76.39,42.46 76.1,42.46 76,42.36 v3(76,41.81)
M_A_DQSN1: length 74
  IN1 w0.089: v3(95.93,89.16) 95.93,89.41 95.76,89.58 92.52,89.58 92.03,89.09 92.03,89.02 92.02,89.01
  IN1 w0.133: v3(81.42,43.89) 81.42,43.23 81.23,43.05 80.98,43.05 80.83,43.2 80.83,47.51 75.27,53.07 75.27,62.85 74.96,63.16 74.5,63.16 74.33,63.33 74.33,63.57 74.46,63.7 75.17,63.7 75.47,64 75.47,64.48 75.16,64.79 74.46,64.79 74.33,64.92 74.33,66.51 76.71,68.89 76.71,75.15 77.91,76.35 77.91,82.65 81.93,86.68 89.69,86.68 92.02,89.01
  BOTTOM w0.114: v3(95.93,89.16) 95.93,89.22 U27.AP8
  BOTTOM w0.127: v3(81.42,43.89) 81.42,43.35 81.57,43.2 81.81,43.2 82.02,43.41 82.02,45.68 81.85,45.85 JDIM2.27
M_A_DQSN2: length 64.9
  IN1 w0.089: 92.13,82.9 92.14,82.92 92.14,82.98 93.72,84.56 96.17,84.56 96.52,84.91 96.52,85.31 96.76,85.56 97.17,85.56 97.53,85.91 97.53,86.32 97.76,86.56 98.17,86.56 98.53,86.92 98.53,87.32 98.78,87.57 99.16,87.57 99.51,87.92 99.51,88.32 99.75,88.57 100.16,88.57 100.33,88.74 100.33,89.42 100.47,89.56 100.79,89.56 100.93,89.42 v3(100.93,89.16)
  IN1 w0.133: v3(87.1,43.75) 86.95,43.6 86.78,43.6 86.64,43.74 86.64,45.06 85.12,46.58 85.12,49.98 82.74,52.36 82.36,52.36 81.23,53.49 81.23,54.52 81.69,54.98 81.69,66.88 83.19,68.38 83.19,71.45 83.93,72.18 83.93,72.76 89.92,78.76 89.92,80.7 92.13,82.9
  BOTTOM w0.114: v3(100.93,89.16) 100.93,89.22 U27.AJ8
  BOTTOM w0.127: JDIM2.45 87.25,45.85 87.42,45.68 87.42,45.13 87.62,44.93 87.62,43.64 87.49,43.5 87.35,43.5 v3(87.1,43.75)
M_A_DQSN3: length 58.1
  IN1 w0.089: 96.17,78.83 96.17,78.9 97.23,79.97 98.02,79.97 99.61,81.55 100.17,81.55 100.51,81.89 100.51,82.3 100.78,82.57 101.2,82.57 101.51,82.88 101.51,83.3 101.76,83.56 103.33,83.56 v3(103.93,84.16)
  IN1 w0.133: v3(91.44,41.93) 91.44,42.13 92.23,42.91 92.23,45.44 89.82,47.85 89.82,51.25 88.98,52.09 88.98,67.97 90.33,69.32 90.33,70.09 91.45,71.22 91.45,74.12 96.17,78.83
  BOTTOM w0.114: U27.AF3 103.93,84.22 v3(103.93,84.16)
  BOTTOM w0.127: JDIM2.62 92.35,39.76 92.52,39.93 92.52,42.36 92.29,42.59 91.65,42.59 91.44,42.39 v3(91.44,41.93)
M_A_DQSN4: length 50.9
  IN1 w0.089: 123.12,80.33 123.12,80.36 123.17,80.4 123.17,80.81 123.34,80.98 123.34,83.33 123.1,83.56 122.92,83.56 122.43,84.05 122.43,84.17 122.31,84.3 122.07,84.3 v3(121.93,84.16)
  IN1 w0.133: v3(115.57,44.47) 115.57,44.22 115.68,44.11 115.95,44.11 116.12,44.28 116.12,46.91 117.22,48.02 117.22,50.77 119.11,52.66 119.11,58.48 120.21,59.58 120.21,60.2 123.12,63.12 123.12,80.33
  BOTTOM w0.114: v3(121.93,84.16) U27.J3
  BOTTOM w0.127: v3(115.57,44.47) 115.57,44.04 115.85,43.76 116.65,43.76 116.83,43.94 116.83,44.23 116.51,44.55 116.51,45.13 116.82,45.43 116.82,45.68 116.65,45.85 JDIM2.135
M_A_DQSN5: length 53.3
  IN1 w0.089: 127.4,81.48 127.45,81.52 127.45,82.25 127.33,82.37 127.33,83.32 127.1,83.56 126.69,83.56 126.34,83.91 126.34,84.49 126.23,84.61 126.05,84.61 125.93,84.48 v3(125.93,84.16)
  IN1 w0.133: v3(121.47,40.87) 121.47,41.15 121.29,41.33 121.05,41.33 120.64,41.74 120.64,42.5 121.44,43.31 121.44,48.11 122.43,49.1 122.43,49.7 126.1,53.37 126.1,58.6 127.92,60.43 127.92,74.02 127.4,74.54 127.4,81.48
  BOTTOM w0.114: v3(125.93,84.16) 125.87,84.16 U27.E2
  BOTTOM w0.127: v3(121.47,40.87) 121.47,41.37 121.57,41.47 121.79,41.47 121.97,41.29 121.97,40.17 121.75,39.95 JDIM2.152
M_A_DQSN6: length 57.9
  IN1 w0.089: v3(127.93,87.16) 127.93,87.42 128.08,87.57 129.1,87.57 129.35,87.32 129.35,86.92 129.7,86.57 130.57,86.57 131.09,86.05 131.09,85.98 131.11,85.96
  IN1 w0.133: v3(126.24,42.24) 126.68,42.24 126.93,42.49 126.93,46 129.32,48.38 129.32,49.99 132.42,53.09 132.42,58.78 132.9,59.26 132.9,67.47 132.14,68.23 132.14,84.94 131.11,85.96
  BOTTOM w0.114: v3(127.93,87.16) 127.87,87.16 U27.C5
  BOTTOM w0.127: JDIM2.169 126.85,42.49 126.6,42.24 v3(126.24,42.24)
M_A_DQSN7: length 66.3
  IN1 w0.089: v3(127.93,93.16) 127.93,93.53 128.02,93.62 128.25,93.62 128.35,93.52 128.35,92.88 128.67,92.56 130.15,92.56 130.51,92.19 131.11,92.19 131.39,91.91 131.39,91.85 131.41,91.83
  IN1 w0.133: 131.41,91.83 136.35,86.88 136.35,80.46 137.12,79.69 137.12,65.51 138.14,64.49 138.14,59.32 137.71,58.89 137.71,52.68 137.32,52.3 137.32,51.27 134.76,48.71 134.76,47.86 132.94,46.04 132.94,43.45 132.81,43.32 132.6,43.32 132.39,43.53 v3(132.39,43.96)
  BOTTOM w0.114: v3(127.93,93.16) 127.87,93.16 U27.C11
  BOTTOM w0.127: v3(132.39,43.96) 132.39,43.55 132.21,43.38 131.86,43.38 131.51,43.03 131.51,41.43 132.12,40.83 132.12,40.12 131.95,39.95 JDIM2.186
M_A_DQSP0: length 82.7
  IN1 w0.089: 91.82,94.28 91.84,94.28 91.89,94.33 93.43,94.33 93.66,94.56 95.27,94.56 95.52,94.82 95.52,95.48 95.69,95.65 95.93,95.65 96.05,95.53 96.05,95.28 v5(95.93,95.16)
  IN1 w0.133: v3(76,43.1) 76,42.62 75.8,42.41 75.57,42.41 75.46,42.53 75.46,46.13 69.78,51.81 68.84,51.81 67.9,52.75 67.9,58.35 69.57,60.02 69.57,69.3 71.15,70.88 71.15,75.61 71.71,76.17 71.71,82.42 81.09,91.8 88.85,91.8 91.32,94.28 91.82,94.28
  BOTTOM w0.114: v5(95.93,95.16) 95.93,95.22 U27.AP14
  BOTTOM w0.127: JDIM2.12 77.35,39.76 77.19,39.93 77.19,40.21 76.83,40.57 76.83,42.4 76.5,42.73 76.37,42.73 v3(76,43.1)
M_A_DQSP1: length 74
  IN1 w0.089: 91.82,89.2 91.84,89.22 91.91,89.22 92.44,89.75 95.53,89.75 v3(95.93,90.16)
  IN1 w0.133: 91.82,89.2 89.57,86.95 81.82,86.95 77.63,82.76 77.63,76.47 76.43,75.27 76.43,69 74.05,66.63 74.05,64.81 74.35,64.52 75.05,64.52 75.2,64.37 75.2,64.11 75.06,63.98 74.35,63.98 74.05,63.68 74.05,63.22 74.39,62.89 74.85,62.89 75,62.74 75,52.95 80.56,47.4 80.56,43.09 80.87,42.78 81.24,42.78 v3(81.42,42.6)
  BOTTOM w0.114: U27.AP9 95.93,90.22 v3(95.93,90.16)
  BOTTOM w0.127: v3(81.42,42.6) 81.75,42.93 81.92,42.93 82.29,43.29 82.29,45.68 82.45,45.85 JDIM2.29
M_A_DQSP2: length 64.9
  IN1 w0.089: 91.92,83.08 91.95,83.11 92.02,83.11 93.65,84.74 96.1,84.74 96.34,84.98 96.34,85.39 96.69,85.73 97.1,85.73 97.35,85.98 97.35,86.39 97.69,86.73 98.09,86.73 98.35,86.99 98.35,87.39 98.7,87.75 99.09,87.75 99.33,87.99 99.33,88.39 99.68,88.75 100.09,88.75 100.15,88.81 100.15,88.93 100.15,88.94 v3(99.93,89.16)
  IN1 w0.133: v3(87.1,42.99) 87.1,43.21 86.98,43.33 86.67,43.33 86.37,43.62 86.37,44.95 84.85,46.46 84.85,49.87 82.63,52.09 82.25,52.09 80.96,53.38 80.96,54.63 81.42,55.09 81.42,66.99 82.92,68.49 82.92,71.56 83.65,72.3 83.65,72.87 89.65,78.87 89.65,80.81 91.92,83.08
  BOTTOM w0.114: v3(99.93,89.16) 99.93,89.22 U27.AK8
  BOTTOM w0.127: JDIM2.47 87.85,45.85 87.69,45.68 87.69,45.24 87.89,45.04 87.89,43.53 87.6,43.24 87.35,43.24 v3(87.1,42.99)
M_A_DQSP3: length 58.1
  IN1 w0.089: 95.97,79.03 96.04,79.03 97.16,80.15 97.95,80.15 99.53,81.73 100.09,81.73 100.33,81.97 100.33,82.37 100.7,82.75 101.12,82.75 101.33,82.95 101.33,83.37 101.69,83.73 103.26,83.73 103.51,83.99 103.51,84.12 103.33,84.3 103.07,84.3 v3(102.93,84.16)
  IN1 w0.133: v3(91.44,43.23) 91.75,42.92 91.85,42.92 91.95,43.03 91.95,45.33 89.54,47.74 89.54,51.14 88.71,51.98 88.71,68.09 90.05,69.43 90.05,70.21 91.17,71.33 91.17,74.23 95.97,79.03
  BOTTOM w0.114: U27.AG3 102.93,84.22 v3(102.93,84.16)
  BOTTOM w0.127: JDIM2.64 92.95,39.75 92.79,39.91 92.79,42.47 92.4,42.86 91.82,42.86 v3(91.44,43.23)
M_A_DQSP4: length 50.9
  IN1 w0.089: v3(122.93,84.16) 122.93,83.81 122.99,83.74 123.18,83.74 123.52,83.4 123.52,80.91 123.35,80.74 123.35,80.4 123.39,80.36 123.39,80.33
  IN1 w0.133: 123.39,80.33 123.39,63 120.48,60.09 120.48,59.47 119.39,58.37 119.39,52.55 117.49,50.66 117.49,47.9 116.39,46.8 116.39,44.17 116.06,43.84 115.71,43.84 115.57,43.71 v3(115.57,43.18)
  BOTTOM w0.114: v3(122.93,84.16) U27.H3
  BOTTOM w0.127: v3(115.57,43.18) 115.89,43.49 116.76,43.49 117.1,43.83 117.1,44.34 116.78,44.66 116.78,45.02 117.09,45.32 117.09,45.68 117.25,45.85 JDIM2.137
M_A_DQSP5: length 53.2
  IN1 w0.089: v3(125.93,85.16) 125.93,84.9 126.05,84.78 126.3,84.78 126.52,84.57 126.52,83.98 126.77,83.73 127.17,83.73 127.51,83.39 127.51,82.45 127.63,82.32 127.63,81.52 127.68,81.48
  IN1 w0.133: 127.68,81.48 127.68,74.65 128.19,74.13 128.19,60.31 126.37,58.49 126.37,53.26 122.7,49.59 122.7,48.99 121.71,48 121.71,43.19 120.91,42.39 120.91,41.86 121.16,41.6 121.34,41.6 121.47,41.73 v3(121.47,42.16)
  BOTTOM w0.114: U27.E3 125.87,85.16 v3(125.93,85.16)
  BOTTOM w0.127: JDIM2.154 122.35,39.95 122.23,40.07 122.23,41.4 121.47,42.16 v3(121.47,42.16)
M_A_DQSP6: length 57.9
  IN1 w0.089: v3(127.93,88.16) 127.93,87.86 128.04,87.75 129.17,87.75 129.53,87.39 129.53,86.99 129.77,86.75 130.65,86.75 131.22,86.17 131.29,86.17 131.3,86.16
  IN1 w0.133: 131.3,86.16 132.41,85.05 132.41,68.35 133.17,67.58 133.17,59.15 132.69,58.66 132.69,52.97 129.59,49.87 129.59,48.27 127.21,45.89 127.21,42.57 v3(127.54,42.24)
  BOTTOM w0.114: U27.C6 127.87,88.16 v3(127.93,88.16)
  BOTTOM w0.127: v3(127.54,42.24) 127.28,42.24 127.12,42.4 127.12,45.7 127.45,46.04 JDIM2.171
M_A_DQSP7: length 66.2
  IN1 w0.089: 131.6,92.03 131.58,92.04 131.52,92.04 131.18,92.37 130.58,92.37 130.22,92.73 128.75,92.73 128.53,92.95 128.53,93.59 128.33,93.8 128.05,93.8 127.93,93.91 v3(127.93,94.16)
  IN1 w0.133: v3(132.39,42.66) 132.39,42.92 132.52,43.05 132.92,43.05 133.21,43.33 133.21,45.92 135.03,47.75 135.03,48.6 137.6,51.16 137.6,52.19 137.98,52.57 137.98,58.78 138.41,59.21 138.41,64.61 137.39,65.62 137.39,79.81 136.63,80.57 136.63,87 131.6,92.03
  BOTTOM w0.114: v3(127.93,94.16) 127.87,94.16 127.72,94.01 U27.C12
  BOTTOM w0.127: JDIM2.188 132.55,39.95 132.39,40.12 132.39,40.94 131.78,41.54 131.78,42.92 131.97,43.11 132.27,43.11 132.39,43 v3(132.39,42.66)
M_A_ODT0: length 64.4
  IN1 w0.216: v3(112.22,42.15) 112.22,42.17 111.78,42.61 111.78,47.95 112.18,48.36 112.18,51.09 113.54,52.44 113.54,59.04 117.54,63.04 117.54,65.28 117.87,65.61 118.15,65.61 118.39,65.37 118.39,64.89 118.59,64.7 118.99,64.7 119.32,65.03 119.32,81.64 119.43,81.75 119.43,88.53 119.66,88.76 120.19,88.76 120.35,88.92 120.35,89.35 120.22,89.48 119.64,89.48 119.13,89.99 118.83,89.99 118.57,89.73 118.57,89.51 v3(118.93,89.16)
  BOTTOM w0.178: v3(118.93,89.16) U27.M8
  BOTTOM w0.191: v3(112.22,42.15) 112.89,42.82 113.33,42.82 113.72,42.43 113.72,42.03 112.68,40.99 111.69,40.99 110.95,40.25 JDIM2.116
M_A_ODT1: length 62.4
  IN1 w0.216: v3(113.57,40.89) 113.48,40.8 113.48,37.79 113.27,37.58 112.7,37.58 112.49,37.79 112.49,40.93 112.95,41.39 112.95,42.52 112.35,43.12 112.35,47.71 112.76,48.12 112.76,50.85 114.11,52.21 114.11,58.8 119.89,64.58 119.89,81.3 120.45,81.86 120.45,87.52 119.93,88.04 v3(119.93,88.16)
  BOTTOM w0.178: v3(119.93,88.16) U27.L7
  BOTTOM w0.191: JDIM2.120 112.15,40.01 112.4,40.25 112.93,40.25 v3(113.57,40.89)
M_A_RAS#: length 67
  IN1 w0.089: 114.41,81.62 114.41,85.35 114.2,85.56 112.64,85.56 112.43,85.77 112.43,86.46 112.6,86.63 113.03,86.63 113.56,87.16 v3(113.92,87.16)
  IN1 w0.216: v3(107.85,40.21) 107.85,37.72 107.66,37.53 107.4,37.53 107.21,37.72 107.21,43.94 106.9,44.25 106.9,45.39 106.75,45.54 106.75,53.9 106.36,54.29 106.36,57.65 105.46,58.55 105.46,59.52 106.4,60.46 106.4,61.07 107.45,62.12 107.98,62.12 108.28,62.41 108.28,62.95 114.41,69.08 114.41,81.62
  BOTTOM w0.178: v3(113.92,87.16) U27.U6
  BOTTOM w0.191: v3(107.85,40.21) 108.14,40.21 108.47,40.54 108.47,41.41 108.67,41.61 109.6,41.61 109.73,41.47 109.73,40.46 109.15,39.88 JDIM2.110
M_A_WE#: length 62.3
  IN1 w0.089: 116.72,84.71 116.52,84.91 116.52,85.67 116.35,85.84 116.35,86.37 115.98,86.74 115.69,86.74 115.43,86.99 115.43,87.36 115.22,87.57 114.53,87.57 114.35,87.75 114.35,88.36 114.14,88.58 113.67,88.58 113.54,88.45 113.54,88.28 113.67,88.16 v3(113.93,88.16)
  IN1 w0.216: v3(110.37,42.29) 110.37,42.54 110.18,42.72 109.66,42.72 109.46,42.93 109.46,45.94 109.15,46.25 109.15,47.9 109.43,48.18 109.43,54.97 109.97,55.51 109.97,59.85 112.52,62.41 113.21,62.41 114.3,63.5 114.3,63.9 113.52,64.68 113.52,64.93 113.7,65.12 113.96,65.12 114.48,64.6 114.74,64.6 114.92,64.78 114.92,65.04 114.4,65.56 114.4,65.84 116.7,68.14 116.7,81.03 116.91,81.24 116.91,84.53 116.72,84.71
  BOTTOM w0.178: v3(113.93,88.16) U27.U7
  BOTTOM w0.191: JDIM2.113 110.05,45.9 109.5,45.35 109.5,44.63 109.86,44.27 109.86,42.48 110.05,42.29 v3(110.37,42.29)
M_B_A0: length 48.3
  IN2 w0.089: v3(115.93,89.16) 115.53,89.56 113.59,89.56 112.33,88.29 112.33,87.99 112.1,87.75 111.54,87.75 111.21,87.42 111.21,86.88 110.65,86.32 110.65,86.1 110.29,85.75 109.68,85.75 108.92,84.98 108.92,82.71 109.11,82.52
  IN2 w0.216: 109.11,82.52 109.42,82.21 109.42,77.32 105.61,73.51 105.61,69.67 104.21,68.27 104.21,59.05 103.77,58.61 103.77,57.46 103.29,56.97 v3(103.29,56.95)
  BOTTOM w0.178: v3(115.93,89.16) U27.R8
  BOTTOM w0.191: v3(103.29,56.95) 103.29,56.74 102.62,56.08 102.62,55.75 103.08,55.29 103.64,55.29 104.33,54.6 104.33,53.92 105.55,52.7 JDIM1.98
M_B_A1: length 47.1
  IN2 w0.089: v5(111.05,86.16) 111.51,86.62 111.51,87.37 111.72,87.58 112.17,87.58 112.33,87.41 112.33,85.99 111.9,85.56 109.76,85.56 109.11,84.9
  IN2 w0.102: 109.29,82.93 109.11,83.1 109.11,84.9
  IN2 w0.216: 109.29,82.93 109.99,82.22 109.99,77.09 106.18,73.27 106.18,69.44 104.78,68.04 104.78,58.87 104.37,58.47 104.37,57.38 103.33,56.34 v3(103.33,55.93)
  BOTTOM w0.178: v5(111.05,86.16) 110.57,86.16 110.4,86.32 U27.Y5
  BOTTOM w0.191: v3(103.33,55.93) 103.77,55.93 104.21,55.5 104.45,55.5 104.63,55.67 104.63,55.95 104.14,56.44 104.14,57.88 105.25,58.99 JDIM1.97
M_B_A2: length 45.3
  IN2 w0.089: v3(110.1,91.19) 110.51,90.77 110.51,88.86 110.33,88.68 110.33,87.12 109.99,86.79 109.75,86.79 109.17,86.22 109.17,85.77 108.54,85.14 108.54,81.47
  IN2 w0.216: 108.54,81.47 108.54,79.52 108.28,79.26 108.28,77.8 104.47,73.98 104.47,70.15 102.34,68.02 102.34,65.88 103.07,65.15 103.07,59.46 102.59,58.98 102.59,57.1 102.59,57.1 102.59,56.01 103.28,55.32 v3(103.28,54.67)
  BOTTOM w0.178: v3(110.1,91.19) 110.1,91.38 U27.Y10
  BOTTOM w0.191: JDIM1.96 104.95,52.74 103.76,53.93 103.76,54.19 v3(103.28,54.67)
M_B_A3: length 45.5
  IN2 w0.089: 109.07,82.1 108.73,82.44 108.73,85.06 109.37,85.7 109.37,86.16 109.79,86.58 110.04,86.58 110.51,87.05 110.51,88.3 110.9,88.69 110.9,89.6 111,89.71 111.23,89.71 111.33,89.61 111.33,87.99 110.95,87.61 110.95,86.96 110.14,86.16 v3(109.93,86.16)
  IN2 w0.216: v3(103.31,58.26) 103.31,58.89 103.64,59.22 103.64,65.84 103.46,66.03 103.09,66.03 102.91,66.21 102.91,66.47 103.09,66.65 103.46,66.65 103.64,66.83 103.64,67.09 103.46,67.27 103.09,67.27 102.91,67.45 102.91,67.71 103.09,67.89 103.46,67.89 103.64,68.08 103.64,68.51 105.04,69.91 105.04,73.75 108.85,77.56 108.85,79.2 109.07,79.42 109.07,82.1
  BOTTOM w0.178: U27.AA5 109.2,86.49 109.2,86.33 109.37,86.16 v3(109.93,86.16)
  BOTTOM w0.191: JDIM1.95 104.65,58.95 104.37,58.67 103.72,58.67 v3(103.31,58.26)
M_B_A4: length 45.8
  IN2 w0.089: 107.28,81.63 107.28,81.91 107.33,81.96 107.33,82.32 107.07,82.59 107.07,82.72 107.33,82.99 107.33,83.35 107.09,83.58 107.09,83.75 107.33,83.99 107.33,84.32 107.09,84.56 107.09,84.75 107.33,84.99 107.33,85.45 107.63,85.75 108.32,85.75 108.52,85.96 108.52,86.1 108.28,86.34 108.28,86.48 108.39,86.58 108.64,86.58 108.74,86.68 108.74,86.78 108.52,86.99 108.52,87.32 108.76,87.56 109.28,87.56 109.38,87.65 110.01,87.65 110.11,87.75 110.11,87.97 v3(109.93,88.16)
  IN2 w0.216: 107.28,81.63 107.28,80.35 106.56,79.63 106.56,78.51 102.75,74.69 102.75,70.86 100.63,68.73 100.63,58.45 100.86,58.22 100.86,56.68 v3(101.61,55.93)
  BOTTOM w0.178: U27.Y7 110.06,88.69 109.93,88.56 v3(109.93,88.16)
  BOTTOM w0.191: v3(101.61,55.93) 102.06,55.48 102.06,54.91 102.24,54.73 102.49,54.73 102.72,54.5 102.72,54.12 102.44,53.84 102.44,53.59 102.62,53.41 103.54,53.41 103.75,53.19 JDIM1.92
M_B_A5: length 45.5
  IN2 w0.089: 107.69,81.76 107.53,81.92 107.53,83.54 107.62,83.63 108.03,83.63 108.12,83.72 108.12,83.9 108.03,83.99 107.62,83.99 107.53,84.07 107.53,84.25 107.62,84.34 108.03,84.34 108.12,84.43 108.12,84.61 108.03,84.7 107.62,84.7 107.53,84.79 107.53,85.32 107.77,85.56 108.39,85.56 108.74,85.92 108.74,86.29 109.15,86.69 109.15,86.94 v3(108.93,87.16)
  IN2 w0.216: v3(101.63,56.59) 101.43,56.78 101.43,58.66 101.2,58.9 101.2,59.57 101.38,59.75 101.74,59.75 101.92,59.93 101.92,60.19 101.74,60.37 101.38,60.37 101.2,60.55 101.2,60.81 101.38,60.99 101.74,60.99 101.92,61.18 101.92,61.43 101.74,61.62 101.38,61.62 101.2,61.8 101.2,62.81 101.38,62.99 101.74,62.99 101.92,63.17 101.92,63.43 101.74,63.61 101.38,63.61 101.2,63.8 101.2,64.05 101.38,64.24 101.74,64.24 101.92,64.42 101.92,64.68 101.74,64.86 101.38,64.86 101.2,65.04 101.2,68.49 103.32,70.62 103.32,74.46 107.14,78.27 107.14,79.54 107.69,80.09 107.69,81.76
  BOTTOM w0.178: v3(108.93,87.16) 108.93,87.22 U27.AA6
  BOTTOM w0.191: v3(101.63,56.59) 101.63,57.22 103.45,59.04 JDIM1.91
M_B_A6: length 47.9
  IN2 w0.089: v3(109.88,87.24) 109.88,87.17 108.94,86.24 108.94,85.81 108.35,85.22 108.35,81.94
  IN2 w0.102: 108.09,81.68 108.35,81.94
  IN2 w0.216: 108.09,81.68 108.09,79.84 107.71,79.45 107.71,78.03 103.89,74.22 103.89,70.38 101.77,68.26 101.77,65.64 102.5,64.91 102.5,59.7 102,59.2 102,56.92 102.16,56.77 102.16,55.34 102.75,54.76 102.75,53 102.56,52.81 101.16,52.81 100.97,53 100.97,53.26 101.16,53.45 101.88,53.45 102.11,53.68 102.11,54.3 101.8,54.61 v3(101.58,54.61)
  BOTTOM w0.178: U27.Y6 110.32,87.69 v3(109.88,87.24)
  BOTTOM w0.191: JDIM1.90 103.15,52.83 102.98,53.01 102.29,53.01 102.03,53.26 102.03,54.3 101.72,54.61 v3(101.58,54.61)
M_B_A7: length 43.8
  IN2 w0.089: 106.34,80.87 106.33,80.88 106.33,85.45 106.63,85.75 107.1,85.75 107.34,86 107.34,86.4 107.51,86.57 107.51,87.3 107.53,87.32 107.53,87.32 107.76,87.56 108.17,87.56 108.77,88.16 v5(108.93,88.16)
  IN2 w0.216: v3(100.21,55.22) 100.57,55.22 100.81,55.46 100.81,55.98 100.47,56.33 99.96,56.33 99.7,56.59 99.7,58.7 99.47,58.92 99.47,69.19 101.61,71.33 101.61,75.17 105.42,78.98 105.42,79.95 106.34,80.87
  BOTTOM w0.178: U27.AA7 108.93,88.22 v5(108.93,88.16)
  BOTTOM w0.191: JDIM1.86 101.95,52.77 101.1,53.62 101.1,54.32 v3(100.21,55.22)
M_B_A8: length 47.9
  IN2 w0.089: v3(109.93,89.16) 109.93,88.99 109.51,88.57 108.78,88.57 108.35,88.14 108.35,87.98 108.12,87.75 107.71,87.75 107.33,87.37 107.33,86.66 107.22,86.56 106.76,86.56 106.53,86.32 106.53,85.92 106.17,85.56 105.77,85.56 105.53,85.32 105.53,81.81
  IN2 w0.216: 105.53,81.81 105.55,81.79 105.55,80.67 104.85,79.97 104.85,79.22 101.04,75.4 101.04,71.57 98.9,69.43 98.9,58.78 99.34,58.34 99.34,55.88 99.57,55.65 99.97,55.65 v3(100.19,55.86)
  BOTTOM w0.178: v3(109.93,89.16) 109.93,89.22 U27.Y8
  BOTTOM w0.191: v3(100.19,55.86) 100.25,55.86 100.72,55.4 100.97,55.4 101.1,55.53 101.1,56.35 100.66,56.79 100.66,57.32 101.86,58.52 102.34,58.52 102.85,59.03 JDIM1.89
M_B_A9: length 43.7
  IN2 w0.089: v3(108.93,91.16) 109.38,90.71 109.97,90.71 110.33,90.34 110.33,88.95 110.07,88.69 109.9,88.69 109.41,88.2 109.41,88.06 109.09,87.73 108.65,87.73 108.35,87.42 108.35,86.97 108.14,86.76 107.96,86.76 107.53,86.32 107.53,85.92 107.17,85.56 106.71,85.56 106.52,85.37 106.52,81.94 106.77,81.69
  IN2 w0.102: 106.77,80.55 106.77,81.69
  IN2 w0.216: 106.77,80.55 105.99,79.77 105.99,78.74 102.18,74.93 102.18,71.09 100.05,68.97 100.05,57.56 v3(100.19,57.43)
  BOTTOM w0.178: v3(108.93,91.16) 108.93,91.22 U27.AA10
  BOTTOM w0.191: v3(100.19,57.43) 101.65,58.9 JDIM1.85
M_B_A10: length 51.5
  IN2 w0.089: 111.41,83.71 111.41,84.57 111.52,84.68 112.23,84.68 112.33,84.79 112.33,85.58 112.51,85.75 112.51,87.5 112.7,87.7 113.15,87.7 113.33,87.88 113.33,88.5 113.56,88.73 116.07,88.73 116.33,88.99 116.33,90.07 116.24,90.16 v3(115.93,90.16)
  IN2 w0.216: v3(107.19,57.35) 107.03,57.51 107.03,63.2 107.21,63.38 107.52,63.38 107.71,63.57 107.71,63.82 107.52,64.01 107.21,64.01 107.03,64.19 107.03,64.45 107.21,64.63 107.52,64.63 107.71,64.81 107.71,65.07 107.52,65.25 107.21,65.25 107.03,65.43 107.03,65.69 107.21,65.87 107.52,65.87 107.71,66.06 107.71,66.31 107.52,66.5 107.21,66.5 107.03,66.68 107.03,66.95 107.21,67.13 107.52,67.13 107.71,67.31 107.71,67.78 108.07,68.15 108.43,68.5 108.43,70.05 108.83,70.45 108.83,70.71 108.43,71.11 108.43,71.37 108.61,71.55 108.87,71.55 109.27,71.15 109.53,71.15 112.95,74.56 112.95,76.05 112.76,76.24 112.42,76.24 112.24,76.42 112.24,76.68 112.42,76.86 112.76,76.86 112.95,77.04 112.95,77.3 112.76,77.48 112.42,77.48 112.24,77.66 112.24,77.92 112.42,78.1 112.77,78.1 112.95,78.28 112.95,78.53 112.77,78.71 112.39,78.71 112.24,78.86 112.24,80.03 111.41,80.87 111.41,83.71
  BOTTOM w0.178: v3(115.93,90.16) U27.R9
  BOTTOM w0.191: v3(107.19,57.35) 107.55,57.35 107.7,57.5 107.7,57.85 107.4,58.16 107.4,58.39 107.6,58.59 108.01,58.59 108.25,58.84 JDIM1.107
M_B_A11: length 46.4
  IN2 w0.089: 105.22,82.55 105.22,82.76 105.34,82.87 105.34,85.38 105.71,85.75 106.1,85.75 106.34,86 106.34,86.4 106.52,86.58 106.52,87.31 106.78,87.57 107.16,87.57 107.53,87.94 107.53,88.32 107.78,88.57 108.5,88.57 108.68,88.75 109.09,88.75 109.34,89 109.34,89.63 v3(109.87,90.17)
  IN2 w0.216: 105.22,82.55 105.22,80.92 104.28,79.98 104.28,79.45 100.47,75.64 100.47,71.8 98.33,69.67 98.33,58.72 98.94,58.11 98.94,55.05 v3(100.19,53.8)
  BOTTOM w0.178: U27.Y9 109.88,90.17 v3(109.87,90.17)
  BOTTOM w0.191: JDIM1.84 101.35,52.66 100.21,53.8 v3(100.19,53.8)
M_B_A12: length 42
  IN2 w0.089: 103.53,81.74 103.53,88.05 103.64,88.16 v5(103.93,88.16)
  IN2 w0.216: 103.53,81.74 103.55,81.73 103.55,81.29 101.38,79.12 101.38,78.97 98.75,76.35 98.75,74.86 96.6,72.71 96.6,58.52 97.25,57.86 97.25,56.75 97.5,56.5 v3(97.72,56.5)
  BOTTOM w0.178: v5(103.93,88.16) 103.93,88.22 U27.AF7
  BOTTOM w0.191: JDIM1.83 101.05,58.93 99.65,57.53 99.65,56.66 99.49,56.5 v3(97.72,56.5)
M_B_A13: length 52.7
  IN2 w0.089: 114.01,83.61 114.52,84.12 114.52,85.31 114.76,85.56 115.22,85.56 115.42,85.75 115.53,85.86 115.53,86.32 115.76,86.56 116.03,86.56 116.33,86.86 116.33,87.46 116.53,87.66 116.53,88.32 116.87,88.66 117,88.66 117.33,88.99 117.33,89.77 v3(116.89,90.21)
  IN2 w0.216: v3(110.51,55.32) 110.2,55.32 109.1,54.22 109.1,52.84 108.89,52.64 108.58,52.64 108.4,52.82 108.4,54.42 109.54,55.55 109.54,60.45 109.99,60.9 109.99,66.64 115.24,71.89 115.24,80 114.01,81.23 114.01,83.61
  BOTTOM w0.178: U27.P9 116.42,90.69 v3(116.89,90.21)
  BOTTOM w0.191: v3(110.51,55.32) 111.03,55.84 111.03,56.92 111.85,57.75 JDIM1.119
M_B_A14: length 49.2
  IN2 w0.089: v3(108.93,89.16) 108.58,89.16 108.17,88.75 107.61,88.75 107.33,88.47 107.33,87.99 107.1,87.75 106.62,87.75 106.34,87.48 106.34,86.67 106.22,86.56 105.76,86.56 105.53,86.32 105.53,85.92 105.17,85.56 104.77,85.56 104.52,85.31 104.52,84.97 104.64,84.86 104.64,84.5 104.52,84.39 104.52,83.98 104.66,83.84 104.66,83.49 104.52,83.35 104.52,82.81 104.82,82.52 104.82,81.1
  IN2 w0.216: 104.82,81.1 103.71,79.99 103.71,79.69 99.89,75.88 99.89,74.39 99.12,73.61 99.12,73.11 99.8,72.42 99.8,71.95 97.76,69.9 97.76,58.58 98.29,58.04 98.29,56.12 98.02,55.85 v3(97.72,55.85)
  BOTTOM w0.178: v3(108.93,89.16) 108.93,89.22 U27.AA8
  BOTTOM w0.191: JDIM1.80 100.15,52.74 99.65,53.24 99.65,54.48 99.48,54.66 98.61,54.66 98.43,54.83 98.43,55.08 98.61,55.25 99.17,55.25 99.35,55.43 99.35,55.67 99.17,55.85 v3(97.72,55.85)
M_B_A15: length 41.8
  IN2 w0.089: 102.62,81.17 103.33,81.88 103.33,87.75 v3(102.93,88.16)
  IN2 w0.216: 102.62,81.17 100.79,79.34 100.79,79.2 98.16,76.57 98.16,75.08 96.02,72.93 96.02,58.42 96.88,57.56 96.88,55.38 v3(97.72,54.54)
  BOTTOM w0.178: U27.AG7 102.93,88.22 v3(102.93,88.16)
  BOTTOM w0.191: JDIM1.78 99.55,52.71 v3(97.72,54.54)
M_B_BS#0: length 50
  IN2 w0.089: 111.97,82.63 112.33,82.99 112.33,84.35 112.52,84.54 112.52,85.38 112.76,85.62 113.19,85.62 113.33,85.76 113.33,87.49 113.51,87.66 113.51,88.38 113.69,88.56 114.29,88.56 114.48,88.36 114.48,87.88 114.6,87.75 115.53,87.75 v5(115.93,88.16)
  IN2 w0.216: v3(107.7,56.44) 107.82,56.56 107.82,61.95 108.28,62.41 108.28,67.35 109.63,68.7 109.63,69.15 109.11,69.66 109.11,69.92 109.29,70.1 109.55,70.1 110.16,69.49 110.42,69.49 110.61,69.67 110.61,69.93 109.99,70.54 109.99,70.8 110.18,70.98 110.43,70.98 111.05,70.37 111.3,70.37 111.49,70.55 111.49,70.81 110.87,71.42 110.87,71.68 111.06,71.86 111.31,71.86 111.83,71.35 112.23,71.35 112.86,71.98 112.86,73.67 113.52,74.33 113.52,79.57 111.97,81.12 111.97,82.63
  BOTTOM w0.178: v5(115.93,88.16) U27.R7
  BOTTOM w0.191: JDIM1.109 108.85,58.6 108.41,58.16 108.41,56.76 108.09,56.44 v3(107.7,56.44)
M_B_BS#1: length 52.2
  IN2 w0.089: v3(116.93,89.16) 116.93,89.52 116.82,89.63 116.62,89.63 116.51,89.52 116.51,88.73 116.33,88.56 116.33,87.84 116.06,87.58 113.67,87.58 113.51,87.41 113.51,85.43 113.33,85.25 113.33,83.75 113.24,83.67 112.69,83.67 112.6,83.58 112.6,83.4 112.69,83.31 113.24,83.31 113.33,83.22 113.33,83.04 113.24,82.95 112.69,82.95 112.6,82.87 112.6,82.69 112.69,82.6 113.24,82.6 113.33,82.51 113.33,82.3 113.17,82.15
  IN2 w0.216: v3(107.27,55.93) 107.55,55.65 107.98,55.65 108.39,56.06 108.39,60.92 108.85,61.38 108.85,67.11 114.1,72.36 114.1,79.7 113.16,80.64 113.16,81.2 113.01,81.35 112.6,81.35 112.42,81.53 112.42,81.83 112.63,82.03 113.06,82.03 113.17,82.15
  BOTTOM w0.178: v3(116.93,89.16) U27.P8
  BOTTOM w0.191: JDIM1.108 108.55,52.71 107.49,53.77 106.81,53.77 106.43,54.15 106.43,54.51 106.66,54.73 106.66,55.06 106.35,55.37 106.35,55.75 106.53,55.93 v3(107.27,55.93)
M_B_BS#2: length 46.6
  IN2 w0.089: v3(108.93,90.16) 108.53,89.75 107.8,89.75 107.53,89.48 107.53,89.19 107.1,88.75 106.7,88.75 106.53,88.59 106.53,88.02 106.26,87.75 105.71,87.75 105.53,87.58 105.53,86.87 105.36,86.71 104.75,86.71 104.43,86.39 104.43,85.49 104.33,85.39 104.33,84.99 104.21,84.86 104.21,84.44 104.34,84.31 104.34,84.01 104.33,83.99 104.33,83.99 104.18,83.84 104.18,83.49 104.33,83.34 104.33,82.98 104.18,82.83 104.18,82.47 104.43,82.22 104.43,81.52
  IN2 w0.216: v3(97.72,57.8) 97.72,58.03 97.18,58.57 97.18,70.14 99.06,72.02 99.06,72.33 98.25,73.14 98.25,73.55 99.32,74.62 99.32,76.11 103.13,79.92 103.13,80.21 104.43,81.52
  BOTTOM w0.178: v3(108.93,90.16) 108.93,90.22 U27.AA9
  BOTTOM w0.191: JDIM1.79 99.85,58.34 99.67,58.16 99.43,58.16 98.96,58.62 98.68,58.62 98.45,58.39 98.45,58.11 98.86,57.71 98.86,57.45 98.56,57.15 98.38,57.15 v3(97.72,57.8)
M_B_CAS#: length 50.7
  IN2 w0.089: v3(116.93,88.16) 117.38,88.16 117.51,88.29 117.51,90.63 117.63,90.75 119.12,90.75 119.23,90.65 119.23,90.32 119.1,90.19 118.5,90.19 118.33,90.02 118.33,87.91 118.17,87.75 116.92,87.75 116.51,87.34 116.51,86.03 116.21,85.73 115.67,85.73 115.33,85.39 115.33,84.94 115.18,84.78 115.18,84.53 115.33,84.38 115.33,83.8 115.17,83.63 114.67,83.63
  IN2 w0.216: v3(110.51,56.64) 110.29,56.64 110.11,56.82 110.11,60.21 110.56,60.67 110.56,66.4 115.81,71.65 115.81,80.12 114.42,81.51 114.42,83.38 114.67,83.63
  BOTTOM w0.178: v3(116.93,88.16) U27.P7
  BOTTOM w0.191: v3(110.51,56.64) 110.51,56.81 111.41,57.72 111.41,58.45 111.29,58.57 110.96,58.57 110.65,58.88 JDIM1.115
M_B_CKE0: length 45.6
  IN2 w0.089: v3(103.93,91.16) 103.93,90.73 102.52,89.32 102.52,81.8
  IN2 w0.216: 102.52,81.8 97.54,76.83 97.54,75.34 95.38,73.18 95.38,56.48 95.54,56.33 v3(96.1,56.33)
  BOTTOM w0.178: U27.AF10 103.93,91.22 v3(103.93,91.16)
  BOTTOM w0.191: v3(96.1,56.33) 96.57,55.85 96.8,55.85 96.99,56.03 96.99,58.42 97.18,58.62 97.87,58.62 98.05,58.8 JDIM1.73
M_B_CKE1: length 45
  IN2 w0.089: v3(102.93,91.16) 102.93,90.19 102.34,89.6 102.34,83 101.99,82.64
  IN2 w0.216: v3(96.14,54.76) 94.8,56.11 94.8,73.4 96.36,74.97 96.36,76.46 101.99,82.08 101.99,82.64
  BOTTOM w0.178: v3(102.93,91.16) 102.93,91.22 U27.AG10
  BOTTOM w0.191: v3(96.14,54.76) 98.35,52.55 JDIM1.74
M_B_CLKN0: length 48.7
  IN2 w0.089: v3(110.93,85.16) 110.77,85.31 110.47,85.31 110.37,85.21 110.37,84.7 110.19,84.52 109.65,84.52 109.5,84.37 109.5,83.53 109.64,83.4 110.27,83.4 110.57,83.1 110.57,79.82 110.8,79.59 110.8,79.21 110.85,79.16 110.85,79.14
  IN2 w0.133: v3(105.7,57.02) 104.73,56.06 104.73,53.09 104.56,52.92 104.28,52.92 104.11,53.09 104.11,56.25 105.16,57.29 105.16,58.04 105.64,58.52 105.64,67.68 107.03,69.08 107.03,72.88 110.85,76.69 110.85,79.14
  BOTTOM w0.114: U27.Y4 110.7,85.69 110.93,85.46 v3(110.93,85.16)
  BOTTOM w0.127: v3(105.7,57.02) 105.49,56.82 105.05,56.82 104.89,56.99 104.89,57.66 105.34,58.11 106.56,58.11 106.89,58.43 106.89,58.68 107.05,58.85 JDIM1.103
M_B_CLKN1: length 47.7
  IN2 w0.089: v3(110.94,84.2) 110.68,84.2 110.54,84.06 110.54,83.92 111.03,83.43 111.03,80.38 111.61,79.8 111.61,79.21 111.66,79.16 111.66,79.14
  IN2 w0.133: v3(105.69,54.38) 105.69,54.78 105.83,54.92 106.29,54.92 106.66,55.29 106.66,56.23 106.45,56.44 106.45,67.35 107.85,68.74 107.85,72.54 108.23,72.93 108.42,72.93 109.24,72.1 109.66,72.1 110.02,72.46 110.02,72.86 109.19,73.69 109.19,73.88 109.38,74.08 109.57,74.08 110.39,73.25 110.81,73.25 111.17,73.61 111.17,74.01 110.34,74.85 110.34,75.03 110.53,75.23 110.72,75.23 111.51,74.45 112.01,74.45 112.34,74.78 112.34,75.26 111.66,75.95 111.66,79.14
  BOTTOM w0.114: U27.Y3 110.88,84.2 v3(110.94,84.2)
  BOTTOM w0.127: JDIM1.104 107.35,52.67 107.19,52.83 107.19,53.04 106.89,53.34 105.88,53.34 105.13,54.09 105.13,54.66 105.32,54.85 105.55,54.85 105.69,54.71 v3(105.69,54.38)
M_B_CLKP0: length 48.8
  IN2 w0.089: 110.57,79.14 110.57,79.16 110.62,79.21 110.62,79.52 110.39,79.75 110.39,83.03 110.2,83.22 109.56,83.22 109.32,83.46 109.32,84.45 109.58,84.7 110.12,84.7 110.19,84.78 110.19,84.89 v5(109.93,85.16)
  IN2 w0.133: v3(105.7,56.34) 105.4,56.34 105.01,55.95 105.01,52.98 104.68,52.65 104.16,52.65 103.84,52.98 103.84,56.36 104.88,57.4 104.88,58.15 105.36,58.63 105.36,67.8 106.76,69.19 106.76,72.99 110.57,76.81 110.57,79.14
  BOTTOM w0.114: U27.AA4 109.64,85.69 109.93,85.39 v5(109.93,85.16)
  BOTTOM w0.127: v3(105.7,56.34) 105.49,56.55 104.94,56.55 104.62,56.88 104.62,57.77 105.23,58.38 106.45,58.38 106.62,58.54 106.62,58.68 106.45,58.85 JDIM1.101
M_B_CLKP1: length 47.7
  IN2 w0.089: v3(109.93,84.12) 110.26,84.12 110.36,84.01 110.36,83.84 110.85,83.36 110.85,80.31 111.43,79.73 111.43,79.21 111.39,79.16 111.39,79.14
  IN2 w0.133: 111.39,79.14 111.39,75.83 112.07,75.15 112.07,74.9 111.89,74.72 111.62,74.72 110.84,75.5 110.42,75.5 110.06,75.15 110.06,74.73 110.9,73.9 110.9,73.72 110.7,73.53 110.5,73.53 109.68,74.35 109.27,74.35 108.91,74 108.91,73.58 109.74,72.75 109.74,72.57 109.55,72.38 109.35,72.38 108.53,73.2 108.12,73.2 107.57,72.66 107.57,68.86 106.18,67.46 106.18,56.33 106.39,56.12 106.39,55.4 106.17,55.19 105.85,55.19 105.69,55.34 v3(105.69,55.67)
  BOTTOM w0.114: U27.AA3 109.93,84.15 v3(109.93,84.12)
  BOTTOM w0.127: JDIM1.102 106.75,52.67 106.92,52.84 106.92,52.93 106.78,53.07 105.77,53.07 104.86,53.98 104.86,54.77 105.21,55.11 105.54,55.11 105.69,55.27 v3(105.69,55.67)
M_B_CS#0: length 49.7
  IN2 w0.216: v5(116.93,85.16) 117.45,84.63 117.45,81.67 119.6,79.53 119.6,79.25 120.49,78.36 120.49,70.1 114.97,64.58 114.97,60.84 113.08,58.95 113.08,54.02 114.32,52.79 114.32,52.15 114.16,52 111.83,52 111.66,52.16 111.66,52.44 111.87,52.65 112.86,52.65 113.03,52.82 113.03,53.1 112.32,53.82 v3(111.56,53.82)
  BOTTOM w0.178: v5(116.93,85.16) U27.P4
  BOTTOM w0.191: v3(111.56,53.82) 111.17,54.21 110.62,54.21 110.43,54.02 110.11,54.02 109.96,53.87 109.96,53.05 110.35,52.66 JDIM1.114
M_B_CS#1: length 46.7
  IN2 w0.216: v3(111.55,56.8) 111.22,57.12 111.22,59.91 111.76,60.44 111.76,61.94 111.94,62.13 112.24,62.13 112.42,62.31 112.42,62.57 112.24,62.75 111.94,62.75 111.76,62.93 111.76,63.19 111.94,63.37 112.28,63.37 112.46,63.55 112.46,63.81 112.28,63.99 111.94,63.99 111.76,64.18 111.76,64.55 111.92,64.71 112.32,64.71 112.46,64.85 112.46,65.18 112.3,65.35 111.91,65.35 111.76,65.5 111.76,65.91 112.25,66.4 112.51,66.4 112.86,66.04 113.12,66.04 113.3,66.23 113.3,66.48 112.95,66.84 112.95,67.1 113.13,67.28 113.39,67.28 113.72,66.95 113.98,66.95 114.16,67.13 114.16,67.39 113.83,67.72 113.83,67.98 114.01,68.16 114.27,68.16 114.59,67.84 114.84,67.84 115.03,68.02 115.03,68.28 114.71,68.6 114.71,68.86 114.89,69.04 115.15,69.04 115.49,68.7 115.75,68.7 115.93,68.88 115.93,69.14 115.59,69.48 115.59,69.74 115.77,69.92 116.03,69.92 116.31,69.64 116.57,69.64 116.75,69.82 116.75,70.08 116.47,70.36 116.47,70.62 117.01,71.16 117.01,80.35 115.85,81.5 v5(115.85,83.23)
  BOTTOM w0.178: v5(115.85,83.23) U27.R2
  BOTTOM w0.191: v3(111.55,56.8) 111.57,56.82 113.06,56.82 113.19,56.95 113.19,57.2 113.09,57.3 112.58,57.3 112.35,57.53 112.35,57.86 112.49,58.01 113.57,58.01 113.72,58.16 113.72,58.49 113.59,58.62 112.58,58.62 112.45,58.74 JDIM1.121
M_B_DQ0: length 69.5
  IN2 w0.133: v3(94.93,99.15) 94.47,99.62 92.7,99.62 90.78,97.69 86.01,97.69 84.84,96.52 82.6,96.52 70.22,84.14 70.22,72.58 72.57,70.23 72.57,65.74 71.81,64.99 71.81,59.4 70.46,58.05 70.46,55.14 71.45,54.15 73.67,54.15 74,53.82 v3(74,53.8)
  BOTTOM w0.114: v3(94.93,99.15) 94.93,99.22 U27.AR18
  BOTTOM w0.127: JDIM1.4 74.95,52.84 v3(74,53.8)
M_B_DQ1: length 67.8
  IN2 w0.133: v5(93.93,99.15) 93.11,99.15 91.26,97.31 86.17,97.31 84.57,95.7 82.33,95.7 70.61,83.98 70.61,72.74 72.95,70.39 72.95,65.58 72.31,64.94 72.31,59.35 70.87,57.9 70.87,55.29 71.63,54.53 73.67,54.53 v3(73.8,54.66)
  BOTTOM w0.114: U27.AT18 93.93,99.22 v5(93.93,99.15)
  BOTTOM w0.127: v3(73.8,54.66) 74.71,53.75 74.71,53.64 75.55,52.79 JDIM1.6
M_B_DQ2: length 73.4
  IN2 w0.089: v3(97.93,98.15) 97.93,97.72 97.53,97.32 97.53,96.73 97.36,96.56 96.76,96.56 96.53,96.32 96.53,95.86 96.22,95.56 95.76,95.56 95.41,95.2 95.41,94.86 95.2,94.66 94.69,94.66 94.47,94.44 94.47,93.87 94.26,93.67 93.48,93.67 92.41,92.6
  IN2 w0.133: 92.41,92.6 92.22,92.41 89.25,92.41 89.08,92.25 89.08,91.26 88.92,91.1 88.67,91.1 88.53,91.23 88.53,92.28 88.4,92.41 88.13,92.41 87.99,92.28 87.99,91.23 87.86,91.1 87.59,91.1 87.45,91.23 87.45,92.28 87.32,92.41 87.05,92.41 86.91,92.28 86.91,91.23 86.78,91.1 85.53,91.1 85.4,90.96 85.4,90.5 85.27,90.37 84.99,90.37 84.86,90.5 84.86,90.96 84.73,91.1 84.45,91.1 84.32,90.96 84.32,90.5 84.19,90.37 83.91,90.37 83.78,90.5 83.78,90.96 83.65,91.1 83.34,91.1 83.19,90.95 83.19,90.54 83.01,90.37 81.75,90.37 74.97,83.58 74.97,80.32 74.53,79.88 74.53,79.42 74.39,79.29 74.08,79.29 73.95,79.16 73.95,78.88 74.08,78.75 74.39,78.75 74.53,78.62 74.53,78.34 74.39,78.21 74.08,78.21 73.95,78.08 73.95,77.8 74.08,77.67 74.39,77.67 74.53,77.54 74.53,76.97 75.21,76.29 75.21,73.2 76.84,71.57 76.84,66.94 77.42,66.36 77.42,58.88 77.53,58.77 77.53,56.87 v3(77.15,56.49)
  BOTTOM w0.114: v3(97.93,98.15) 97.93,98.22 U27.AM17
  BOTTOM w0.127: v3(77.15,56.49) 78.57,57.91 78.57,58.7 78.85,58.98 JDIM1.17
M_B_DQ3: length 72.3
  IN2 w0.089: 92.41,93.2 93.77,94.56 94.17,94.56 94.52,94.91 94.52,95.58 94.68,95.75 96.15,95.75 96.34,95.94 96.34,96.4 96.68,96.75 97.09,96.75 97.34,97 97.34,97.4 97.52,97.58 97.52,98.75 v5(97.93,99.15)
  IN2 w0.133: 92.41,93.2 92.01,92.8 86.66,92.8 86.53,92.67 86.53,91.62 86.39,91.48 86.11,91.48 85.97,91.62 85.97,92.67 85.84,92.8 85.57,92.8 85.43,92.67 85.43,91.62 85.3,91.48 85.03,91.48 84.89,91.62 84.89,92.67 84.76,92.8 84.49,92.8 84.36,92.67 84.36,91.62 84.22,91.48 83.93,91.48 83.79,91.62 83.79,92.25 83.66,92.39 83.39,92.39 83.26,92.25 83.26,91.56 82.69,91 81.83,91 74.58,83.75 74.58,80.48 73.53,79.44 73.53,77.41 74.82,76.13 74.82,73.04 76.33,71.53 76.33,66.9 77.03,66.2 77.03,61.08 76.9,60.95 76.29,60.95 76.16,60.81 76.16,60.54 76.29,60.41 76.9,60.41 77.03,60.27 77.03,59.21 76.59,58.77 76.59,57.66 v3(77.06,57.18)
  BOTTOM w0.114: U27.AM18 97.93,99.22 v5(97.93,99.15)
  BOTTOM w0.127: v3(77.06,57.18) 78.25,58.38 JDIM1.15
M_B_DQ4: length 69.4
  IN2 w0.089: 92.41,96.99 93.17,97.75 94.21,97.75 94.61,98.15 v5(94.93,98.15)
  IN2 w0.133: v3(73.99,56.44) 74.46,56.91 74.46,58.79 73.09,60.16 73.09,63.12 73.22,63.26 73.59,63.26 73.73,63.39 73.73,63.66 73.59,63.8 73.22,63.8 73.09,63.93 73.09,64.33 73.24,64.48 73.54,64.48 73.73,64.67 73.73,70.71 71.38,73.06 71.38,83.66 72.22,84.49 72.26,84.49 82.7,94.93 86.83,94.93 86.97,95.06 86.97,95.45 87.1,95.59 87.37,95.59 87.51,95.45 87.51,95.06 87.64,94.93 87.91,94.93 88.04,95.06 88.04,95.45 88.18,95.59 88.45,95.59 88.58,95.45 88.58,95.06 88.72,94.93 88.99,94.93 89.12,95.06 89.12,95.45 89.26,95.59 89.53,95.59 89.66,95.45 89.66,95.06 89.8,94.93 90.07,94.93 90.2,95.06 90.2,95.45 90.34,95.59 90.61,95.59 90.74,95.45 90.74,95.06 90.88,94.93 91.13,94.93 92.29,96.09 92.29,96.87 92.41,96.99
  BOTTOM w0.114: U27.AR17 94.93,98.22 v5(94.93,98.15)
  BOTTOM w0.127: v3(73.99,56.44) 75.85,58.31 JDIM1.7
M_B_DQ5: length 67.7
  IN2 w0.102: v3(93.93,98.15) 92.91,98.15
  IN2 w0.133: 92.91,98.15 92.74,98.15 90.56,95.98 90.18,95.98 90.04,96.11 90.04,96.76 89.91,96.89 89.64,96.89 89.5,96.76 89.5,96.11 89.37,95.98 89.1,95.98 88.96,96.11 88.96,96.76 88.83,96.89 88.56,96.89 88.42,96.76 88.42,96.11 88.29,95.98 87.9,95.98 87.77,96.11 87.77,96.74 87.64,96.87 87.36,96.87 87.23,96.74 87.23,96.11 87.1,95.98 86.82,95.98 86.69,96.11 86.69,96.74 86.56,96.87 86.28,96.87 86.15,96.74 86.15,95.54 85.93,95.32 82.49,95.32 70.99,83.82 70.99,72.9 73.34,70.55 73.34,65.42 72.7,64.78 72.7,59.99 73.51,59.17 73.51,57.61 v3(74,57.13)
  BOTTOM w0.114: U27.AT17 93.93,98.22 v3(93.93,98.15)
  BOTTOM w0.127: JDIM1.5 75.25,58.38 v3(74,57.13)
M_B_DQ6: length 72.3
  IN2 w0.089: v5(96.93,98.15) 96.34,97.56 96.34,96.94 96.15,96.75 94.68,96.75 94.34,96.4 94.34,95.94 94.12,95.72 93.84,95.72 92.41,94.29
  IN2 w0.133: v3(77.15,54.41) 76.69,54.87 76.69,55.03 76.3,55.42 76.3,56.43 75.81,56.92 75.81,59.35 75.08,60.08 75.08,64.35 75.21,64.48 76.12,64.48 76.26,64.62 76.26,64.89 76.12,65.02 75.27,65.02 75.13,65.16 75.13,65.43 75.27,65.56 75.56,65.56 75.69,65.7 75.69,65.97 75.56,66.1 75.21,66.1 75.08,66.24 75.08,66.84 75.21,66.98 75.42,66.98 75.56,67.11 75.56,67.38 75.42,67.52 75.21,67.52 75.08,67.65 75.08,67.92 75.21,68.06 75.42,68.06 75.56,68.19 75.56,68.46 75.42,68.6 75.21,68.6 75.08,68.73 75.08,69 75.21,69.14 75.42,69.14 75.56,69.27 75.56,69.54 75.42,69.68 75.21,69.68 75.08,69.81 75.08,71.68 73.99,72.77 73.99,75.86 72.76,77.09 72.76,79.76 73.13,80.13 73.13,80.43 72.76,80.81 72.76,81 72.89,81.13 73.42,81.13 73.56,81.26 73.56,81.53 73.42,81.67 72.89,81.67 72.76,81.8 72.76,82.07 72.89,82.21 73.45,82.21 73.58,82.34 73.58,83.86 83.29,93.58 91.69,93.58 92.41,94.29
  BOTTOM w0.114: U27.AN17 96.93,98.22 v5(96.93,98.15)
  BOTTOM w0.127: JDIM1.16 78.55,53.15 77.29,54.41 v3(77.15,54.41)
M_B_DQ7: length 71.4
  IN2 w0.089: v3(96.93,99.15) 97.33,98.75 97.33,97.99 96.9,97.56 96.76,97.56 96.53,97.32 96.53,96.86 96.22,96.56 94.76,96.56 94.53,96.32 94.53,95.86 94.33,95.66 94.33,94.99 94.1,94.75 93.42,94.75 92.41,93.75
  IN2 w0.133: 92.41,93.75 91.85,93.19 83.47,93.19 74.88,84.6 74.19,83.91 74.19,80.64 73.15,79.6 73.15,77.25 74.43,75.97 74.43,72.89 75.94,71.37 75.94,66.7 76.64,66 76.64,64.14 76.47,63.96 75.68,63.96 75.54,63.83 75.54,63.56 75.68,63.42 76.27,63.42 76.38,63.31 76.38,63.04 76.22,62.88 75.68,62.88 75.54,62.75 75.54,62.48 75.68,62.34 76.31,62.34 76.44,62.21 76.44,61.94 76.31,61.8 75.81,61.8 75.62,61.61 75.62,60.09 76.2,59.51 76.2,57.08 76.69,56.59 76.69,55.59 77.15,55.13 v3(77.15,55.09)
  BOTTOM w0.114: U27.AN18 96.93,99.22 v3(96.93,99.15)
  BOTTOM w0.127: JDIM1.18 79.15,53 78.44,53.71 78.44,54.22 77.57,55.09 v3(77.15,55.09)
M_B_DQ8: length 56.6
  IN2 w0.089: 92.49,91.87 93.78,93.16 v3(93.93,93.16)
  IN2 w0.133: v3(79.16,54.46) 77.96,55.66 77.96,66.58 77.4,67.14 77.4,71.81 75.78,73.43 75.78,83.63 81.97,89.83 85.58,89.83 86.31,90.56 89.28,90.56 90.6,91.87 92.49,91.87
  BOTTOM w0.114: U27.AT12 93.93,93.22 v3(93.93,93.16)
  BOTTOM w0.127: JDIM1.22 80.35,53.26 v3(79.16,54.46)
M_B_DQ9: length 57.8
  IN2 w0.089: 92.58,91.49 93.75,92.66 94.43,92.66 v3(94.93,93.16)
  IN2 w0.133: 92.58,91.49 92.58,91.49 90.76,91.49 89.44,90.17 86.47,90.17 85.74,89.44 82.13,89.44 76.17,83.47 76.17,74.38 77.8,72.74 77.8,67.28 78.35,66.74 78.35,55.99 78.53,55.81 v3(79.1,55.81)
  BOTTOM w0.114: v3(94.93,93.16) 94.93,93.22 U27.AR12
  BOTTOM w0.127: v3(79.1,55.81) 79.45,55.81 80.95,54.3 JDIM1.24
M_B_DQ10: length 61.8
  IN2 w0.089: 93.34,88.66 94,88.66 94.33,88.99 94.33,89.15 94.8,89.63 95.1,89.63 95.43,89.96 95.43,90.37 95.71,90.65 96.09,90.65 96.43,90.99 96.43,91.26 96.84,91.67 97.14,91.67 97.33,91.86 97.33,92.75 v3(96.93,93.16)
  IN2 w0.133: 93.34,88.66 92.81,88.66 89.98,85.84 87.09,85.84 86.9,85.64 86.9,85.38 86.77,85.25 86.49,85.25 86.36,85.38 86.36,85.78 86.23,85.91 85.95,85.91 85.82,85.78 85.82,85.38 85.69,85.25 85.41,85.25 85.28,85.38 85.28,85.78 85.15,85.91 84.87,85.91 84.74,85.78 84.74,85.38 84.61,85.25 84.33,85.25 84.2,85.38 84.2,85.78 84.07,85.91 83.8,85.91 83.66,85.78 83.66,85.43 83.52,85.29 83.13,85.29 83,85.42 83,85.71 82.87,85.84 82.59,85.84 82.46,85.71 82.46,85.42 82.33,85.29 81.54,85.29 78.68,82.43 78.68,76.7 80.76,74.62 80.76,67.9 81.54,67.13 81.54,58.59 81.72,58.41 81.72,57.4 82.46,56.66 v3(82.46,56.01)
  BOTTOM w0.114: v3(96.93,93.16) 96.93,93.22 U27.AN12
  BOTTOM w0.127: JDIM1.35 84.25,58.75 83.45,57.94 83.45,57 v3(82.46,56.01)
M_B_DQ11: length 62.6
  IN2 w0.089: 93.56,87.55 93.57,87.56 94.9,87.56 95.33,87.99 95.33,88.13 95.95,88.75 96.13,88.75 96.47,89.09 96.47,89.26 96.96,89.75 97.1,89.75 97.53,90.19 97.53,91.37 97.86,91.69 97.86,92.08 v3(97.93,92.16)
  IN2 w0.133: v3(82.53,53.87) 82.91,54.26 82.91,58.21 82.5,58.62 82.5,67.89 82.69,68.07 82.69,74.69 79.56,77.82 79.56,82.21 81.75,84.4 85.43,84.4 85.57,84.26 85.57,83.69 85.7,83.56 85.97,83.56 86.11,83.69 86.11,84.26 86.24,84.4 86.51,84.4 86.65,84.26 86.65,83.69 86.78,83.56 87.05,83.56 87.19,83.69 87.19,84.26 87.32,84.4 87.59,84.4 87.73,84.26 87.73,83.72 87.86,83.58 88.13,83.58 88.26,83.72 88.26,84.26 88.4,84.4 88.67,84.4 88.8,84.26 88.8,83.72 88.94,83.58 89.21,83.58 89.34,83.72 89.34,84.26 89.48,84.4 90.06,84.4 93.22,87.55 93.56,87.55
  BOTTOM w0.114: v3(97.93,92.16) 97.93,92.22 U27.AM11
  BOTTOM w0.127: v3(82.53,53.87) 82.84,53.87 83.95,52.76 JDIM1.34
M_B_DQ12: length 56.2
  IN2 w0.089: 92.7,91.1 93.75,92.16 v3(93.93,92.16)
  IN2 w0.133: v3(79.16,57.79) 78.73,58.21 78.73,66.9 78.21,67.42 78.21,72.92 76.55,74.57 76.55,83.31 81.93,88.69 82.17,88.69 82.27,88.59 82.27,88.21 82.43,88.06 82.69,88.06 82.83,88.21 82.83,88.92 82.96,89.05 83.29,89.05 83.42,88.93 83.42,88.19 83.55,88.06 83.82,88.06 83.96,88.19 83.96,88.77 84.12,88.93 86.58,88.93 86.73,89.08 86.73,89.6 86.86,89.73 87.14,89.73 87.27,89.6 87.27,89.06 87.4,88.93 87.68,88.93 87.81,89.06 87.81,89.6 87.94,89.73 88.21,89.73 88.35,89.6 88.35,89.06 88.48,88.93 88.75,88.93 90.66,90.84 92.44,90.84 92.7,91.1
  BOTTOM w0.114: U27.AT11 93.93,92.22 v3(93.93,92.16)
  BOTTOM w0.127: JDIM1.21 80.05,58.68 v3(79.16,57.79)
M_B_DQ13: length 57.8
  IN2 w0.089: 92.54,90.45 93.73,91.64 93.98,91.64 94.5,92.16 v5(94.93,92.16)
  IN2 w0.133: 92.54,90.45 90.82,90.45 88.91,88.54 84.92,88.54 84.05,87.67 81.47,87.67 76.94,83.15 76.94,75.89 78.62,74.21 78.62,67.57 79.38,66.8 79.38,66.15 79.12,65.89 79.12,65.62 79.25,65.48 79.51,65.48 79.64,65.35 79.64,65.08 79.51,64.94 79.25,64.94 79.12,64.81 79.12,64.54 79.25,64.4 79.51,64.4 79.64,64.27 79.64,64 79.51,63.86 79.25,63.86 79.12,63.73 79.12,63.46 79.25,63.32 79.51,63.32 79.64,63.19 79.64,62.92 79.51,62.78 79.25,62.78 79.12,62.65 79.12,62.38 79.25,62.24 79.51,62.24 79.64,62.11 79.64,61.84 79.51,61.7 79.25,61.7 79.12,61.57 79.12,61.3 79.25,61.16 79.51,61.16 79.64,61.03 79.64,60.76 79.51,60.62 79.25,60.62 79.12,60.49 79.12,60.22 79.25,60.08 79.51,60.08 79.64,59.95 79.64,59.68 79.51,59.54 79.25,59.54 79.12,59.41 79.12,59.13 79.64,58.61 79.64,57.61 v3(79.16,57.13)
  BOTTOM w0.114: U27.AR11 94.93,92.22 v5(94.93,92.16)
  BOTTOM w0.127: JDIM1.23 80.65,58.88 80.48,58.7 80.48,58.45 v3(79.16,57.13)
M_B_DQ14: length 62.8
  IN2 w0.089: v3(97.93,93.16) 97.53,92.75 97.53,91.64 97.33,91.44 97.33,90.92 97.17,90.75 96.79,90.75 96.34,90.31 96.34,89.94 96.15,89.75 95.78,89.75 95.33,89.3 95.33,88.99 95.1,88.75 94.7,88.75 94.33,88.38 94.33,87.99 94.1,87.75 93.01,87.75
  IN2 w0.133: v3(82.48,57.35) 82.06,57.78 82.06,67.16 81.16,68.06 81.16,68.45 81.29,68.59 81.48,68.59 81.61,68.72 81.61,68.99 81.48,69.13 81.29,69.13 81.16,69.26 81.16,69.53 81.29,69.67 81.99,69.67 82.12,69.8 82.12,70.07 81.99,70.21 81.29,70.21 81.16,70.34 81.16,70.61 81.29,70.74 82.02,70.74 82.15,70.88 82.15,71.15 82.02,71.28 81.29,71.28 81.16,71.42 81.16,71.69 81.29,71.82 82.01,71.82 82.15,71.96 82.15,72.23 82.01,72.36 81.29,72.36 81.16,72.5 81.16,75.66 79.15,77.67 79.15,82.35 81.59,84.78 87.24,84.78 87.37,84.92 87.37,85.32 87.51,85.45 87.78,85.45 87.91,85.32 87.91,84.92 88.05,84.78 88.32,84.78 88.45,84.92 88.45,85.29 88.59,85.43 88.86,85.43 88.99,85.29 88.99,84.92 89.13,84.78 89.44,84.78 89.56,84.91 89.56,85.31 89.64,85.39 90.5,85.39 92.87,87.75 93.01,87.75
  BOTTOM w0.114: v3(97.93,93.16) 97.93,93.22 U27.AM12
  BOTTOM w0.127: JDIM1.33 83.65,58.6 83.07,58.02 83.07,57.94 v3(82.48,57.35)
