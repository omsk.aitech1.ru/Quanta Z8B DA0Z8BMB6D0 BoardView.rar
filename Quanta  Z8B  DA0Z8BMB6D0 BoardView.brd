# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_IREF: length 6.6
  BOTTOM w0.127: v3(147.63,109.97) 148.12,109.48 R499.2 150.43,109.12 152.26,107.3 U24.BE30
PCIE_LAN_WAKE#: length 384.1
  TOP w0.127: v3(146.18,44.54) 146.03,44.54 145.22,43.73 145.22,24.88 148.06,22.04 148.06,20.19 147.6,19.73 147.6,16.61 149.44,14.78 154.89,14.78 155.69,15.57 180.7,15.57 181.45,16.32 181.45,17.54 182.27,18.37 182.27,20.26 186.69,24.68 186.69,28.54 185.48,29.76 185.48,37.03 186.34,37.89 186.34,43.27 185.43,44.18 v3(185.43,44.66) ; v3(45.19,34.64) 45.17,34.64 v2(42.47,37.33) 40.31,39.49 40.31,40.53 39.22,41.62 39.22,43.14 36.73,45.64 32.88,45.64 32.22,44.98 29.59,44.98 28.96,45.61 v3(26.48,45.61) ; Q17.3 23.05,106.93 v3(23.05,105.48) R118.1
  IN1 w0.133: v3(26.48,45.61) 25.73,46.36 25.73,64.55 27.75,66.57 30.77,66.57 32.13,67.92 32.13,72.96 32.95,73.78 32.95,85.03 32.44,85.54 32.44,89.22 28.99,92.67 25.6,92.67 24.19,94.08 24.19,100.63 23.4,101.42 23.4,105.13 v3(23.05,105.48) ; v3(45.19,34.64) 45.76,34.64 47.86,32.54 48.89,32.54 49.69,31.75 49.69,24.97 52.75,21.9 67.58,21.9 73.92,28.24 81.11,28.24 83.27,30.4 132.65,30.4 139.9,37.66 139.9,39.13 145.27,44.49 146.13,44.49 v3(146.18,44.54) 146.18,45.5 159.72,59.04 159.72,60.1 160.02,60.39 160.02,74.27 165.17,79.42 165.17,80.65 167.89,83.38 167.89,83.84 167.94,83.88 167.94,88.36 168.1,88.53 168.1,88.74 170.12,90.76 v3(170.51,90.76)
  BOTTOM w0.102: R579.1 170.51,90.67 v3(170.51,90.76) 170.51,91.22 169.22,92.51 168.67,92.51 167.09,94.09 167.09,94.66 167.18,94.75 167.18,95.26 167.19,95.28 167.19,95.28 167.39,95.48 167.39,95.95 U24.K3
  BOTTOM w0.127: Q56.1 185.83,46.42 185.98,46.27 R689.2 v3(185.43,44.66)
PCIE_LAN_WAKE#_R: length 14.7
  TOP w0.127: U7.21 27.72,101.11 27.85,101.25 27.85,102.47 27.18,103.14 v2(26.01,103.14) 22.83,103.14 R125.1 R118.2 22.25,105.37 22.25,107.98 23.3,109.02 Q17.1
PCIE_RCOMP: length 6
  BOTTOM w0.127: U24.BD29 151.97,106.87 150.44,108.4 v3(149.13,108.4) 148.55,108.4 R503.1
PCIE_REQ_LAN#_R: length 13.2
  TOP w0.127: Q18.1 33.96,103.88 33.72,103.64 R133.2 34.01,103.07 34.19,103.24 35.43,103.24 R130.1 35.51,103.16 35.51,102.94 34.75,102.18 v2(34.75,101.75) 34.75,99.21 33.46,97.92 32.3,97.92 32.08,98.14 31.82,98.14 31.82,98.14 U7.12
PCIE_RX3+_WLAN: length 79.2
  IN2 w0.133: v3(154.99,108.18) 155.2,107.97 155.2,107.71 155.53,107.38 157.33,107.38 158.12,106.6 158.12,104.84 158.37,104.59 158.37,104.36 159.31,103.42 159.85,103.42 160.3,102.96 160.3,100.75 160.71,100.34 161.77,100.34 162.03,100.09 162.03,97.25 161.39,96.62 161.39,96 163.02,94.38 163.02,90.27 162.25,89.5 162.25,88.48 162.65,88.08 162.65,84.23 161.25,82.82 161.25,65.89 162.1,65.04 162.1,58.21 162.69,57.63 162.69,53.15 162.92,52.93 163.16,52.93 v3(163.44,52.65)
  BOTTOM w0.127: v3(154.99,108.18) 154.82,108.35 U24.AY33 ; CN10.25 175.5,52.17 175.78,52.45 175.78,52.58 174.33,54.03 170.67,54.03 169.73,53.09 163.89,53.09 v3(163.44,52.65)
PCIE_RX3-_WLAN: length 79.2
  IN2 w0.133: v3(163.44,53.41) 163.22,53.18 163.02,53.18 162.94,53.26 162.94,57.73 162.36,58.32 162.36,65.14 161.51,66 161.51,82.72 162.91,84.12 162.91,88.18 162.51,88.58 162.51,89.39 163.27,90.16 163.27,94.48 161.65,96.11 161.65,96.51 162.28,97.15 162.28,100.2 161.88,100.6 160.81,100.6 160.56,100.86 160.56,103.07 159.95,103.67 159.42,103.67 158.62,104.46 158.62,104.69 158.37,104.95 158.37,106.7 157.43,107.64 155.63,107.64 155.45,107.82 155.45,107.96 v3(155.66,108.17)
  BOTTOM w0.127: v3(163.44,53.41) 163.52,53.33 169.63,53.33 170.57,54.27 174.43,54.27 176.02,52.68 176.02,52.45 176.3,52.17 CN10.23 ; U24.AW33 155.6,108.67 155.73,108.54 155.73,108.24 v3(155.66,108.17)
PCIE_RX4+_LAN: length 154.4
  TOP w0.127: v4(37.9,103.19) 38.03,103.06 38.18,103.06 38.4,103.27 38.4,103.66 34.61,107.45 31.82,107.45 30.11,105.74 30.11,104.97 C157.2
  IN2 w0.102: 153.82,108.82 153.85,108.82 153.88,108.8 156.69,108.8 156.88,108.6 157.35,108.6 v3(157.71,108.25)
  IN2 w0.133: v4(37.9,103.19) 37.9,103.12 38.11,102.91 38.81,102.91 39.01,103.11 46.76,103.11 47.4,103.76 51.52,103.76 52.09,103.19 53.67,103.19 55.2,101.66 70.93,101.66 84.56,115.28 85.71,115.28 90.16,119.74 90.98,119.74 96.04,124.8 96.99,124.8 99.46,127.28 103.05,127.28 107.09,123.23 115.57,123.23 116.31,123.97 133.83,123.97 143.73,114.07 145.32,114.07 145.94,113.44 148.55,113.44 153.16,108.82 153.82,108.82
  BOTTOM w0.102: v3(157.71,108.25) 157.82,108.35 157.82,108.47 157.49,108.8 157.35,108.8 U24.AR33
PCIE_RX4-_LAN: length 154.4
  TOP w0.127: C156.2 29.87,104.98 29.87,105.84 31.72,107.69 34.71,107.69 38.64,103.76 38.64,103.17 37.93,102.46 v3(37.89,102.46)
  IN2 w0.102: v3(157,108.2) 156.6,108.59 153.88,108.59 153.85,108.57 153.82,108.57
  IN2 w0.133: 153.82,108.57 153.06,108.57 148.44,113.18 145.84,113.18 145.21,113.81 143.63,113.81 133.73,123.72 116.42,123.72 115.68,122.98 106.99,122.98 102.95,127.02 99.57,127.02 97.09,124.54 96.15,124.54 91.09,119.48 90.27,119.48 85.81,115.03 84.66,115.03 71.04,101.4 55.1,101.4 53.57,102.94 51.98,102.94 51.42,103.5 47.51,103.5 46.86,102.85 39.11,102.85 38.91,102.65 38.09,102.65 v3(37.89,102.46)
  BOTTOM w0.102: v3(157,108.2) 156.62,108.58 U24.AT33
PCIE_TX3+: length 5.4
  BOTTOM w0.102: U24.BC34 153.33,108.92 152.99,108.58 152.66,108.58
  BOTTOM w0.127: 152.66,108.58 151.91,108.58 149.98,110.5 149.59,110.5 C424.1
PCIE_TX3+_WLAN: length 108.2
  IN2 w0.133: v4(141.11,78.86) 141.11,78.76 141.26,78.61 142.28,78.61 153.28,67.61 153.28,64.19 154.11,63.36 154.11,51.88 154.69,51.29 154.69,48.79 154.41,48.5 154.17,48.5 v3(153.93,48.26)
  BOTTOM w0.127: v3(153.93,48.26) 154.19,48.52 154.36,48.52 155.11,47.77 160.57,47.77 161.55,48.75 163.01,48.75 163.86,49.6 163.86,51.3 164.77,52.22 170.1,52.22 171.02,53.14 172.31,53.14 172.56,52.88 172.56,52.51 172.3,52.25 CN10.33 ; C424.2 148.61,110.51 148.29,110.82 148.02,110.82 147.77,111.07 147.77,111.73 146.69,112.81 143.14,112.81 140.17,109.84 140.17,109.2 137.32,106.34 137.32,80.41 139.1,78.62 141.04,78.62 141.11,78.69 v4(141.11,78.86)
PCIE_TX3-: length 5.4
  BOTTOM w0.102: 152.66,108.82 152.79,108.82 U24.BE34
  BOTTOM w0.127: 152.66,108.82 152.01,108.82 150.08,110.75 149.08,110.75 149.01,110.82 149.01,110.94 C423.1
PCIE_TX3-_WLAN: length 108.2
  IN2 w0.133: v3(153.93,49.02) 154.19,48.76 154.3,48.76 154.44,48.89 154.44,51.19 153.85,51.77 153.85,63.25 153.51,63.59 153.02,64.08 153.02,67.51 142.17,78.36 141.36,78.36 v3(141.11,78.1)
  BOTTOM w0.127: CN10.31 173.1,52.34 172.8,52.64 172.8,52.98 172.41,53.38 170.92,53.38 170,52.46 164.67,52.46 163.62,51.4 163.62,49.7 162.91,48.99 161.45,48.99 160.47,48.01 155.21,48.01 154.46,48.76 154.19,48.76 v3(153.93,49.02) ; v3(141.11,78.1) 140.83,78.38 139,78.38 137.07,80.31 137.07,106.44 139.93,109.3 139.93,109.94 143.04,113.05 146.79,113.05 148.01,111.83 148.01,111.17 148.12,111.06 148.35,111.06 C423.2
PCIE_TX4+: length 6.8
  BOTTOM w0.102: U24.BC36 153.33,109.73 153.01,109.42 152.44,109.42 152.13,109.73 152.1,109.73 152.08,109.75
  BOTTOM w0.127: C422.1 149.59,112.79 150.36,112.79 150.75,112.4 150.75,111.08 152.08,109.75
PCIE_TX4+_LAN: length 143.2
  TOP w0.127: v3(33.13,98.57) 32.9,98.79 31.37,98.79 31.2,98.62 30.77,98.62 30.69,98.54 U7.13
  IN2 w0.133: v3(33.13,98.57) 33.38,98.82 33.84,98.82 34.19,99.18 34.19,101.36 36.75,103.92 46.66,103.92 47.14,104.4 53.53,104.4 55.63,102.3 70.64,102.3 84.29,115.94 85.46,115.94 89.9,120.38 90.72,120.38 95.43,125.1 96.15,125.82 97.1,125.82 99.2,127.92 101.91,127.92 104.44,130.45 110.9,130.45 116.15,125.19 117.96,125.19 118.52,124.63 134.08,124.63 143.49,115.22 146.4,115.22 147.07,114.56 147.07,114.42 v3(146.79,114.14)
  BOTTOM w0.127: v3(146.79,114.14) 147.09,113.85 147.09,113.64 147.75,112.98 148.22,112.98 C422.2
PCIE_TX4-: length 6.8
  BOTTOM w0.102: 152.25,109.92 152.27,109.91 152.27,109.88 152.53,109.62 152.78,109.62 U24.BE36
  BOTTOM w0.127: C421.1 149.02,113.24 149.02,113.12 149.11,113.03 150.46,113.03 150.99,112.5 150.99,111.18 152.25,109.92
PCIE_TX4-_LAN: length 143.2
  TOP w0.127: U7.14 30.69,98.94 30.77,98.86 31.1,98.86 31.27,99.04 32.83,99.04 v4(33.14,99.34)
  IN2 w0.133: v4(33.14,99.34) 33.41,99.08 33.73,99.08 33.94,99.29 33.94,101.47 36.65,104.18 46.56,104.18 47.03,104.65 53.63,104.65 55.73,102.55 70.53,102.55 84.18,116.2 85.36,116.2 89.79,120.63 90.61,120.63 95.33,125.35 96.05,126.07 96.99,126.07 99.09,128.17 101.8,128.17 104.33,130.7 111,130.7 116.26,125.44 118.07,125.44 118.63,124.88 134.18,124.88 143.59,115.48 146.51,115.48 147.32,114.66 147.32,114.41 v3(147.56,114.18)
  BOTTOM w0.127: C421.2 148.22,113.22 147.85,113.22 147.33,113.74 147.33,113.95 v3(147.56,114.18)
PCIE_WAKE#_R: length 9.5
  BOTTOM w0.127: CN10.1 188.3,49.9 189.03,49.17 R680.1 189.03,46.09 188.14,45.2 v2(187.84,45.2) 186.76,45.2 R689.1 186.76,46.27 186.91,46.42 Q56.6
PCLK_TPM: length 88
  TOP w0.127: U11.21 182.09,66.75 183.43,65.42 184.49,65.42 184.89,65.83 186.51,65.83 186.75,66.06 v3(188.21,66.06)
  IN2 w0.133: v4(179.37,119.78) 179.37,119.58 182.41,116.54 185.59,116.54 185.76,116.7 189.36,116.7 195.61,110.46 195.61,91.91 188.36,84.66 186.62,84.66 183.28,81.32 183.28,75.75 188.17,70.86 188.17,66.12 v3(188.21,66.06)
  BOTTOM w0.127: R467.1 174.03,119.65 174.68,119.65 175.79,118.53 178.67,118.53 179.37,119.24 v4(179.37,119.78)
PD#: length 11.6
  TOP w0.127: D15.2 37.4,36.01 36.09,34.7 R346.2 36.09,33.65 R348.2 35.48,33.41 33.83,31.77 33.83,31.08 33.58,30.83 U15.47 ; D15.2 D13.2 ; D15.2 v2(39.53,36.01)
PEG_RCOMP: length 9.8
  TOP w0.305: v2(130.92,107.16) 131.14,107.38 v3(131.62,107.38) R107.2
  IN2 w0.305: v3(124.94,105.08) 125.87,105.08 127.47,106.67 130.92,106.67 v3(131.62,107.38)
  BOTTOM w0.254: v3(124.94,105.08) 125.01,105.08 U27.E23
PEG_RX0: length 51.2
  TOP w0.089: v3(119.9,111.19) 119.72,111.19 119.49,110.95 119.49,110.02 119.74,109.77 125.07,109.77 125.08,109.79 125.11,109.79
  TOP w0.127: 125.11,109.79 125.27,109.79 126.49,111.02 127.69,111.02 129.29,112.62 130.13,112.62 131.14,113.63 131.14,115.34 133.52,117.72 133.52,118.54 147.14,132.16 147.42,132.16 151.82,136.57 151.82,137.31 v2(151.26,137.86) 151.82,138.42 151.82,138.92 C103.1
  BOTTOM w0.102: U27.L29 119.24,110.84 119.24,110.96 119.63,111.35 119.74,111.35 v3(119.9,111.19)
PEG_RX0#_C: length 12.6
  TOP w0.089: v3(151.2,151.26) 151.65,150.8 151.65,149.32 152.02,148.95 152.02,147.33 152.04,147.31 152.04,147.29
  TOP w0.127: C104.2 152.25,140.46 152.25,141.11 152.11,141.26 152.11,144.56 v2(152.58,145.03) 152.04,145.58 152.04,147.29
  BOTTOM w0.127: U19.AB9 150.81,151.64 v3(151.2,151.26)
PEG_RX0_C: length 12.6
  TOP w0.089: 151.82,147.29 151.82,147.31 151.84,147.33 151.84,148.87 151.47,149.24 151.47,150.33 151.41,150.4 v3(151.23,150.4)
  TOP w0.127: C103.2 151.81,140.19 152.04,140.42 152.04,141.02 151.89,141.17 151.89,144.43 v2(151.29,145.03) 151.82,145.57 151.82,147.29
  BOTTOM w0.127: v3(151.23,150.4) 151.35,150.51 151.35,150.63 151.14,150.84 U19.AC9
PEG_RX1: length 50.5
  TOP w0.089: 125.1,110.8 125.07,110.8 125.06,110.79 120.55,110.79 120.31,110.55 120.31,110.29 120.2,110.19 v3(119.9,110.19)
  TOP w0.127: 125.1,110.8 125.22,110.8 129.59,115.18 129.59,117.01 131.45,118.86 132.76,118.86 135,121.11 135,121.52 146.44,132.96 v2(146.44,133.75) 147.22,133.75 150.16,136.69 150.16,142.79 C92.1
  BOTTOM w0.102: U27.L28 v3(119.9,110.19)
PEG_RX1#_C: length 9
  TOP w0.089: v3(150.42,151.25) 150.09,150.92 150.09,150.83 150.09,150.69 149.99,150.59 149.99,150.16 150.19,149.95 150.19,149.24 149.99,149.04 149.99,147.39 150.01,147.37 150.01,147.32 150.03,147.3 150.03,147.29
  TOP w0.127: 150.03,147.29 150.03,147.1 v2(150.55,146.58) 150.03,146.05 150.03,145.14 150.38,144.79 150.38,144.37 C93.2
  BOTTOM w0.127: v3(150.42,151.25) 150.01,150.84 U19.AC10
PEG_RX1_C: length 9
  TOP w0.089: v3(149.58,151.25) 149.71,151.13 149.91,150.92 149.91,150.83 149.91,150.77 149.81,150.67 149.81,150.08 150.01,149.88 150.01,149.32 149.81,149.11 149.81,147.29
  TOP w0.127: 149.81,147.29 149.81,147.13 v2(149.25,146.58) 149.81,146.02 149.81,145.05 150.16,144.7 150.16,144.37 C92.2
  BOTTOM w0.127: U19.AB10 v3(149.58,151.25)
PEG_RX2: length 48.6
  TOP w0.089: v3(119.9,113.19) 119.66,113.19 119.49,113.02 119.49,111.95 119.66,111.78 124.11,111.78 124.31,111.98 124.31,112.44 124.88,113 124.88,113 124.93,113.06 124.93,113.08 124.94,113.1
  TOP w0.127: C109.1 148.49,139 148.49,138.52 v2(147.98,138.02) 148.06,137.94 148.51,137.49 148.51,136.36 146.82,134.66 146.13,134.66 133.74,122.27 133.74,120.87 132.45,119.59 128.26,119.59 125.41,116.74 125.41,113.57 125.22,113.38 124.94,113.1
  BOTTOM w0.102: U27.L31 119.23,112.85 119.23,112.95 119.62,113.34 119.74,113.34 v3(119.9,113.19)
PEG_RX2#_C: length 11.8
  TOP w0.089: v3(148.76,150.46) 149.12,150.1 149.12,149.6 149.33,149.39 149.33,147.57 149.08,147.32 149.08,147.31 149.08,147.3 149.08,147.29
  TOP w0.127: C110.2 148.9,140.38 148.9,141.27 v2(149.28,141.65) 148.73,142.2 148.73,146.94 149.08,147.29
  BOTTOM w0.127: U19.AC11 148.78,150.46 v3(148.76,150.46)
PEG_RX2_C: length 11.8
  TOP w0.089: v3(148.71,149.64) 148.82,149.64 149.15,149.31 149.15,147.64 148.97,147.46 148.94,147.46 148.92,147.44
  TOP w0.127: C109.2 148.61,140.16 148.68,140.24 148.68,140.95 v2(147.98,141.65) 148.51,142.17 148.51,147.03 148.92,147.44
  BOTTOM w0.127: U19.AD11 148.83,150.04 148.71,149.92 v3(148.71,149.64)
PEG_RX3: length 49.5
  TOP w0.089: 123.31,116.77 123.31,116.75 123.29,116.73 123.29,116.3 122.48,115.49 122.48,112.95 122.14,112.61 120.61,112.61 120.49,112.49 120.49,112.29 120.59,112.19 v3(120.9,112.19)
  TOP w0.127: 123.31,116.77 123.31,119.11 123.67,119.47 123.67,120.52 124.78,121.62 132.3,121.62 146.02,135.34 146.73,135.34 147.2,135.81 147.2,136.01 v2(147.73,136.54) 147.2,137.07 147.2,142.79 C91.1
  BOTTOM w0.102: U27.K30 v3(120.9,112.19)
PEG_RX3#_C: length 8.8
  TOP w0.089: v3(147.92,151.29) 147.92,150.62 147.32,150.03 147.32,148.23 147.37,148.18 147.37,147.22 147.35,147.2 147.35,147.18
  TOP w0.127: 147.35,147.18 147.35,146.74 146.99,146.37 146.99,144.37 C90.2
  BOTTOM w0.127: U19.AB12 148.33,151.3 148.22,151.19 148.02,151.19 v3(147.92,151.29)
PEG_RX3_C: length 8.8
  TOP w0.089: 147.57,147.18 147.57,147.19 147.55,147.21 147.55,148.25 147.5,148.3 147.5,149.95 148.76,151.21 v3(148.76,151.29)
  TOP w0.127: C91.2 147.2,144.37 147.2,146.28 147.57,146.65 147.57,147.18
  BOTTOM w0.127: U19.AC12 148.33,150.86 v3(148.76,151.29)
PEG_RX4: length 45
  TOP w0.089: v3(119.9,115.19) 119.76,115.19 119.49,114.91 119.49,114.01 119.71,113.78 121.14,113.78 121.31,113.96 121.31,116.63 121.81,117.12 121.81,117.15 121.82,117.16
  TOP w0.127: 121.82,117.16 121.99,117.33 121.99,117.33 122.33,117.67 122.33,119.7 122.58,119.96 122.58,120.75 124.39,122.56 131.84,122.56 145.33,136.05 145.33,137.39 144.82,137.9 v2(144.78,137.94) 145.33,138.49 145.33,138.98 C107.1
  BOTTOM w0.102: v3(119.9,115.19) 119.74,115.34 119.61,115.34 119.25,114.98 119.25,114.84 U27.L33
PEG_RX4#_C: length 13
  TOP w0.089: 146.6,147.29 146.6,147.31 146.59,147.33 146.59,147.87 146.99,148.28 146.99,149.27 146.86,149.4 146.86,150.38 146.92,150.44 v3(147.11,150.44)
  TOP w0.127: C108.2 145.53,140.16 145.44,140.25 145.44,144.39 v2(146.11,145.05) 145.52,145.64 145.52,145.71 146.6,146.8 146.6,147.29
  BOTTOM w0.127: v3(147.11,150.44) 146.99,150.56 146.99,150.65 147.18,150.84 U19.AC13
PEG_RX4_C: length 13
  TOP w0.089: v3(147.11,151.26) 146.69,150.84 146.69,149.32 146.81,149.2 146.81,148.35 146.41,147.95 146.41,147.33 146.39,147.31 146.39,147.29
  TOP w0.127: C107.2 145.23,140.45 145.23,144.64 v2(144.81,145.05) 145.3,145.55 145.3,145.8 146.39,146.89 146.39,147.29
  BOTTOM w0.127: U19.AB13 v3(147.11,151.26)
PEG_RX5: length 44.6
  TOP w0.089: 121.49,119.3 121.47,119.28 121.45,119.28 121.26,119.1 121.26,118.26 120.49,117.48 120.49,114.6 v3(120.9,114.19)
  TOP w0.127: C89.1 144.03,142.79 144.03,136.92 v2(144.56,136.39) 144.03,135.86 144.03,135.53 131.59,123.09 124.2,123.09 121.99,120.87 121.99,120.12 121.9,120.03 121.74,119.88 121.74,119.55 121.49,119.3
  BOTTOM w0.102: U27.K32 v3(120.9,114.19)
PEG_RX5#_C: length 8.2
  TOP w0.089: 145.6,147.38 145.62,147.4 145.62,149.14 145.85,149.37 145.85,150.03 v3(146.27,150.44)
  TOP w0.127: 145.6,147.38 145.6,147.38 145.6,147.12 143.63,145.16 143.63,144.19 C88.2
  BOTTOM w0.127: U19.AC14 146.29,150.44 v3(146.27,150.44)
PEG_RX5_C: length 8.2
  TOP w0.089: 145.82,147.29 145.82,147.31 145.8,147.33 145.8,149.06 146.03,149.3 146.03,149.58 146.09,149.64 v3(146.27,149.64)
  TOP w0.127: C89.2 143.96,143.97 143.85,144.08 143.85,145.07 145.82,147.03 145.82,147.29
  BOTTOM w0.127: U19.AD14 146.83,149.91 146.83,149.77 146.7,149.64 v3(146.27,149.64)
PEG_RX6: length 38.3
  TOP w0.127: v3(120.09,119.93) 120.35,120.19 120.91,120.19 121.24,120.52 121.24,121.15 124.06,123.98 130.95,123.98 142.38,135.41 142.38,137.11 v2(142.93,137.66) 142.38,138.22 142.38,138.98 C106.1
  BOTTOM w0.102: 119.01,118.51 119.01,118.48 119,118.48 119,116.79 119.1,116.69 U27.L35
  BOTTOM w0.127: 119.01,118.51 119.01,119.45 119.73,120.17 119.85,120.17 v3(120.09,119.93)
PEG_RX6#_C: length 13.7
  TOP w0.089: 144.6,147.18 144.61,147.19 144.63,147.19 144.64,147.2 144.83,147.39 144.83,150.08 145.04,150.28 145.04,150.74 145.45,151.16 v3(145.45,151.26)
  TOP w0.127: C105.2 142.03,140.43 142.03,145.47 143.05,146.5 143.92,146.5 144.6,147.18
  BOTTOM w0.127: U19.AB15 145.85,151.66 v3(145.45,151.26)
PEG_RX6_C: length 13.7
  TOP w0.089: v3(145.45,150.44) 145.45,150.44 145.01,150 145.01,147.31 144.76,147.06 144.76,147.04 144.75,147.03
  TOP w0.127: 144.75,147.03 144.55,146.83 144.01,146.28 143.14,146.28 142.24,145.38 142.24,140.03 142.35,139.92 142.54,139.92 C106.2
  BOTTOM w0.127: v3(145.45,150.44) 145.38,150.51 145.38,150.71 145.51,150.84 U19.AC15
PEG_RX7: length 43.9
  TOP w0.089: v3(120.42,118.26) 120.14,118.53 119.36,118.53 118.93,118.96 118.93,119.41 118.91,119.43 118.91,119.45
  TOP w0.127: C86.1 140.64,142.79 140.64,138.28 140.76,138.16 140.76,136.76 v2(140.21,136.21) 140.76,135.67 140.76,135.12 130.68,125.04 123.5,125.04 118.91,120.45 118.91,119.45
  BOTTOM w0.102: v3(120.42,118.26) 120.14,118.53 119.95,118.53 119.81,118.4 119.81,117.57 120,117.38 120,115.79 120.1,115.69 U27.K34
PEG_RX7#_C: length 11
  TOP w0.089: 143.94,147.28 143.95,147.3 143.95,147.32 143.95,147.32 144.4,147.77 144.4,150.37 144.47,150.44 v3(144.63,150.44)
  TOP w0.127: C87.2 140.77,143.97 140.68,144.07 140.68,144.46 v3(141.38,145.17) 140.85,145.69 140.85,145.8 140.99,145.94 141.74,145.94 142.8,147.01 143.67,147.01 143.94,147.28
  BOTTOM w0.127: U19.AC16 144.69,150.84 144.53,150.68 144.53,150.54 v3(144.63,150.44)
PEG_RX7_C: length 11
  TOP w0.089: v3(144.63,151.26) 144.22,150.85 144.22,147.84 143.86,147.48 143.86,147.48 143.82,147.44 143.79,147.44 143.79,147.43
  TOP w0.127: C86.2 140.46,144.19 140.46,144.79 v3(140.08,145.17) 140.63,145.72 140.63,145.89 140.9,146.16 141.65,146.16 142.71,147.22 143.58,147.22 143.79,147.43
  BOTTOM w0.127: U19.AB16 v3(144.63,151.26)
PEG_RX#0: length 51.2
  TOP w0.089: v3(118.9,111.19) 119.31,110.77 119.31,109.95 119.66,109.59 125.07,109.59 125.08,109.57 125.11,109.57
  TOP w0.127: 125.11,109.57 125.36,109.57 126.58,110.8 127.78,110.8 127.79,110.81 129.38,112.4 130.22,112.4 131.36,113.54 131.36,115.25 133.74,117.63 133.74,118.46 147.23,131.95 147.51,131.95 152.04,136.48 152.04,137.34 v2(152.56,137.86) 152.04,138.38 152.04,138.92 C104.1
  BOTTOM w0.102: U27.M29 v3(118.9,111.19)
PEG_RX#1: length 50.6
  TOP w0.089: 125.1,110.59 125.07,110.59 125.06,110.61 120.62,110.61 120.49,110.47 120.49,110.31 120.61,110.19 v3(120.9,110.19)
  TOP w0.127: 125.1,110.59 125.31,110.59 129.81,115.09 129.81,116.92 131.54,118.65 132.85,118.65 135.21,121.02 135.21,121.43 146.61,132.83 v2(147.35,132.83) 147.35,133.57 150.38,136.6 150.38,142.79 C93.1
  BOTTOM w0.102: U27.K28 v3(120.9,110.19)
PEG_RX#2: length 48.6
  TOP w0.089: 125.1,112.95 125.08,112.93 125.05,112.93 125.05,112.93 124.49,112.36 124.49,111.91 124.18,111.6 119.59,111.6 119.31,111.88 119.31,112.77 v3(118.9,113.19)
  TOP w0.127: C110.1 148.73,138.98 148.73,138.57 v2(149.28,138.02) 148.73,137.46 148.73,136.27 146.91,134.45 146.22,134.45 133.95,122.18 133.95,120.78 132.54,119.37 128.35,119.37 125.63,116.66 125.63,113.48 125.1,112.95
  BOTTOM w0.102: U27.M31 v3(118.9,113.19)
PEG_RX#3: length 49.5
  TOP w0.089: 123.1,116.77 123.1,116.75 123.12,116.73 123.12,116.37 122.3,115.56 122.3,113.02 122.07,112.79 120.53,112.79 120.31,112.56 120.31,112.26 120.23,112.19 v3(119.9,112.19)
  TOP w0.127: 123.1,116.77 123.1,119.2 123.46,119.56 123.46,120.61 124.69,121.84 132.21,121.84 145.93,135.55 146.64,135.55 146.99,135.9 146.99,135.99 v2(146.44,136.54) 146.99,137.09 146.99,142.79 C90.1
  BOTTOM w0.102: U27.L30 v3(119.9,112.19)
PEG_RX#4: length 45
  TOP w0.089: 121.97,117.01 121.96,116.99 121.93,116.99 121.49,116.55 121.49,113.89 121.21,113.61 119.64,113.61 119.31,113.94 119.31,114.77 v3(118.9,115.19)
  TOP w0.127: 121.97,117.01 122.04,117.07 122.54,117.58 122.54,119.61 122.8,119.87 122.8,120.66 124.48,122.35 131.93,122.35 145.55,135.96 145.55,137.41 v2(146.08,137.94) 145.55,138.47 145.55,138.98 C108.1
  BOTTOM w0.102: U27.M33 v3(118.9,115.19)
PEG_RX#5: length 44.6
  TOP w0.089: 121.34,119.45 121.33,119.44 121.33,119.41 121.29,119.38 121.08,119.17 121.08,118.33 120.31,117.56 120.31,114.6 v3(119.9,114.19)
  TOP w0.127: C88.1 143.81,142.79 143.81,136.94 v2(143.26,136.39) 143.81,135.84 143.81,135.62 131.5,123.31 124.12,123.31 121.77,120.96 121.77,120.21 121.74,120.19 121.53,119.97 121.53,119.64 121.34,119.45
  BOTTOM w0.102: U27.L32 v3(119.9,114.19)
PEG_RX#6: length 38.3
  TOP w0.127: v3(120.09,120.69) 120.39,120.4 120.82,120.4 121.02,120.61 121.02,121.24 123.97,124.19 130.86,124.19 142.16,135.5 142.16,137.14 v2(141.63,137.66) 142.16,138.19 142.16,138.98 C105.1
  BOTTOM w0.102: 118.79,118.51 118.79,118.48 118.8,118.48 118.8,116.79 118.7,116.69 U27.M35
  BOTTOM w0.127: 118.79,118.51 118.79,119.54 119.64,120.39 119.79,120.39 v3(120.09,120.69)
PEG_RX#7: length 43.9
  TOP w0.089: 119.13,119.45 119.13,119.44 119.11,119.42 119.11,119.03 119.43,118.71 120.12,118.71 v3(120.42,119.02)
  TOP w0.127: C87.1 140.85,142.79 140.85,138.37 140.97,138.25 140.97,136.75 v2(141.51,136.21) 140.97,135.68 140.97,135.03 130.77,124.82 123.59,124.82 119.13,120.36 119.13,119.45
  BOTTOM w0.102: v3(120.42,119.02) 120.14,118.74 119.86,118.74 119.61,118.48 119.61,117.49 119.8,117.3 119.8,115.79 119.7,115.69 U27.L34
PEG_TX0: length 50.1
  IN2 w0.133: v4(138.25,138.93) 138.47,138.7 138.47,138.48 138.93,138.02 148.08,138.02 154.27,144.21 154.27,146.58 154.03,146.82 153.72,146.82 v3(153.49,147.05)
  BOTTOM w0.127: U19.AG6 153.06,147.41 153.06,146.98 153.18,146.86 153.31,146.86 v3(153.49,147.05) ; C392.1 121.09,123.04 121.09,123.28 121.61,123.81 122.39,123.81 123.61,125.02 124.85,125.02 127.12,127.28 129.4,127.28 138.18,136.06 138.18,137.76 138.5,138.09 138.5,138.67 v4(138.25,138.93)
PEG_TX1: length 49.9
  IN2 w0.133: v3(152.89,148.07) 152.76,147.94 152.76,143.87 147.84,138.94 142.42,138.94 140.23,141.14 139.75,141.14 139.54,140.94 139.54,140.48 139.64,140.38 v4(139.86,140.38)
  BOTTOM w0.127: C395.1 123.48,122.63 123.4,122.71 123.4,123.21 124.06,123.87 125.03,123.87 127.19,126.03 130.41,126.03 139.13,134.75 139.13,137.08 139.8,137.75 139.8,139.75 139.61,139.95 139.61,140.3 139.69,140.38 v4(139.86,140.38) ; U19.AF7 152.81,148.44 152.97,148.29 152.97,148.15 v3(152.89,148.07)
PEG_TX2: length 47.3
  IN2 w0.133: v3(151.21,148.81) 151.4,148.63 151.64,148.63 151.99,148.28 151.99,144.37 147.31,139.69 143.42,139.69 142.19,140.92 142.19,141.58 142.06,141.71 141.67,141.71 v3(141.48,141.52)
  BOTTOM w0.127: C397.1 125.87,123.03 125.87,123.49 127.58,125.2 131.08,125.2 140.95,135.07 140.95,141.55 141.14,141.74 141.26,141.74 v3(141.48,141.52) ; U19.AE9 150.81,149.21 v3(151.21,148.81)
PEG_TX3: length 40.5
  IN2 w0.133: v3(151.18,145.74) 150.97,145.52 150.97,144.66 146.74,140.43 144.48,140.43 143.61,141.3 143.2,141.3 v3(143.05,141.15)
  BOTTOM w0.127: U19.AG9 150.61,147.64 150.55,147.57 150.55,146.89 150.89,146.54 150.89,146.03 v3(151.18,145.74) ; v3(143.05,141.15) 142.88,141.33 142.59,141.33 142.38,141.13 142.38,135.08 131.62,124.31 129.12,124.31 128.16,123.36 128.16,123.02 C399.1
PEG_TX4: length 38
  IN2 w0.133: v3(144.78,141.9) 145.01,142.13 147.02,142.13 149.76,144.87 149.76,148.11 150.05,148.39 150.27,148.39 150.4,148.27 v3(150.4,148.05)
  BOTTOM w0.127: v3(150.4,148.05) 150.4,148.3 150.25,148.44 U19.AF10 ; v3(144.78,141.9) 144.53,142.16 144.15,142.16 143.97,141.98 143.97,135.52 131.8,123.36 130.64,123.36 130.44,123.16 130.44,123.03 C401.1
PEG_TX5: length 41.7
  IN2 w0.133: v3(143.08,144.75) 143.25,144.92 144.89,144.92 145.77,144.04 147.95,144.04 149.13,145.22 149.13,148.48 v3(148.74,148.86)
  BOTTOM w0.127: v3(143.08,144.75) 143.28,144.94 144.99,144.94 145.32,144.62 145.32,138.24 v2(144.78,137.71) 145.32,137.18 145.32,136.11 132.35,123.15 132.35,122.88 C402.1 ; v3(148.74,148.86) 148.36,149.24 U19.AE12
PEG_TX6: length 31.1
  BOTTOM w0.127: C405.1 135.03,123.03 135.03,123.29 v2(135.56,123.82) 135.06,124.33 135.06,124.5 146.86,136.31 146.86,145.94 148.01,147.08 148.01,147.32 U19.AG12
PEG_TX7: length 38
  IN2 w0.133: v3(147.95,148.05) 147.93,148.05 147.64,148.34 147.45,148.34 147.16,148.05 147.16,145.69 147.29,145.56 147.58,145.56 v3(147.8,145.79)
  BOTTOM w0.127: v3(147.8,145.79) 148.02,145.57 148.48,145.57 148.83,145.22 148.83,136.78 137.72,125.67 137.72,121.15 135.94,119.37 135.72,119.37 C411.1 ; v3(147.95,148.05) 147.56,148.44 U19.AF13
PEG_TX#0: length 50.1
  IN2 w0.133: v3(139.01,138.93) 138.79,138.93 138.7,138.84 138.7,138.57 139.03,138.25 147.98,138.25 154.04,144.3 154.04,146.48 153.93,146.59 153.57,146.59 153.49,146.52 v3(153.49,146.4)
  BOTTOM w0.127: U19.AG7 152.74,147.64 152.84,147.54 152.84,146.89 153.09,146.64 153.39,146.64 153.49,146.53 v3(153.49,146.4) ; C393.2 121.47,122.63 121.3,122.8 121.3,123.19 121.7,123.59 122.48,123.59 123.69,124.8 124.94,124.8 127.21,127.07 129.49,127.07 138.4,135.97 138.4,137.67 138.72,138 138.72,138.85 138.8,138.93 v3(139.01,138.93)
PEG_TX#1: length 49.9
  IN2 w0.133: v3(139.09,140.38) 139.32,140.6 139.32,141.03 139.65,141.37 140.32,141.37 142.52,139.17 147.74,139.17 152.53,143.96 152.53,147.83 152.47,147.9 152.47,148.45 v3(152.88,148.86)
  BOTTOM w0.127: v3(152.88,148.86) 152.5,149.24 U19.AE7 ; v3(139.09,140.38) 139.39,140.08 139.39,139.86 139.59,139.66 139.59,137.84 138.92,137.17 138.92,134.84 130.32,126.24 127.1,126.24 124.95,124.09 123.97,124.09 123.19,123.3 123.19,122.86 C394.1
PEG_TX#2: length 47.3
  IN2 w0.133: v3(151.2,148.06) 151.2,148.29 151.31,148.4 151.55,148.4 151.76,148.18 151.76,144.46 147.21,139.92 143.52,139.92 142.42,141.01 142.42,141.67 142.16,141.94 141.73,141.94 v3(141.48,142.18)
  BOTTOM w0.127: C396.1 125.44,122.63 125.65,122.84 125.65,123.58 127.49,125.42 130.99,125.42 140.73,135.16 140.73,141.64 141.05,141.96 141.25,141.96 v3(141.48,142.18) ; v3(151.2,148.06) 151.2,148.25 151.01,148.44 U19.AF9
PEG_TX#3: length 40.6
  IN2 w0.133: v3(143.03,141.84) 143.34,141.53 143.7,141.53 144.57,140.66 146.64,140.66 150.74,144.75 150.74,145.52 v3(150.52,145.74)
  BOTTOM w0.127: v3(143.03,141.84) 142.74,141.55 142.5,141.55 142.17,141.22 142.17,135.17 131.53,124.53 129.03,124.53 127.94,123.45 127.94,123.04 C398.1 ; v3(150.52,145.74) 150.68,145.89 150.68,146.45 150.33,146.8 150.33,147.52 150.21,147.64 U19.AG10
PEG_TX#4: length 38
  IN2 w0.133: v3(150.4,148.84) 150.18,148.62 149.95,148.62 149.53,148.2 149.53,144.97 146.92,142.36 144.96,142.36 v3(144.76,142.56)
  BOTTOM w0.127: C400.1 130.22,123.03 130.22,123.25 130.55,123.58 131.72,123.58 143.75,135.61 143.75,142.07 144.06,142.37 144.57,142.37 v3(144.76,142.56) ; v3(150.4,148.84) 150.01,149.22 U19.AE10
PEG_TX#5: length 41.7
  IN2 w0.133: v3(143.11,145.46) 143.11,145.35 143.31,145.15 144.99,145.15 145.87,144.26 147.86,144.26 148.9,145.31 148.9,147.84 v3(148.71,148.04)
  BOTTOM w0.127: v3(148.71,148.04) 148.84,148.17 148.84,148.31 148.71,148.44 U19.AF12 ; v3(143.11,145.46) 143.11,145.3 143.25,145.16 145.08,145.16 145.53,144.71 145.53,138.23 v2(146.05,137.71) 145.53,137.19 145.53,136.02 132.57,123.06 132.57,122.74 132.68,122.63 C403.1
PEG_TX#6: length 31.1
  BOTTOM w0.127: C404.1 134.82,123.03 134.82,123.29 v2(134.29,123.82) 134.84,124.36 134.84,124.59 146.65,136.4 146.65,146.03 147.79,147.17 147.79,147.38 U19.AG13
PEG_TX#7: length 38
  IN2 w0.133: v3(147.8,145.1) 147.58,145.33 147.48,145.33 147.48,145.33 147.19,145.33 146.93,145.6 146.93,148.14 147.36,148.57 147.64,148.57 v3(147.93,148.86)
  BOTTOM w0.127: v3(147.8,145.1) 148.06,145.36 148.39,145.36 148.62,145.13 148.62,136.87 137.51,125.76 137.51,121.24 136.13,119.87 135.85,119.59 135.71,119.59 C410.1 ; v3(147.93,148.86) 147.55,149.24 U19.AE13
PEGX_RST#: length 20.3
  BOTTOM w0.127: U19.AC7 152.9,150.44 159.47,150.44 160.5,151.47 160.5,153.2 161.19,153.89 v2(161.83,153.89) R436.1 R435.2 163.02,155.15 163.02,156.34 R434.1 163.24,156.39 163.58,156.05 164.47,156.05 165,155.52 165,155.08 165.35,154.74 U21.4
PEX_CLKREQ#: length 17.5
  TOP w0.127: v3(159.95,152.18) Q10.1 161.84,152.18 162.23,152.57 162.23,155.48 R36.1 163.33,155.74 164.92,154.15 R39.1 165.85,153.98 v2(165.87,153.99)
  BOTTOM w0.127: U19.AC6 153.29,151.05 153.74,151.5 153.74,151.9 153.98,152.14 159.91,152.14 v3(159.95,152.18)
PEX_PLLVDD: length 14.5
  TOP w0.508: v3(140.39,147.11) 140.11,147.11 v2(139.63,146.63) 138.84,145.84 138.84,145.36 138.21,144.73 138.08,144.73 137.71,144.36 C84.1
  IN2 w0.508: v3(140.39,147.11) 142.47,147.11 143.14,147.78 143.14,151.53 143.52,151.91 145.14,151.91 145.29,152.06 v3(146.29,152.06)
PEX_TERMP: length 7.5
  BOTTOM w0.127: R450.2 137.72,142.13 v2(138.43,142.84) 138.66,143.07 138.66,146.8 138.01,147.46 138.01,148.02 U19.AF25
PEX_TSTCLK: length 7.5
  BOTTOM w0.127: U19.AF22 140.09,148.34 139.71,147.96 139.71,146.86 140.24,146.33 140.24,142.59 139.89,142.24 139.89,141.97 139.81,141.89 R449.2
PEX_TSTCLK#: length 8.6
  BOTTOM w0.127: U19.AE22 139.71,148.86 139.71,148.36 139.46,148.11 139.46,146.55 139.98,146.02 139.98,142.69 139.64,142.35 139.64,142.07 R449.1
PLL_ODVR_EN: length 1.8
  TOP w0.089: R155.1 162.06,98.56 v3(161.41,99.21)
  BOTTOM w0.102: U24.AD11 161.66,99.46 v3(161.41,99.21)
PLTRST#: length 597.7
  TOP w0.127: v3(166.12,46.07) 166.12,47.52 167.04,48.44 168.41,48.44 168.62,48.65 170.37,48.65 171.86,50.14 v3(171.86,52.47) 171.81,52.42 168.65,52.42 168.34,52.73 U13.22 ; U5.2 84.41,101.52 84.05,101.16 83.12,101.16 82.33,101.95 v3(82.33,103.02) ; v3(28.31,105.08) 28.31,104.02 v2(28.33,104.01) 28.68,103.65 28.68,101.72 28.52,101.56 U7.19 ; R239.1 178.2,77.28 v3(178.09,77.16)
  IN1 w0.133: v3(103.97,140.89) 103.97,140.35 84.54,120.92 79.83,120.92 67.72,108.81 v3(67.72,104.03) 67.05,104.7 61.6,104.7 59.01,107.3 31.89,107.3 30.55,105.96 28.78,105.96 28.31,105.49 v3(28.31,105.08) 28.82,104.58 34.12,104.58 36.81,101.89 36.81,100.95 35.71,99.85 35.32,99.85 34.44,98.97 34.44,86.34 36.58,84.19 36.58,81.91 35.7,81.03 35.7,72.64 34.88,71.82 34.88,65.29 34.46,64.87 34.46,63.28 33.64,62.46 33.64,52.06 34.65,51.04 34.65,50.42 33.91,49.68 33.91,42.09 39.81,36.2 39.81,35.48 46.05,29.23 46.05,28.67 46.77,27.96 46.77,23.46 47.17,23.06 v3(47.17,20.95) 49.93,18.19 76.83,18.19 85.46,26.82 110.71,26.82 113.18,24.35 135.24,24.35 147.82,36.92 147.82,39.85 150.91,42.94 152.58,42.94 154.13,44.49 154.46,44.49 155.96,46 160.35,46 160.74,45.6 163.87,45.6 164.17,45.91 165.96,45.91 v3(166.12,46.07) ; v3(171.86,52.47) 171.86,52.48 173.74,54.36 173.74,59.25 172.68,60.31 172.68,62.97 174.37,64.66 v3(176.06,64.66) 176.28,64.89 176.28,65.65 175.76,66.17 175.46,66.17 174.72,66.92 174.72,67.42 175.03,67.73 175.03,69.53 174.92,69.63 174.92,70.7 178.6,74.38 178.6,76.65 v3(178.09,77.16)
  IN2 w0.133: v3(103.97,140.89) 103.66,140.89 103.18,141.37 103.18,169.66 100.61,172.23 100.61,181.7 104.6,185.69 106.95,185.69 108.35,187.09 114.71,187.09 119.75,192.12 129.79,192.12 129.86,192.2 138.48,192.2 141.66,189.02 141.66,187.89 147.04,182.51 147.04,179.64 150.14,176.54 150.14,175.6 153.71,172.04 153.71,170.46 156.11,168.06 156.11,165.22 157.99,163.34 157.99,162.37 160,160.36 160,157.5 v3(160.28,157.22)
  BOTTOM w0.127: R683.2 165.22,46.97 v3(166.12,46.07) ; v3(82.33,103.02) 80.5,104.84 68.53,104.84 v3(67.72,104.03) ; v3(160.28,157.22) 165.13,157.22 165.46,157.55 166.32,157.55 167.08,156.79 167.08,154.73 167.24,154.58 168.3,154.58 168.71,154.17 U20.2 ; v3(176.06,64.66) 176.64,64.66 177.08,64.22 R673.2 ; U28.4 190.96,98.49 R549.1 191.13,96.32 191.6,95.85 191.6,91.56 189.03,88.99 188.02,88.99 185.11,86.09 183.92,86.09 182.63,84.79 182.63,83.84 179.95,81.16 179.95,80.32 178.54,78.92 178.54,77.62 v3(178.09,77.16) ; R698.2 29.62,20.64 29.95,20.97 47.15,20.97 v3(47.17,20.95)
PLTRST#_TPM: length 14.2
  TOP w0.127: R240.1 R239.2 178.23,78.06 v3(178.03,77.86) ; U11.16 178.84,70.56 v3(179.32,71.04)
  BOTTOM w0.127: v3(179.32,71.04) 179.32,71.05 176.46,73.91 176.46,76.28 v3(178.03,77.86)
PM_DRAM_PWRGD: length 203.4
  TOP w0.114: R265.2 75.25,68.13 76,67.39 76,66.62 77.67,64.95 77.67,44.69 76.59,43.6 76.59,40.6 76.51,40.52 76.3,40.52 75.23,39.46 75.23,33.46 74.48,32.71 v3(74.48,27.73) ; R265.2 76.6,70.31 77.04,69.88 U12.2 ; R265.2 74.88,70.31 74.65,70.54 74.65,71.92 76.06,73.34 R257.2
  IN1 w0.127: v3(173.73,92.61) 173.73,91.54 172.55,90.37 170.77,90.37 170.58,90.17 170.4,90.17 169.61,89.38 169.61,87.97 168.41,86.76 168.41,83.73 168.37,83.69 168.37,83.18 165.64,80.46 165.64,79.22 160.49,74.07 160.49,64.62 161.56,63.54 161.56,60.77 160.87,60.08 160.87,59.52 146.74,45.39 146.74,44.39 146.36,44.01 145.5,44.01 141.24,39.76 141.24,38.32 132.85,29.93 83.47,29.93 81.27,27.73 v3(74.48,27.73)
  BOTTOM w0.102: v3(173.73,92.61) 173.72,92.61 173.93,92.61 174.63,91.91 ; U24.H3 168.3,95.57 168.61,95.27 168.61,95.11 168.82,94.91 168.82,94.76 169.79,93.78 171.32,93.78 171.51,93.59 171.83,93.59
  BOTTOM w0.114: 171.83,93.59 172.49,93.59 173.47,92.61 v3(173.73,92.61) ; TP123.1 175.21,91.62 174.92,91.62 174.63,91.91
PM_DRAM_PWRGD_Q: length 57
  TOP w0.114: R264.2 84.41,71.44 84.59,71.62 84.85,71.62 85.03,71.44 85.03,70.95 85.15,70.84 85.47,70.84 85.58,70.95 85.58,71.77 85.1,72.25 v3(85.02,72.25) 85.02,73.04 84.79,73.26 R256.1 R255.2 83.21,72.92 83.42,72.7 84.3,72.7 84.42,72.58 84.42,72.41 84.3,72.28 83.54,72.28 83.29,72.04 83.29,71.34 83.18,71.23 82.92,71.23 82.8,71.34 82.8,72.12 82.64,72.28 82.41,72.28 82.25,72.12 82.25,71.25 82.14,71.14 81.85,71.14 81.73,71.25 81.73,72.12 81.62,72.23 80.95,72.23 80.64,72.54 R258.2 79.93,72.13 79.93,70.35 79.81,70.24 79.62,70.24 79.51,70.35 79.51,72.07 79.38,72.19 79.21,72.19 79.09,72.07 79.09,70.33 78.97,70.21 78.78,70.21 78.67,70.33 78.67,72.07 78.55,72.19 78.37,72.19 78.25,72.07 78.25,70.31 78.14,70.2 77.8,70.2 77.69,70.31 U12.4 77.69,72.12 78.18,72.61 79.8,72.61 80,72.81 80,73.04 79.89,73.15 78.1,73.15 77.98,73.27 77.98,73.45 78.1,73.57 79.89,73.57 80.02,73.7 80.02,73.89 79.89,74.02 78.31,74.02 78.18,74.14 78.18,74.31 78.31,74.44 79.38,74.44 79.51,74.56 79.51,74.73 79.38,74.86 78.13,74.86 77.63,74.35 75.53,74.35 72.46,71.28 72.46,71.07 72.61,70.92 72.82,70.92 75.66,73.77 77.3,73.77 77.5,73.57 R257.1
PM_DRAM_PWRGD_R: length 48.5
  TOP w0.114: v3(93.26,98.65) 93.39,98.52 93.39,85.71 92.15,84.47 92.15,82.22 v3(85.05,75.12) 84.48,74.55 R256.2
  IN1 w0.127: v3(93.26,98.65) 93.26,98.65 98.39,98.65 99.51,97.53 99.51,93.62 100.45,92.68 104.99,92.68 105.45,92.22 105.45,91.65 105.94,91.16 v3(106.93,91.16)
  BOTTOM w0.114: v3(106.93,91.16) 107.4,91.62 U27.AC10
PM_EXTTS#0: length 232.2
  TOP w0.127: U1.6 166,178.07 166.73,177.34 166.73,176.98 167.72,175.99 169.24,175.99 v3(169.35,175.89) ; R333.2 R334.2 135.57,37.07 v3(136.05,36.59)
  IN1 w0.133: v3(140.26,35.38) 140.8,35.38 143.46,38.04 143.46,38.87 151.05,46.46 153.81,46.46 155.19,47.84 160.66,47.84 160.96,48.14 162.79,48.14 163.58,48.93 164.62,48.93 167.75,52.06 168.5,52.06 171.64,55.2 171.64,56.21 170.55,57.3 170.55,59.79 171.13,60.37 171.13,62.85 172.88,64.59 172.88,68.97 173.15,69.24 173.75,69.24 174.14,69.63 174.14,72.62 177.3,75.78 177.3,79.42 181.13,83.26 182.05,83.26 182.32,83.53 182.32,84.45 184.78,86.9 186.49,86.9 189.84,90.26 189.84,97.01 190.4,97.57 190.4,106.43 191.42,107.45 191.42,111.02 191.37,111.06 191.37,111.22 188.4,114.19 188.4,115.58 188.4,116.08 187.27,117.21 187.27,118.66 186.52,119.41 186.52,121.44 187.32,122.24 187.39,122.24 187.78,122.62 v3(187.84,122.62)
  IN2 w0.133: v3(187.84,122.62) 187.84,122.4 188.42,121.81 191.71,121.81 193.89,123.99 193.89,163.21 193.3,163.8 193.3,167.35 189.79,170.86 183.21,170.86 179.73,174.34 173.85,174.34 172.17,176.02 171.09,176.02 170.76,176.35 169.8,176.35 v3(169.35,175.89)
  BOTTOM w0.127: v3(140.26,35.38) 137.27,35.38 v3(136.05,36.59) 135.55,37.09 JDIM2.198 135.55,40.3 135.77,40.51 135.77,42.75 138.54,45.52 138.54,47.93 137.58,48.9 136.64,48.9 135.85,49.69 135.85,50.27 135.55,50.57 JDIM1.198
PM_EXTTS#0_EC: length 4.2
  TOP w0.127: U1.4 171.06,178.72 R2.1 172.88,179.52 v2(172.93,179.57)
PM_SYNC: length 218.5
  IN2 w0.127: v3(84.46,104.23) 83.74,103.52 83.74,102.86 81.54,100.65 81.54,98.81 67.85,85.12 67.85,75.25 61.91,69.31 61.91,59.14 65.35,55.7 65.35,45.79 69.09,42.05 69.09,39.79 72.67,36.21 73.51,36.21 75.5,34.22 80.39,34.22 83.67,30.95 113.61,30.95 114.22,31.56 118.28,31.56 122.99,36.26 134.12,36.26 134.75,35.63 137.92,35.63 139.57,37.28 139.57,38.23 142.88,41.55 142.88,43.86 147.73,48.71 147.73,52.1 148.85,53.21 148.85,57.16 150.97,59.28 150.97,66.66 150.65,66.97 v3(150.65,68.72)
  BOTTOM w0.114: v3(150.65,68.72) 150.9,68.97 150.9,72.68 155.16,76.95 155.23,76.95 155.93,77.64 155.93,78.35 149.9,84.37 R623.2 ; v3(84.46,104.23) 84.89,104.67 84.89,107.49 85.88,108.48 R500.1
PM_SYNC_R: length 12.9
  BOTTOM w0.102: 93.33,108.86 93.33,109.13 93.74,109.54 93.91,109.54 94.26,109.2 94.4,109.2 94.57,109.37 94.57,109.52 U27.AT28
  BOTTOM w0.114: 93.33,108.86 93.48,108.72 93.48,108.3 93.35,108.17 93.17,108.17 93.04,108.3 93.04,108.69 92.93,108.81 92.76,108.81 92.64,108.69 92.64,108.27 92.49,108.12 92.27,108.12 92.12,108.27 92.12,108.68 91.97,108.83 91.75,108.83 91.6,108.68 91.6,107.54 91.45,107.38 91.23,107.38 91.08,107.54 91.08,108.59 90.97,108.7 v3(90.56,108.7) 90.35,108.7 90.2,108.56 90.2,108.4 90.59,108.01 90.59,107.82 90.45,107.69 90.25,107.69 89.46,108.48 R500.2
PM_TEST_RST#: length 4
  TOP w0.127: R211.1 162.42,89 162.42,88.67 162.57,88.52 162.57,87.6 161.73,86.76 TP58.1
PM_THRMTRIP#: length 181.1
  TOP w0.114: Q60.1 173.99,174.06 R742.1 173.06,173.26 172.44,172.63 v3(172.44,171.33) ; v3(134.07,114.19) 135.56,114.19 136.65,115.28 136.65,116.04 137.95,117.33 137.95,118.01 137.94,118.01 137.94,121.41 141.54,125.01 142.73,125.01 143.84,126.12 143.84,127.32 146.47,129.94 v3(151.87,129.94)
  IN1 w0.127: v3(157.81,137.99) 157.84,138.02 157.84,141.05 160.04,143.25 160.89,143.25 v3(162.36,144.72) ; v3(151.04,86.26) 147.57,89.73 145.91,89.73 145.44,90.2 141.52,90.2 132.45,99.27 132.45,111.21 133.71,112.47 133.71,113.83 v3(134.07,114.19) 134.47,114.6 134.47,117.43 133.71,118.2 133.71,120.45 132.49,121.66 116.26,121.66 113.59,118.99 97.84,118.99 v3(97.49,118.64) ; v3(172.44,171.33) 171.42,170.31 171.42,166.8 172.2,166.02 172.2,158.1 171.19,157.09 v3(171.19,146.3)
  IN2 w0.127: v3(151.87,129.94) 151.87,130.98 157.81,136.92 v3(157.81,137.99) ; v3(162.36,144.72) 166.32,148.68 170.11,148.68 171.19,147.6 v3(171.19,146.3)
  BOTTOM w0.102: U27.AM35 97.92,117.16 97.92,118.21 v3(97.49,118.64) 97.49,118.64 97.49,119.21 98.04,119.76 98.04,121.28 R459.2
  BOTTOM w0.114: R594.2 v3(151.04,86.26)
PROCHOT_EC: length 55.7
  TOP w0.127: v3(162.82,59.61) 161.68,59.61 161.07,59 152.68,59 152.51,58.82 152.51,58.57 152.68,58.39 155.63,58.39 155.78,58.24 155.78,58.03 155.63,57.88 152.7,57.88 152.56,57.74 152.56,57.54 152.7,57.4 154.59,57.4 154.74,57.25 154.74,57.04 154.59,56.89 152.53,56.89 152.38,56.74 152.38,56.53 152.53,56.38 153.54,56.38 153.7,56.22 153.7,56 153.54,55.85 152.54,55.85 152.34,55.64 152.34,55.2 153.13,54.41 v2(155.35,54.41) 157.01,54.41 157.27,54.67 157.27,55.82 157.43,55.97 157.65,55.97 157.81,55.82 157.81,54.73 157.96,54.58 158.17,54.58 158.32,54.73 158.32,55.85 158.49,56.03 158.74,56.03 158.91,55.85 158.91,54.7 159.64,53.96 160.75,53.96 161,54.22 161.73,54.22 R329.2 162.36,53.96 163.34,53.96 163.45,53.85 163.72,53.85 164.44,53.13 165.86,53.13 166.41,53.68 166.41,54.44 166.7,54.73 U13.17
  BOTTOM w0.127: v3(162.82,59.61) 161.57,60.85 158.45,60.85 Q53.2
PWM-VID: length 65
  IN2 w0.133: v3(158.88,143.81) 157.81,144.87 157.81,151.68 156.8,152.7 156.8,158.87 155.53,160.14 155.53,161.28 152.88,163.93 v3(152.88,165.42)
  BOTTOM w0.127: v3(158.88,143.81) 160.63,145.55 165.06,145.55 166.31,144.3 166.31,143.07 166.39,142.99 167.82,142.99 174.93,135.88 174.93,134.56 176.77,132.73 185.75,132.73 189.77,136.75 PR167.1 ; U19.E7 152.49,165.82 v3(152.88,165.42)
PWR_DEBUG: length 2.1
  TOP w0.127: R88.1 134.72,112.24 R87.1 136.76,112.24 v2(136.78,112.21)
PWR_DEBUG_R: length 13.9
  TOP w0.127: R88.2 133.52,111.45 R89.1 132.29,111.45 R90.2 132.26,111.42 130.83,111.42 130.11,110.71 129.27,110.71 v2(129.26,110.71) 129.05,110.71 126.97,108.63 123.46,108.63 v3(122.9,109.19)
  BOTTOM w0.102: U27.H27 v3(122.9,109.19)
PWRLED#: length 130
  TOP w0.203: 166.39,51.93 U13.24
  TOP w0.254: v3(65.18,7.82) 65.18,9.26 v2(80.95,25.04) 81.59,25.67 136.06,25.67 143.72,33.33 143.72,45.38 147.58,49.24 149.98,49.24 152.35,51.61 165.13,51.61 165.46,51.93 166.39,51.93
  BOTTOM w0.254: R722.1 v3(65.18,7.82) R726.1
R_SPK+: length 84.3
  BOTTOM w1.016: 35.19,32.25 36.61,33.67 42.77,33.67 52.07,24.38 53.78,24.38 54.9,23.25 56.76,23.25 62.97,17.04 v2(78.94,17.04) 79.84,17.04 82.27,19.47 102.16,19.47 107.9,13.73 107.9,13.05
  vias: v3(34.84,31.32) v3(35.5,31.28) v3(107.75,12.08) v3(107.75,11.42)
R_SPK+_1:
  vias: v3(109.12,5.48) v3(109.45,6.09)
R_SPK-: length 77.8
  BOTTOM w1.016: 106.33,13.33 101.58,18.08 82.85,18.08 80.42,15.64 v2(76.1,15.64) 62.4,15.64 56.18,21.85 54.32,21.85 53.2,22.98 51.49,22.98 42.2,32.27 38.63,32.27 38.44,32.08
  vias: v3(35.05,30.47) v3(35.71,30.47) v3(106.38,12.18) v3(106.4,11.5)
R_SPK-_1:
  vias: v3(107.55,6.09) v3(107.55,5.43)
REGOUT:
  vias: v2(25.38,101.62) v3(26.47,102.3)
RF_EN: length 19.7
  TOP w0.127: v3(177.16,49.29) 177.16,48.64 177.52,48.28 181.38,48.28 182.23,49.13 U13.66
  BOTTOM w0.127: v3(177.16,49.29) 178.09,49.29 v3(178.16,49.22) 178.48,49.22 179.25,49.98 179.25,51.94 179.34,52.03 179.34,55.53 177.5,57.37 CN10.20
RING2: length 21.5
  TOP w0.254: Q44.3 23.42,28.08 v3(23.78,28.44)
  IN2 w1.016: 18.06,24.12 16.72,22.77 16.72,13.97 13.79,11.05 11.18,11.05 10.22,12.01 8.97,12.01
  vias: v2(7.01,10.56) v3(6.71,11.19) v3(7.4,11.19) v3(25.4,29.66) v3(25.94,30.06)
RING2_R:
  vias: v2(3.94,13.99)
ROM_CS: length 4.7
  TOP w0.102: 148.57,166.38 148.34,166.61 148.34,167.68 148.65,167.98
  TOP w0.127: 148.57,166.38 v3(148.71,166.24) ; 148.65,167.98 148.7,168.03 R15.1 147.88,169.2 v3(147.86,169.18)
  BOTTOM w0.102: U19.D12 148.33,166.62 v3(148.71,166.24)
ROM_SCLK: length 9.3
  TOP w0.127: R7.2 148.94,173.64 v3(148.75,173.45) 148.42,173.77 R9.1 148.1,174.81 v2(148.11,174.82)
  BOTTOM w0.127: U19.C12 148.33,167.64 148.74,168.05 148.74,168.63 148.91,168.8 148.91,171.02 149.12,171.22 149.12,172.47 148.75,172.84 v3(148.75,173.45)
ROM_SI: length 8.8
  BOTTOM w0.127: R394.1 R400.1 148.9,175 148.16,174.26 148.16,172.64 v3(148.61,172.2) 148.61,172.2 148.61,170.69 148.69,170.61 148.69,168.9 148.33,168.54 U19.B12
ROM_SO: length 10.6
  BOTTOM w0.127: R386.2 149.27,177.79 R393.1 148.77,176.55 148.77,175.28 147.73,174.24 v3(147.71,174.24) 147.86,174.08 147.86,169.93 148.33,169.46 U19.A12
RSET: length 3.9
  TOP w0.203: 24.98,97.06 25.27,97.34 U7.31
  TOP w0.254: v2(23.8,94.63) 23.8,95.01 24.19,95.4 R164.2 24.19,96.04 24.98,96.83 24.98,97.06
RSMRST#: length 32.6
  TOP w0.127: v3(177.67,60.69) 177.12,60.14 176.07,60.14 175.76,60.46 175.76,61.78 175.63,61.91 U13.112
  BOTTOM w0.127: R625.1 173.97,83.82 TP143.1 173.63,83.48 172.65,82.5 R639.2 172.4,82.25 171.21,81.06 171.21,75.03 174.64,71.6 174.64,69.97 175.44,69.17 175.44,67.9 175.97,67.36 175.97,66.77 177.67,65.07 v3(177.67,60.69)
RSTZ: length 8.2
  BOTTOM w0.127: R698.1 29.47,18.86 28.85,19.47 v3(28.76,19.47) ; R698.1 29.28,18.52 R707.1 ; R698.1 30.99,18.86 C540.2 R708.1 30.69,17.3 30.69,15.82 31.14,15.37 U32.22
RSVD30: length 11.2
  TOP w0.127: v3(122.93,108.15) 122.93,108.15 124.2,108.15 124.45,107.9 124.45,106.99 123.85,106.4 v2(123.85,106.09) 122.83,105.06 118.19,105.06 R126.2
  BOTTOM w0.127: U27.G26 v3(122.93,108.15)
RSVD38: length 15.6
  TOP w0.127: v3(112.02,112.19) 112.38,112.55 112.38,113.37 113.29,114.27 113.29,119.31 117.59,123.61 118.01,123.61 TP14.1
  BOTTOM w0.102: v3(112.02,112.19) 111.52,111.69 U27.W30
RSVD39: length 16.8
  TOP w0.127: TP12.1 117.62,126 116.37,124.76 116.37,123.55 112.93,120.11 112.93,114.28 111.93,113.28 v3(111.93,113.15)
  BOTTOM w0.102: U27.W31 111.46,112.69 v3(111.93,113.15)
RTC_RST#: length 104.1
  TOP w0.127: v3(151.57,67.76) 154.23,70.42 v3(154.23,70.55) ; v3(173.69,90.79) 174.97,92.07 R183.2 174.57,92.38 174.31,92.12 173.37,92.12 C211.1 172.98,93.25 172.8,93.44 172.8,94.2 172.07,94.93 172.07,95.03 171.58,95.52 171.58,97.22 v2(171.86,97.5) 172.51,98.15 v3(172.51,98.15)
  IN2 w0.133: v3(173.69,90.79) 173.69,89.53 172.67,88.51 172.67,86.01 173.09,85.6 173.09,83.97 170.71,81.59 170.71,80.55 v3(169.75,79.6) ; v3(151.57,67.76) 151.57,66.95 151.57,66.95 151.57,59.05 149.44,56.92 149.44,53.16 149.48,53.12 149.18,52.82 149.06,52.7 149.06,49.25 143.67,43.86 143.67,37.36 139.81,33.5 139.81,33.46 139.54,33.19 139.5,33.19 135.74,29.43 133.99,29.43 131.93,27.37 v3(129.29,27.37)
  BOTTOM w0.102: v3(172.51,98.15) 172.25,98.15 171.74,98.66 171.39,98.66 171.2,98.47 170.94,98.47 170.65,98.76 U24.D9
  BOTTOM w0.127: J2.1 v3(129.29,27.37) ; v3(154.23,70.55) 154.74,70.05 158.78,70.05 168.33,79.6 v3(169.75,79.6)
RTC_X1: length 12
  IN2 w0.133: v3(170.51,96.8) 171.93,96.8 172.71,96.02 v3(172.71,95.35)
  BOTTOM w0.102: 174.83,94.91 174.37,95.37 172.72,95.37 v3(172.71,95.35) ; v3(170.51,96.8) 170.81,97.1 U24.B5
  BOTTOM w0.127: 174.83,94.91 174.91,94.83 175.24,94.51 176.73,94.51 176.87,94.64 C495.2 177.32,94.51 177.81,94.51 177.99,94.69 R554.1 179.68,94.69 Y4.1
RTC_X2: length 12
  IN2 w0.133: v3(173.19,94.87) 173.11,94.79 172.24,94.79 170.89,96.13 v3(170.51,96.13)
  BOTTOM w0.102: v3(170.51,96.13) 170.83,96.45 U24.B4 ; 174.02,94.84 173.99,94.87 v3(173.19,94.87)
  BOTTOM w0.127: 174.02,94.84 174.47,94.39 174.86,94 176.68,94 176.87,93.81 C497.2 177.24,93.91 R554.2 178.41,93.91 Y4.2
S5_ON: length 396
  TOP w0.127: v3(181.03,63.94) 180.61,63.94 180.43,63.75 U13.100 ; v3(190.22,119.78) 189.99,119.78 189.6,119.39 PR68.2 ; PQ29.2 45.75,113.1 44.51,113.1 44,112.59 PQ35.2 40.26,111.42 31.47,111.42 v3(27.07,107.03) ; R315.1 v3(159.95,50.69)
  IN1 w0.133: v3(27.07,107.03) 26.93,106.88 26.93,104.59 27.82,103.7 34.27,103.7 36.25,101.72 36.25,101.12 35.5,100.37 35.1,100.37 33.92,99.18 33.92,86.12 34.4,85.65 34.4,73.18 33.57,72.36 33.57,65.83 33.16,65.41 33.16,63.82 31.88,62.54 31.88,50.69 32.61,49.96 32.61,41.45 38.43,35.63 38.43,35.01 44.75,28.69 44.75,28.13 45.46,27.42 45.46,23.05 45.01,22.6 45.01,21.16 50.9,15.27 76.37,15.27 84.44,23.34 111.16,23.34 v3(111.82,22.69) 112.69,23.56 135.66,23.56 148.64,36.54 148.64,39.56 151.21,42.13 152.94,42.13 154.51,43.71 154.78,43.71 155.94,44.86 157.82,44.86 158.75,43.93 164.27,43.93 v3(164.65,44.32) 165.45,45.12 166.31,45.12 166.91,45.72 166.91,46.27 167.22,46.58 178.77,46.58 181.19,49 181.19,51.72 179.92,53 179.92,55.71 180.76,56.55 180.76,59.57 182.34,61.16 182.34,62.63 v3(181.03,63.94) 180.45,64.52 180.45,66.67 181.79,68.01 181.79,73.15 182.91,74.27 182.91,79.91 182.91,80.36 186.63,84.08 186.63,84.09 186.79,84.25 188.55,84.25 189.24,84.94 189.24,84.94 193.27,88.97 194.95,88.97 195.73,89.75 195.73,110.96 191.3,115.39 191.3,119.63 191.15,119.78 v3(190.22,119.78)
  IN2 w0.133: v3(159.95,50.69) 160.53,50.69 163.08,48.14 163.08,46.32 164.65,44.76 v3(164.65,44.32)
  BOTTOM w0.127: v3(111.82,22.69) 112.46,22.69 118.72,16.43 v2(118.72,13.63) 118.72,10.56 118.27,10.1 118.27,8.46 PQ18.2
S5D: length 244
  TOP w0.127: v3(146.25,55.42) 147.26,56.42 147.26,73.4 151.11,77.26 155.93,77.26 PQ17.2 ; v3(30.97,48.33) 31.41,48.77 35.45,48.77 39.31,52.63 41.63,52.63 44.64,55.64 46.74,55.64 50.46,59.36 PQ14.4 ; v3(122.34,17.06) 122.78,17.49 134.01,17.49 v3(134.72,18.2)
  IN1 w0.133: v3(30.97,48.33) 31.02,48.28 31.02,40.51 34.83,36.7 34.83,36.46 36.11,35.18 36.11,34.38 36.62,33.86 37.89,33.86 43.56,28.19 43.56,27.63 44.27,26.92 44.27,23.54 43.82,23.09 43.82,20.58 50.36,14.04 69.29,14.04 71.57,11.76 75.88,11.76 82.19,18.07 121.32,18.07 v3(122.34,17.06)
  BOTTOM w0.127: v3(134.72,18.2) v2(134.72,19.8) 134.72,21.19 145.23,31.7 145.23,40.09 147.45,42.31 147.45,52.47 146.63,53.29 146.63,55.05 v3(146.25,55.42) ; v3(122.34,17.06) 122.76,16.64 122.76,12.49 121.5,11.22 PR64.2 122.86,11.12 PC49.2 122.87,10.69 122.53,10.36 PR65.2 122.97,9.34 PQ21.3
SATA_IREF: length 1.7
  TOP w0.305: R166.1 153.2,95.3 153.9,96 v3(153.9,96.13)
  BOTTOM w0.254: U24.BD4 153.9,96.16 v3(153.9,96.13)
SATA_RCOMP: length 2.6
  TOP w0.127: v3(155.05,96.59) 154.92,96.72 153.65,96.72 R161.2
  BOTTOM w0.102: v3(155.05,96.59) 155.35,96.88 U24.AY5
SATA_RXN0: length 161.3
  IN2 w0.133: v3(154.81,77.83) 154.57,77.59 154.57,76.94 159.58,71.92 159.58,56.67 158.32,55.41 158.32,53.3 159.2,52.42 159.2,49 162.68,45.52 162.68,44.94 v3(162.91,44.71)
  BOTTOM w0.102: U24.BC8 153.69,98.25 153.23,98.25 153.02,98.05 152.14,98.05 151.04,96.95 151.04,96.92 151.02,96.9
  BOTTOM w0.127: C496.2 195.02,94.49 194.15,94.49 193.29,93.63 193.29,90.27 188.95,85.93 188.01,85.93 182.97,80.89 182.97,73 183.88,72.09 184.43,72.09 189.81,66.71 189.81,66.05 190.92,64.93 190.92,62.93 192.29,61.57 192.29,61.24 193.95,59.58 193.95,48.03 192.21,46.29 192.21,45.03 188.82,41.65 184.44,41.65 183.73,42.36 181.51,42.36 181.12,42.75 178.61,45.26 172.76,45.26 171.25,43.76 166.48,43.76 164.96,45.28 162.82,45.28 162.68,45.14 162.68,44.94 v3(162.91,44.71) ; v3(154.81,77.83) 154.55,78.09 154.55,79.01 150.64,82.92 148.91,82.92 148.01,83.82 148.01,91.47 149.8,93.26 149.8,95.18 150.55,95.93 150.55,96.43 151.02,96.9
SATA_RXN0_C: length 4.2
  BOTTOM w0.127: CN6.5 199.58,94.42 196.61,94.42 C496.1
SATA_RXN1: length 5.4
  BOTTOM w0.102: 150.47,99.19 150.77,99.19 151.1,99.51 152.99,99.51 153.24,99.26 153.71,99.26 U24.BC10
  BOTTOM w0.127: TP107.1 149.55,98.37 150.37,99.19 150.47,99.19
