# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 161.95,147.74 161.95,147.44 162.1,147.29 162.11,147.28 162.15,147.22 162.21,147.18 162.22,147.18 162.28,147.11 163.81,147.11 163.89,147.03 163.89,146.5 163.73,146.35 159.91,146.35 159.59,146.35 159.49,146.45 159.49,147.69 159.95,148.15 161.54,148.15
GND on TOP (solid shape): 31.08,32.63 31.08,32.13 31.09,32.08 31.1,32.02 31.1,31.63 31.14,31.63 31.14,31.46 31.22,31.39 32.06,31.39 32.21,31.23 32.21,26.87 32.16,26.82 27.89,26.82 27.8,26.9 27.8,31.27 27.92,31.39 30.79,31.39 30.88,31.48 30.88,31.63 30.9,31.63 30.9,32.66 31.05,32.66
GND on TOP (solid shape): 92.35,75.7 92.35,74.91 90.45,73.02 88.29,73.02 87.35,72.08 87.35,71.72 87.12,71.49 86.91,71.49 86.54,71.12 86.08,71.12 85.96,71.25 85.96,72.97 86.97,73.98 89.79,73.98 90.48,74.67 91.04,74.67 91.34,74.97 91.34,75.51 91.62,75.79 92.26,75.79
GND on TOP (solid shape): 44,18.15 44,13.51 43.08,12.59 42.37,12.59 41.97,13 41.97,15.27 42.27,16.1 41.97,16.93 41.97,18.33 42.22,18.59 43.57,18.59
GND on TOP (solid shape): 73.99,49.65 73.99,49.06 74.02,49.03 74.02,48.07 73.82,47.88 72.44,47.88 71.4,46.83 68.94,46.83 67.9,47.87 67.9,48.61 68.13,48.84 69.14,48.84 69.68,48.3 71.23,48.3 71.89,48.96 72.14,48.96 72.3,49.13 72.31,49.13 72.4,49.18 72.46,49.28 72.46,49.29 73.11,49.93 73.72,49.93
GND on TOP (solid shape): 16.31,92.86 16.31,90.49 12.73,86.91 12.73,85.79 12.65,85.72 11.94,85.72 11.89,85.77 11.89,87.11 11.51,87.5 11.03,87.5 10.04,88.49 7.19,88.49 5.14,86.43 3.97,86.43 3.72,86.68 3.72,97.09 4.51,97.09 4.76,97.12 4.99,97.22 7.64,97.22 7.73,97.3 11.87,97.3
GND on TOP (solid shape): 193.4,177.84 194.19,177.84 194.44,177.59 194.44,175.91 194.52,175.84 196.94,175.84 197.56,176.45 197.84,176.45 198,176.29 198,174.31 197.9,174.21 197.57,174.21 197.04,174.73 195.17,174.73 195.05,174.62 195.05,173.83 194.85,173.63 193.7,173.63 193.22,174.11 193.22,177.11 192.79,177.54 192.79,177.87 192.97,178.04 193.2,178.04
GND on TOP (solid shape): 173.7,191.65 173.7,190.81 173.3,190.4 173.3,189.65 172.61,188.97 170.57,188.97 170.06,189.48 170.06,189.53 169.35,189.53 168.73,190.14 166.17,190.14 166.06,190.25 166.06,191.42 166.17,191.53 172.01,191.53 172.03,191.54 172.06,191.55 172.72,191.66 173.34,191.89 173.35,191.89 173.46,191.89
GND on TOP (solid shape): 81.33,75.96 81.5,75.89 81.63,75.84 82.23,75.23 82.23,73.77 81.91,73.44 81.91,73.06 81.85,72.9 81.87,72.73 81.85,72.64 81.77,72.59 81.17,72.59 81.13,72.64 81.13,74.52 80.07,75.59 80.07,75.92 80.19,76.04 81.15,76.04
GND on TOP (solid shape): 15.41,30.54 15.41,29.29 14.89,28.77 13.12,28.77 11.81,27.46 2.65,27.46 2.08,28.03 2.08,28.59 2.28,28.79 9.59,28.79 10.07,28.34 10.73,28.26 11.33,28.26 11.59,28.52 11.59,30.3 12.09,30.8 15.14,30.8
GND on TOP (solid shape): 142.75,160.93 142.75,160.72 142.75,160.5 142.95,160.3 143.35,160.3 143.56,160.51 143.56,160.7 143.72,160.87 143.96,160.87 144.11,160.72 144.11,157.11 144.34,156.88 144.51,156.88 145.09,156.3 145.1,156.3 145.34,156.05 145.34,155.62 145.22,155.49 143.14,155.49 143.06,155.57 143.06,156.01 143.61,156.57 143.61,157.08 143.27,157.42 143.05,157.42 142.9,157.58 142.9,157.89 143.66,158.66 143.66,159.15 143.42,159.39 142.95,159.39 142.74,159.18 142.74,158.72 142.68,158.66 142.06,158.66 141.98,158.75 141.98,159.84 141.8,160.02 141.8,160.82 141.93,160.96 142.72,160.96
GND on TOP (solid shape): 101.32,125.7 101.32,125.37 101.13,125.17 100.43,125.17 100.21,124.94 100.21,122.23 100.05,122.07 99.16,122.07 99.05,122.18 99.05,125.09 99.38,125.42 99.4,125.42 99.52,125.45 99.63,125.52 99.87,125.52 100.34,125.48 100.49,125.92 100.51,126 100.59,126.04 100.98,126.04
GND on TOP (solid shape): 5.77,64.92 10.19,64.92 10.62,64.48 12.15,64.48 12.6,64.03 12.6,63.01 12.17,62.58 9.86,62.58 9.36,63.08 9.36,63.2 8.58,64.31 7.27,63.96 1.11,63.96 1.11,64.53 1.11,65.04 1.31,65.25 2.53,65.25 2.95,65.31 3.33,65.48 5.21,65.48
GND on TOP (solid shape): 154.43,21.77 155.14,21.77 155.35,21.56 155.35,20.27 155.83,19.79 155.92,19.79 155.96,19.75 158.02,19.75 159.4,19.75 159.67,19.75 159.84,19.93 174.83,19.93 175.19,19.57 175.19,17.19 175.39,16.99 176.63,16.99 176.79,16.83 176.79,16.02 176.63,15.87 175.32,15.87 173.69,17.49 170.66,17.49 170.49,17.66 170.16,17.66 170,17.49 158.35,17.49 157.51,16.66 155.1,16.66 154.33,17.42 154.33,18.94 153.22,20.06 152.64,20.06 152.45,20.12 152.27,20.17 151.97,20.46 152.01,20.5 152.12,20.79 151.98,21.07 151.97,21.08 151.95,21.12 151.95,21.43 152.31,21.8 153.07,21.8 153.13,21.86 154.34,21.86
GND on TOP (solid shape): 109.32,176.37 109.32,172.36 109.76,171.92 109.76,170.9 109.69,170.8 109.58,170.84 108.2,170.8 108.69,169.51 109.1,169.11 109.1,168.6 109.02,168.53 108.69,168.53 108.59,168.63 108.59,169.05 108.3,169.35 107.19,169.35 107,169.16 106.37,169.16 106.31,169.22 106.31,169.56 106.49,169.73 106.94,169.73 107.6,170.4 107.6,170.81 108.81,172.02 108.81,176.36 108.85,176.4 109.29,176.4
GND on TOP (solid shape): 140.24,62.84 140.24,57.79 140.92,57.11 140.92,45.1 141.43,44.59 141.43,41.39 140.92,40.88 140.92,38.32 140.59,37.99 139.38,37.99 139.18,38.19 139.18,41.6 140.11,42.54 140.11,43.42 138.94,44.6 138.94,48.63 138.97,48.67 138.97,50.24 138.97,50.27 138.97,50.57 138.97,50.6 138.97,51.38 138.97,51.41 138.97,51.72 138.98,51.74 138.99,51.76 139.19,51.97 139.19,53.36 139.15,53.41 139.15,53.42 138.71,53.86 138.71,54.73 138.81,54.83 139.58,54.83 139.88,55.14 139.88,55.31 139.98,56.09 139.43,56.66 139.02,57.07 139.02,61.81 138.76,62.07 136.02,62.07 135.64,61.69 131.68,61.69 130.47,60.49 129.28,60.49 129.04,60.73 129.04,61.98 130.25,63.19 139.89,63.19
GND on TOP (solid shape): 14.96,47.47 19.51,47.47 19.59,47.39 19.59,45.36 17.23,45.36 16.77,45.81 15.22,45.81 14.33,44.93 14.33,43.72 15.13,42.92 15.13,42.06 14.86,41.79 11.58,41.79 11.58,42.9 10.78,43.93 9.59,43.41 2.28,43.41 2.08,43.61 2.08,46.63 2.08,46.63 2.08,47.24 7.27,47.24 8.58,46.89 9.36,48 9.36,48.58 9.96,49.18 13.25,49.18
GND on TOP (solid shape): 142.4,157.09 142.58,156.94 142.56,156.71 142.48,156.62 142.42,156.59 142.36,156.58 142.28,156.59 142.06,156.59 142.05,156.58 141.99,156.58 141.99,156.51 141.79,156.32 141.79,154.27 141.93,154.12 142.21,154.12 142.95,154.12 143.03,154.2 143.35,154.2 143.44,154.11 143.44,153.68 143.35,153.59 142.27,153.59 142.26,153.59 141.06,153.59 140.81,153.84 140.81,153.86 140.72,154.05 140.55,154.16 140.54,154.17 140.52,154.2 140.52,155.01 140.53,155.04 140.55,155.06 140.8,155.34 140.68,155.7 140.67,155.72 140.67,155.74 140.67,156.45 140.82,156.6 141.61,156.6 142.02,157.01 142.09,157.09
GND on TOP (solid shape): outline of 120 points within 144.92,152.67 157.82,163.44
GND on TOP (solid shape): outline of 127 points within 146.84,153.52 149.64,159.15
GND on TOP (solid shape): outline of 146 points within 172.47,146.45 193.07,161.61
GND on TOP (solid shape): outline of 171 points within 73.41,0.51 102.27,11.67
GND on TOP (solid shape): 38.28,10.08 38.28,9.8 39.21,7.69 40.01,9.85 40.01,10.1 40.14,10.23 55.04,10.23 57.72,7.55 58.97,7.55 61.42,5.1 61.42,3.78 61.52,3.68 65.82,3.68 65.97,3.52 65.97,2.33 65.87,2.23 60.35,2.23 60.01,2.37 59.87,2.71 59.87,3.4 59.43,4.44 58.4,4.9 58.39,4.89 46.95,4.89 45.88,4.45 45.44,3.38 45.44,2.21 39.01,2.21 38.08,4.12 37.52,4.73 36.72,4.96 25.33,4.96 23.98,2.21 7.12,2.21 3.81,4.72 1.62,8.25 1.62,8.69 1.88,8.96 4.5,8.96 5.03,9.49 9.78,9.49 11.74,7.54 18.08,7.54 19.21,8.67 28.78,8.67 30.34,10.23 38.13,10.23
GND on TOP (solid shape): outline of 331 points within 43.87,75.33 72.85,95.95
GND on TOP (solid shape): outline of 303 points within 111.1,92.01 115.33,102.51
GND on TOP (solid shape): outline of 359 points within 104.04,92.48 108.15,102.48
GND on TOP (solid shape): outline of 428 points within 104.19,0.51 198.14,26.82
GND on TOP (solid shape): outline of 443 points within 186.41,60.4 202.12,195.52
GND on TOP (solid shape): outline of 112 points within 3.72,110.76 174.17,195.52
GND on TOP (solid shape): outline of 648 points within 98.59,38.75 108.21,43.66
GND on TOP (solid shape): outline of 3072 points within 118.28,81.22 131.09,104.79
GND on BOTTOM (solid shape): 38.33,10.41 38.33,9.21 37.75,8.63 35.51,8.63 35.21,8.93 35.21,10.18 35.67,10.64 38.1,10.64
GND on BOTTOM (solid shape): 43.67,14.6 43.67,12.87 43.24,12.44 41.97,12.44 41.66,12.74 41.66,14.7 42.09,15.13 43.13,15.13
GND on BOTTOM (solid shape): 54.15,27.63 54.15,25.37 54.05,25.27 52.63,25.27 52.35,25.55 52.35,27.45 52.61,27.7 54.08,27.7
GND on BOTTOM (solid shape): 103.98,127.54 103.98,123.77 103.67,123.46 102.37,123.46 102.11,123.73 102.11,128.01 102.33,128.23 103.29,128.23
GND on BOTTOM (solid shape): 113.82,159.63 113.82,155.95 113.64,155.77 111.86,155.77 111.56,156.08 111.56,159.68 111.69,159.81 113.64,159.81
GND on BOTTOM (solid shape): 140.47,34.07 140.47,28.75 140.03,28.31 136.79,28.31 136.57,28.54 136.57,33.33 137.89,34.65 139.88,34.65
GND on BOTTOM (solid shape): 143.72,15.69 143.72,14.52 143.57,14.37 140.77,14.37 140.77,15.66 140.92,15.82 143.59,15.82
GND on BOTTOM (solid shape): 175.82,190.52 175.82,188.36 175.54,188.08 173.61,188.08 172.78,188.92 172.78,189.83 173.79,190.85 175.49,190.85
GND on BOTTOM (solid shape): 185.35,140.56 185.35,138.98 185.32,138.96 183.75,138.96 183.72,138.98 183.72,140.56 183.75,140.58 185.32,140.58
GND on BOTTOM (solid shape): 187.81,172.99 187.81,172.08 187.53,171.8 184.26,171.8 183.9,172.15 183.9,173.27 184.26,173.63 187.18,173.63
GND on BOTTOM (solid shape): 192.99,139.39 192.99,137.89 192.89,137.79 192.03,137.79 191.9,137.91 191.9,139.52 191.98,139.59 192.79,139.59
GND on BOTTOM (solid shape): 198.14,58.03 198.14,29.43 198.04,29.33 197.54,29.33 197.44,29.43 197.44,57.93 197.62,58.11 198.05,58.11
GND on BOTTOM (solid shape): 198.23,109.9 198.23,108.73 197.87,108.37 194.47,108.37 194.16,108.68 194.16,110.51 194.39,110.74 197.39,110.74
GND on BOTTOM (solid shape): 22.25,99.36 22.25,95.9 21.49,95.14 20.32,95.14 19.7,95.76 19.7,99.26 20.71,100.27 21.34,100.27
GND on BOTTOM (solid shape): 30.43,31.57 30.43,27.28 30.05,26.9 27.97,26.9 27.71,27.16 27.71,30.78 28.73,31.79 30.2,31.79
GND on BOTTOM (solid shape): 108.97,163.57 108.97,161.94 108.71,161.69 107.22,161.69 107.06,161.84 107.06,163.8 107.2,163.94 108.6,163.94
GND on BOTTOM (solid shape): 66.6,105.66 66.6,102.71 66.04,102.15 64.6,102.15 64.27,102.48 64.27,104.08 64.44,104.26 64.44,105.25 65,105.81 66.45,105.81
GND on BOTTOM (solid shape): 76.81,78.59 76.81,74.21 75.32,72.71 73.77,72.71 72.99,73.49 72.99,78.38 73.8,79.19 76.2,79.19
GND on BOTTOM (solid shape): 148.92,16.88 148.92,16.02 149.17,15.78 149.17,14.23 149.1,14.17 147.02,14.17 146.82,14.37 146.82,16.73 147.15,17.06 148.75,17.06
GND on BOTTOM (solid shape): 149.31,185.08 149.31,182.42 149.18,182.29 146.87,182.29 146.61,182.54 144.35,182.54 143.87,183.03 143.87,184.73 144.48,185.34 149.05,185.34
GND on BOTTOM (solid shape): 151.65,159.53 151.65,159.18 151.54,159.07 150.73,159.07 145.19,153.53 145.06,153.53 144.92,153.67 144.92,153.92 150.62,159.61 151.57,159.61
GND on BOTTOM (solid shape): 153.44,134.92 153.44,134.1 153.06,133.72 153.06,131.31 152.88,131.13 151.31,131.13 151.01,131.44 151.01,134.46 151.77,135.22 153.14,135.22
GND on BOTTOM (solid shape): 155.17,178.96 155.17,177.54 154.77,177.13 153.75,177.13 153.64,177.25 153.64,178.89 153.84,179.09 155.04,179.09
GND on BOTTOM (solid shape): 165.46,15.92 165.46,14.27 164.39,14.27 164.37,14.25 161.04,14.25 160.94,14.34 160.94,16.01 161.17,16.23 165.14,16.23
GND on BOTTOM (solid shape): 170.57,114.64 170.57,113.62 170.52,113.57 169.71,113.57 169.68,113.59 169.68,113.73 169.69,113.76 169.69,114.11 170.32,114.75 170.46,114.75
GND on BOTTOM (solid shape): 182.44,25.9 182.44,25.76 182.45,25.75 182.45,24.2 182.09,23.84 180.16,23.84 180.04,23.97 180.04,26.13 180.34,26.43 181.9,26.43
GND on BOTTOM (solid shape): 184.63,28.81 184.63,25.52 184.58,25.47 183.97,25.47 183.06,26.38 183.06,28.85 183.29,29.08 184.36,29.08
GND on BOTTOM (solid shape): 187.83,22.7 187.83,21.2 187.05,20.41 186.16,20.41 185.51,21.06 185.51,21.34 184.66,22.19 184.66,22.47 185.24,23.06 187.48,23.06
GND on BOTTOM (solid shape): 191.9,55.03 191.9,50.11 191.57,49.78 190.73,49.78 190.31,50.19 190.31,53.12 191.24,54.04 191.24,55.01 191.39,55.16 191.77,55.16
GND on BOTTOM (solid shape): 144.44,163.05 144.44,162.75 142.72,161.03 142.5,161.03 142.44,161.08 142.44,161.51 143.96,163.02 143.96,163.02 144.11,163.18 144.31,163.18
GND on BOTTOM (solid shape): 156.75,75.18 156.75,73.27 156.67,73.2 154.13,73.2 153.86,73.47 153.86,74.23 155.08,75.45 155.21,75.58 156.34,75.58
GND on BOTTOM (solid shape): 30.43,89.48 30.43,86.86 30.33,86.76 27.26,86.76 26.7,87.32 26.7,88.87 27.51,89.68 27.51,91.08 27.77,91.33 28.58,91.33
GND on BOTTOM (solid shape): 31.93,13.63 31.93,11.65 31.92,11.62 31.88,11.6 29.85,11.6 29.65,11.8 29.65,13.61 29.85,13.81 31.75,13.81
GND on BOTTOM (solid shape): 146.57,163.29 146.57,162.89 142.73,159.05 142.56,159.05 142.49,159.12 142.49,159.18 142.39,159.27 142.39,159.36 146.05,163.02 146.05,163.29 146.17,163.4 146.46,163.4
GND on BOTTOM (solid shape): 148.46,163.32 148.46,162.82 142.55,156.91 142.55,156.7 142.44,156.59 142.21,156.59 142.07,156.73 142.07,157.09 147.92,162.95 147.92,163.31 148.05,163.43 148.35,163.43
GND on BOTTOM (solid shape): 149.89,162.93 149.89,162.22 142.77,155.09 142.56,155.09 142.46,155.19 142.46,155.51 149.15,162.21 149.15,162.69 148.81,163.03 148.81,163.29 148.97,163.44 149.38,163.44
GND on BOTTOM (solid shape): 151.68,157.4 151.68,157.1 151.48,156.9 150.54,156.9 148.1,154.45 148.1,153.58 147.98,153.46 147.66,153.46 147.46,153.66 147.46,154.4 150.62,157.56 151.52,157.56
GND on BOTTOM (solid shape): 151.7,155.49 151.7,155.15 151.56,155.01 150.7,155.01 149.88,154.2 149.88,153.44 149.8,153.36 149.37,153.36 149.29,153.44 149.29,154.3 150.57,155.58 151.62,155.58
GND on BOTTOM (solid shape): 154.77,95.25 154.77,94.96 154.07,94.26 153.7,94.26 153.58,94.39 153.58,94.57 153.81,94.8 153.81,95.2 153.93,95.33 154.69,95.33
GND on BOTTOM (solid shape): 184.64,135.35 184.64,134.05 184.51,133.93 184.1,133.93 183.98,134.05 183.98,134.44 183.77,134.64 182.99,134.64 182.76,134.87 182.76,135.32 182.91,135.48 184.51,135.48
GND on BOTTOM (solid shape): 185.31,74.57 185.31,74.23 185.3,74.19 185.26,74.18 183.45,74.18 183.42,74.21 183.42,75.14 183.84,75.56 184.32,75.56
GND on BOTTOM (solid shape): 103.69,12.27 103.69,8.98 103.51,8.81 101.73,8.81 101.55,8.98 101.55,10.76 101.56,10.78 101.57,10.8 101.73,10.96 101.73,12.9 102.06,13.23 102.73,13.23
GND on BOTTOM (solid shape): 152.91,25.6 152.91,24.12 151.26,22.47 149.74,22.47 149.56,22.65 149.56,23.95 149.57,23.96 149.57,24.19 149.57,24.19 149.57,24.97 150.4,25.8 152.71,25.8
GND on BOTTOM (solid shape): 25.51,15.28 25.51,14.7 25.66,14.55 25.96,14.55 26.19,14.32 26.19,11.92 26.03,11.76 25.77,11.76 24.88,12.65 24.88,15.34 25.02,15.48 25.31,15.48
GND on BOTTOM (solid shape): 71.56,47.67 71.56,45.76 71.56,44.34 70.73,43.52 70.73,41.71 70.44,41.42 70.21,41.42 70.18,41.39 66.21,41.39 66,41.6 66,48 66.77,48.76 70.46,48.76
GND on BOTTOM (solid shape): 113.46,145.71 113.46,143.38 113.87,142.97 113.87,142.3 113.62,142.05 113.62,139.95 113.36,139.69 112.17,139.69 111.53,140.33 111.53,146.16 111.94,146.56 112.61,146.56
GND on BOTTOM (solid shape): 151.68,161.55 151.68,161.23 151.55,161.11 150.85,161.11 150.85,161.11 150.77,161.11 143.36,153.7 143.07,153.7 142.94,153.83 142.94,153.92 150.62,161.6 151.63,161.6
GND on BOTTOM (solid shape): 110.75,11.97 112.89,11.97 113.01,11.85 113.01,8.35 112.3,7.64 111.13,7.64 109.87,8.9 109.87,11.49 109.53,11.83 109.53,12.01 109.83,12.31 110.41,12.31
GND on BOTTOM (solid shape): 158.6,18.87 158.6,16.22 156.57,14.19 154.11,14.19 154.03,14.27 154.03,16.38 154.17,16.7 154.27,17.03 154.27,17.05 156.24,19.02 158.45,19.02
GND on BOTTOM (solid shape): 42.45,60.75 42.45,58.97 42.42,58.95 40.62,58.95 40.57,58.9 38.76,58.9 38.66,59 38.66,59.61 38.79,59.73 40.47,59.73 40.59,59.86 40.59,60.72 40.64,60.78 42.42,60.78
GND on BOTTOM (solid shape): 178.67,96.61 178.67,96.59 178.45,96.37 175,96.37 174.73,96.11 174.5,96.11 174.46,96.12 174.45,96.16 174.45,96.46 174.67,96.68 174.91,96.68 174.97,96.74 178.54,96.74
GND on BOTTOM (solid shape): 21.13,94.89 21.31,94.89 21.34,94.86 21.34,93.08 21.35,93.08 21.35,92.07 21.33,92.03 21.29,92.02 18.19,92.02 17.91,92.3 17.91,94.86 18.04,94.99 21.04,94.99
GND on BOTTOM (solid shape): 28.25,100.27 30.28,100.27 30.28,100.27 30.33,100.22 30.33,99.41 29.88,98.96 29.88,96.96 29.52,96.59 28.88,96.59 28.5,96.21 27.1,96.21 26.21,97.1 26.21,100.15 26.47,100.4 28.12,100.4
GND on BOTTOM (solid shape): 105.41,177.74 105.54,177.72 105.67,177.74 105.68,177.74 106.4,177.74 107.27,176.88 107.27,174.03 106.76,173.53 105.21,173.53 104.83,173.91 104.83,177.51 105.06,177.74 105.4,177.74
GND on BOTTOM (solid shape): 153.72,114.1 153.72,113.82 153.73,113.81 153.73,113.08 153.6,112.96 153.37,112.96 153.3,113.03 153.3,113.38 153.17,113.51 153.17,113.51 153.01,113.67 152.62,113.67 152.49,113.8 152.49,114.22 152.56,114.29 153.53,114.29
GND on BOTTOM (solid shape): 113.84,175.69 113.84,169.13 113.72,169 113.34,169 113.18,169.16 113.18,170.93 112.51,171.61 112.51,174.82 112.53,174.92 112.51,175.03 112.51,175.2 113.12,175.81 113.72,175.81
GND on BOTTOM (solid shape): 159.54,187.88 159.64,187.77 159.75,187.77 159.95,187.57 159.95,185.59 159.87,185.51 157.97,185.51 157.84,185.64 157.84,187.55 157.99,187.7 159.08,187.7 159.26,187.88 159.26,188.74 159.29,188.77 159.54,188.77
GND on BOTTOM (solid shape): 170.49,191.2 170.49,189.86 170.39,189.76 169.96,189.76 169.83,189.88 169.83,190.29 169.65,190.47 168.51,190.47 168.36,190.62 167.34,190.62 167.11,190.39 167.11,189.83 166.96,189.68 165.99,189.68 165.89,189.78 165.89,191.23 166.12,191.46 170.24,191.46
GND on BOTTOM (solid shape): 76.61,58.84 76.86,58.84 76.86,59.03 76.87,59.03 76.87,60.53 76.86,60.53 76.86,60.89 77.22,60.89 77.22,58.84 77.47,58.84 77.47,60.89 77.83,60.89 77.83,58.26 77.22,57.65 76.86,57.65 76.28,58.22 76.28,60.81 76.36,60.89 76.61,60.89
GND on BOTTOM (solid shape): 151.24,177.51 151.24,176.93 151.44,176.72 151.6,176.72 151.6,176.72 152.73,176.72 152.84,176.6 152.84,175.49 152.82,175.47 151.49,175.47 151.37,175.58 151.37,176.06 150.75,176.68 150.75,176.8 150.73,176.83 150.73,177.51 150.83,177.62 151.13,177.62
GND on BOTTOM (solid shape): 156.85,67.71 156.85,66.19 156.63,65.96 155.57,65.96 155.46,66 155.35,66.01 154.69,66.01 154.16,65.47 154.16,64.74 154.08,64.66 153.73,64.66 153.6,64.79 153.6,66.66 155.24,68.31 156.25,68.31
GND on BOTTOM (solid shape): 88.32,52.75 88.32,50.72 87.99,50.72 87.99,52.75 87.71,52.75 87.71,50.72 87.38,50.72 87.38,52.75 87.13,52.75 87.13,50.72 86.93,50.72 86.8,50.85 86.8,52.8 86.72,52.88 86.72,53.49 86.11,54.1 85.93,54.1 85.75,54.28 85.75,54.76 85.93,54.94 86.14,54.94
GND on BOTTOM (solid shape): 122.54,104.53 122.54,96.36 122.4,96.21 120.64,96.21 120.51,96.09 120.51,94.56 120.39,94.43 118.99,94.43 118.86,94.56 118.86,100.69 119.05,100.87 119.49,100.87 119.7,101.09 119.7,102.39 118.86,103.23 118.86,104.59 119.12,104.85 122.23,104.85
GND on BOTTOM (solid shape): 82.1,54.46 82.1,53.9 82.08,53.87 82.08,53.29 82.08,52.98 82.33,52.72 82.33,50.59 82.1,50.36 81.59,50.36 81.39,50.56 81.39,50.67 82,50.67 82,52.72 81.72,52.72 81.72,50.67 81.39,50.67 81.39,52.88 81.58,53.07 81.58,54.47 81.67,54.56 82,54.56
GND on BOTTOM (solid shape): 166.53,104.96 166.62,104.9 166.73,104.87 166.75,104.86 166.81,104.8 166.81,104.22 166.61,104.02 166.51,104.02 166.23,103.74 165.9,103.74 165.44,104.19 165.44,104.42 165.55,104.53 165.64,104.58 165.64,104.63 166,104.98 166.52,104.98
GND on BOTTOM (solid shape): 174.93,52.07 174.93,51.02 174.94,50.92 174.96,50.83 174.96,49.77 174.82,49.59 174.81,49.36 174.81,49.35 174.81,49.32 174.3,48.81 174.3,48.23 174.02,47.95 173.03,47.95 172.9,48.08 172.9,48.99 173.69,49.78 173.69,51.99 173.79,52.09 174.91,52.09
GND on BOTTOM (solid shape): 96.32,122.6 96.32,121.79 96.58,121.53 97.54,121.53 97.77,121.3 97.77,120.34 97.31,119.88 92.26,119.88 92.1,120.03 92.1,121.91 92.36,122.17 92.92,122.17 93.12,121.96 93.12,121.18 93.15,121.15 93.15,121.13 93.2,121.02 93.31,120.97 93.33,120.97 93.48,120.82 95.03,120.82 95.43,121.23 95.43,122.78 95.64,122.98 95.94,122.98
GND on BOTTOM (solid shape): 57.79,103.67 57.79,99.94 57.42,99.57 55.26,99.57 54.6,100.23 56.85,100.23 56.85,100.97 55.1,100.97 55.1,100.23 54.6,100.23 53.33,101.5 56.85,101.5 56.85,102.24 55.1,102.24 55.1,101.5 53.33,101.5 52.06,102.77 56.85,102.77 56.85,103.51 55.1,103.51 55.1,102.77 52.06,102.77 51.97,102.86 51.97,103.85 52.33,104.21 57.25,104.21
GND on BOTTOM (solid shape): 191.9,31.79 191.9,26.74 191.59,26.43 190.78,26.43 190.35,26.87 190.35,30.7 190.62,30.97 190.62,30.97 190.83,31.36 190.62,31.75 190.62,31.75 190.52,31.84 190.51,31.88 190.52,31.92 190.58,31.97 191.72,31.97
GND on BOTTOM (solid shape): 187.05,160.98 187.05,159.02 187.56,158.51 188.73,158.51 188.83,158.41 188.83,157.25 188.7,157.12 186.95,157.12 186.59,156.76 186.59,154.83 186.59,154.83 186.59,154.15 186.92,153.82 188.31,153.82 188.6,153.54 188.6,150.49 188.5,150.39 186.89,150.39 186.13,151.15 181.43,151.15 180.22,152.36 178.46,152.36 178.26,152.56 178.26,157.21 177.8,157.68 177.8,158.44 177.95,158.59 179.25,158.59 179.76,159.1 179.76,161.08 180.29,161.61 186.41,161.61
GND on BOTTOM (solid shape): 137.52,147.21 137.75,147.21 138.28,146.68 138.28,143.4 137.27,142.39 137.27,141.55 137.44,141.37 137.93,141.37 138.08,141.22 138.08,140.94 136.91,139.77 136.87,139.77 136.74,139.64 136.71,139.62 136.61,139.56 136.58,139.51 136.05,138.98 136.05,137.38 135.84,137.18 135.23,137.18 135.21,137.18 135.11,137.28 135.11,139.57 135.77,140.23 135.77,142.54 136.63,143.4 136.63,147.77 136.71,147.85 136.87,147.85
GND on BOTTOM (solid shape): 75.49,33.66 75.49,29.28 75.36,29.15 75.33,29.14 75.3,29.15 74.79,29.12 74.76,28.61 74.77,28.58 74.76,28.54 74.32,28.11 72.17,28.11 71.05,29.23 71.05,33.32 72.45,34.71 74.44,34.71
GND on BOTTOM (solid shape): 15.17,30.07 15.17,28.47 14.18,27.48 2.51,27.48 2.08,27.91 2.08,28.59 2.28,28.79 9.56,28.79 9.59,28.79 9.61,28.77 10.8,28.28 11.58,29.3 11.58,29.66 12.29,30.37 14.86,30.37
GND on BOTTOM (solid shape): 153.23,96.31 153.27,96.27 153.31,96.23 153.45,96.09 153.45,96.07 153.52,95.87 153.68,95.72 153.68,95.72 153.74,95.67 153.61,95.54 153.53,95.57 153.48,95.58 153.14,95.49 152.97,95.17 152.97,95.15 152.89,95.07 152.89,94.22 152.73,94.06 152.56,94.06 152.37,94.25 152.37,95.51 152.71,95.85 152.71,96.29 152.87,96.45 153.09,96.45
GND on BOTTOM (solid shape): 162.67,108.92 162.67,108.79 162.36,108.49 162.36,107.88 162.59,107.65 162.59,107.5 162.09,106.99 161.78,106.99 161.65,107.12 161.65,107.15 161.6,107.31 161.47,107.42 161.43,107.43 161.43,107.65 161.5,107.72 161.57,107.77 161.62,107.84 161.68,107.9 161.68,108.28 161.97,108.57 161.98,108.58 162.1,108.65 162.17,108.76 162.17,108.78 162.39,109 162.59,109
GND on BOTTOM (solid shape): 192.14,64.94 192.21,65.04 192.33,65 192.97,64.44 193.8,64.24 195.55,64.24 196.1,63.69 196.85,63.49 198.39,63.49 198.39,61.2 198.39,61.19 197.95,60.75 195.21,60.75 192.14,63.83
GND on BOTTOM (solid shape): 51.03,39.67 51.03,38.65 50.73,38.35 50.73,37.43 51.31,36.85 52.51,36.85 52.89,37.23 52.89,38.02 52.96,38.09 58.27,38.09 60,36.37 61.95,36.37 62.28,36.03 62.28,30.7 61.67,30.09 61.24,30.09 61.05,29.9 61.05,28.46 60.87,28.28 59.92,28.28 59.71,28.49 59.71,29.22 59.73,29.25 59.73,30.67 57.69,32.71 57.69,35.63 57.41,35.91 53.39,35.91 52.91,35.43 52.91,33.47 52.63,33.19 52.25,33.19 51.97,32.91 51.97,31.9 52.17,31.69 53.11,31.69 53.16,31.64 53.16,31.51 52.17,31.51 51.72,31.97 51.72,34.26 50.22,35.76 46.57,35.76 44.55,35.76 43.13,37.18 43.13,39.46 43.54,39.87 50.83,39.87
GND on BOTTOM (solid shape): 171.69,97.03 171.69,96.66 172.43,95.91 172.43,95.6 171.87,95.04 171.87,94.89 171.7,94.72 169.9,94.72 169.59,95.04 169.59,95.26 169.62,95.29 169.83,95.29 169.85,95.3 169.86,95.3 170.24,95.3 170.61,95.68 170.63,95.68 170.85,95.8 170.97,96.03 170.98,96.04 171.03,96.1 171.05,96.1 171.19,96.19 171.28,96.34 171.28,96.35 171.33,96.4 171.33,96.8 171.34,96.83 171.34,97.07 171.38,97.12 171.6,97.12
GND on BOTTOM (solid shape): 165.63,143.83 165.63,142.32 165.44,142.13 165.07,142.13 164.86,141.92 164.8,141.93 164.75,141.93 164.7,141.92 164.64,141.91 164.59,141.88 164.55,141.85 164.51,141.82 164.47,141.78 164.44,141.73 164.42,141.68 164.4,141.63 164.39,141.58 164.39,141.52 164.4,141.47 164.42,141.41 164.44,141.36 164.47,141.32 164.5,141.28 164.54,141.24 164.59,141.21 164.64,141.19 164.64,140.35 164.47,140.18 163.25,140.18 163.15,140.07 163.15,138.73 163.12,138.7 161.44,138.7 161.42,138.73 161.42,140.4 161.44,140.43 162.31,140.43 162.39,140.51 162.39,140.66 162.89,140.66 162.89,141.67 162.67,141.67 162.67,140.66 162.39,140.66 162.39,141.89 162.56,142.06 163.43,142.06 163.95,142.58 163.95,144.29 164.15,144.49 164.97,144.49
GND on BOTTOM (solid shape): 142.79,109.34 143.08,109.26 143.37,109.34 143.96,109.34 144.25,109.26 144.54,109.34 145.15,109.34 145.38,109.26 145.63,109.29 145.64,109.3 145.67,109.29 145.82,109.14 145.82,106.85 145.57,106.6 144.43,106.6 143.86,107.17 143.63,107.17 142.75,108.04 141.63,108.04 141.53,108.15 141.53,109.16 141.66,109.3 141.69,109.3 141.71,109.3 141.96,109.26 142.2,109.34
GND on BOTTOM (solid shape): 146.46,47.72 146.46,44.99 146.42,44.91 146.32,44.9 145.8,44.54 146.32,44.19 146.42,44.18 146.46,44.1 146.46,42.51 144.54,40.59 141.07,40.59 140.52,41.14 140.52,44.71 139.95,45.28 139.95,47.76 139.99,47.79 139.99,48.51 140.69,49.22 144.96,49.22
GND on BOTTOM (solid shape): 171.55,52.11 171.58,52.13 171.62,52.12 171.66,52.09 171.71,52.08 171.73,52.05 171.73,51.02 171.73,50.93 171.75,50.85 171.75,49.96 171.95,49.76 171.95,47.22 171.14,46.42 170.69,46.42 170.37,46.73 170.37,49.12 170.41,49.2 170.49,49.22 170.94,49.6 170.49,49.97 170.41,50 170.37,50.07 170.37,51.59 170.39,51.63 170.42,51.64 171.09,51.64
GND on BOTTOM (solid shape): 35.23,18.76 35.23,18.08 35.45,17.86 35.46,17.83 35.45,17.8 35.62,17.11 36.26,17.4 36.28,17.43 36.31,17.44 36.48,17.44 36.78,17.14 36.78,17.01 37.24,16.55 37.24,15.87 37.06,15.69 36.28,15.69 35.95,15.36 35.21,15.36 35.18,15.39 35.18,15.65 35.19,15.66 35.21,15.79 35.19,15.92 35.18,15.93 35.18,16.43 34.78,16.83 33,16.83 32.44,17.39 31.65,17.39 31.55,17.49 31.55,20.08 31.91,20.44 33.56,20.44
GND on BOTTOM (solid shape): 184.25,126.64 184.25,125.44 184.94,124.76 187.61,124.76 187.73,124.63 191.24,124.63 191.62,124.25 191.62,123.51 191.06,122.95 188.47,122.95 188.37,123.06 185.12,123.06 184.99,122.93 184.99,120.39 185.63,119.75 189.8,119.75 189.83,119.74 189.85,119.71 190.22,119.4 190.6,119.71 190.62,119.74 190.65,119.75 190.93,119.75 191.11,119.58 191.11,118.92 191.04,118.84 187.77,118.84 187.56,118.63 187.56,117.82 187.37,117.64 187.02,117.64 186.87,117.79 186.87,118.62 186.65,118.84 186.21,118.84 186.2,118.85 185.65,118.85 185.12,118.32 183.45,118.32 180.29,121.48 180.29,126.71 180.42,126.84 184.05,126.84
GND on BOTTOM (solid shape): 16.51,68.61 16.51,66.47 18.32,64.66 18.32,61.77 17.17,60.62 14.56,60.62 12.68,62.5 9.94,62.5 9.36,63.08 9.36,63.2 8.58,64.31 7.27,63.96 1.11,63.96 1.11,64.51 1.11,65.04 1.31,65.25 2.53,65.25 3.14,65.38 3.65,65.74 9.07,65.74 11.03,67.7 12.45,67.7 12.45,69.44 12.49,69.49 12.51,69.49 13,69.71 13.34,70.11 15.02,70.11
GND on BOTTOM (solid shape): 170.91,113.32 170.96,113.32 171.04,113.28 171.07,113.21 171.38,112.81 171.86,112.96 172.27,112.96 172.4,112.83 172.4,112.65 172.36,112.6 172.32,112.6 171.67,111.95 171.4,111.95 171.37,112.03 171.35,112.07 171.32,112.11 171.28,112.16 171.28,112.37 171.25,112.41 171.24,112.43 171.22,112.5 171.19,112.58 171.16,112.61 171.13,112.65 171.06,112.69 170.98,112.73 170.98,112.82 170.96,112.91 170.95,112.95 170.93,112.99 170.88,113.07 170.81,113.13 170.77,113.22 170.8,113.32 170.83,113.35
GND on BOTTOM (solid shape): 169.39,140.84 169.39,137.93 169.36,137.88 169.35,137.88 168.04,137.01 167.17,135.7 167.16,135.69 167.11,135.65 165.9,135.65 165.74,135.82 165.74,136.34 166.24,136.84 166.24,137.46 166.35,137.56 166.96,137.56 167.39,137.99 167.39,139.71 167.44,139.8 167.53,139.8 168.06,140.26 167.37,140.35 167.14,140.12 166.47,140.12 166.27,140.33 166.27,140.73 166.42,140.89 167.03,140.89 167.9,141.75 168.48,141.75
GND on BOTTOM (solid shape): outline of 84 points within 171.01,170.78 180.12,181.81
GND on BOTTOM (solid shape): 13.84,47.5 18.34,47.5 19.26,46.58 19.26,45.43 19.13,45.31 17.71,45.31 17.25,45.76 15.07,45.76 14.63,45.33 14.63,43.35 15.12,42.87 15.12,42.16 14.94,41.98 12.36,41.98 11.58,42.77 11.58,42.9 10.8,43.92 9.61,43.43 9.59,43.41 9.56,43.41 2.28,43.41 2.08,43.61 2.08,46.63 2.08,46.63 2.08,47.24 7.27,47.24 8.58,46.89 9.36,48 9.36,48.13 9.86,48.63 12.7,48.63
GND on BOTTOM (solid shape): 114,195.52 115.25,195.02 116.36,194.32 117.65,194.07 171.68,194.07 172.73,194.49 173.19,195.52 173.99,195.52 174.43,195.09 174.43,192.61 173.94,192.13 172.79,192.13 172.29,192.63 153.99,192.63 148.4,187.03 144.62,187.03 143.14,188.51 143.14,189.79 140.89,192.04 135.98,192.04 135.23,192.78 120.25,192.78 118.12,190.65 112.56,190.65 111.31,191.9 111.31,194.2 112.08,194.53 112.75,195.02
GND on BOTTOM (solid shape): 8.07,96.45 9.74,96.45 9.75,96.44 13.68,96.44 15.49,94.62 15.49,89.29 11.71,85.51 9.48,85.51 9.39,85.57 9.4,85.67 8,88.28 6.6,85.67 6.61,85.57 6.52,85.51 5.06,85.51 3.72,86.86 3.72,97.09 4.51,97.09 4.87,97.16 5.18,97.35 7.17,97.35
GND on BOTTOM (solid shape): outline of 106 points within 159.62,50.13 163.05,56.57
GND on BOTTOM (solid shape): outline of 111 points within 45.34,70.66 63.76,95.12
GND on BOTTOM (solid shape): outline of 156 points within 40.57,51.94 53.62,69.94
GND on BOTTOM (solid shape): 128.17,108.32 128.17,108.04 127.91,107.78 127.91,107.33 127.93,107.29 127.96,107.26 128,107.17 127.97,107.08 127.95,107.06 127.9,107.04 127.85,107.06 126.81,106.72 127.81,106.27 127.9,106.31 127.99,106.27 128.03,106.23 128.05,106.19 128.03,106.14 127.81,105.72 127.98,105.28 128.02,105.19 127.98,105.1 127.95,105.06 127.9,105.04 127.85,105.06 127.43,105.27 126.99,105.1 126.9,105.07 126.81,105.1 126.77,105.14 126.75,105.19 126.77,105.23 126.98,105.78 126.62,106.23 125.53,106.23 125.06,106.7 125.06,107.01 125.11,107.11 125.22,107.13 125.4,107.1 125.58,107.13 125.68,107.23 125.68,107.41 125.71,107.43 126.06,107.43 126.34,107.16 126.64,107.16 126.84,107.3 126.96,107.51 126.96,107.56 127.79,108.4 128.1,108.4
GND on BOTTOM (solid shape): outline of 193 points within 103.98,94.5 108.09,104.83
GND on BOTTOM (solid shape): outline of 118 points within 157.67,99.93 165.51,101.94
GND on BOTTOM (solid shape): outline of 294 points within 111.75,94.43 115.96,104.85
GND on BOTTOM (solid shape): outline of 322 points within 153.2,108.96 157.28,112.55
GND on BOTTOM (solid shape): outline of 393 points within 185.99,65.68 202.12,195.52
GND on BOTTOM (solid shape): outline of 86 points within 3.72,111.62 106.51,194.07
GND on BOTTOM (solid shape): outline of 558 points within 153.28,103.87 160.11,109.32
GND on BOTTOM (solid shape): outline of 174 points within 1.86,0.51 198.14,27.12
GND on BOTTOM (solid shape): outline of 979 points within 163.24,102.51 171.19,112.04
GND on SVCC (solid shape): 156.17,96.64 156.17,96.41 155.78,96.02 155.09,96.02 155.02,96 154.96,95.96 154.13,95.13 153.14,95.13 153,95.27 153,96.51 153.4,96.91 155.9,96.91
GND on SVCC (solid shape): 57.56,32.35 57.56,29.62 57.55,29.53 57.56,29.44 57.56,28.5 56.44,27.37 52.95,27.37 52.78,27.41 52.61,27.37 52.33,27.37 51.21,28.5 51.21,32.6 52.08,33.47 56.44,33.47
GND on SVCC (solid shape): 155.86,99.66 155.86,98.98 155.5,98.62 152.43,98.62 152.33,98.6 152.25,98.55 149.27,95.57 146.95,95.57 146.84,95.68 146.84,98.77 146.9,98.83 146.94,98.87 151.15,98.87 151.25,98.89 151.34,98.95 151.64,99.26 153.18,99.26 153.28,99.27 153.37,99.33 154.06,100.02 155.5,100.02
GND on SVCC (solid shape): 176.61,120.08 176.71,120.07 176.81,120.08 177.33,120.08 177.4,120.08 177.47,120.08 183.33,120.08 184.56,118.86 184.56,118.57 184.56,113.52 184.56,113.08 184.56,110.3 184.56,105.52 184.56,105.28 184.59,105.05 184.71,104.87 186.08,103.49 186.08,103.17 185.9,102.99 185.88,102.97 185.86,102.94 184.41,102.94 183.21,104.13 183.13,104.19 183.03,104.21 181.74,104.21 181.18,104.77 181.1,104.83 181,104.84 177.55,104.84 177.51,104.89 177.51,105.36 177.07,105.5 177.07,110.3 177.05,110.4 176.99,110.48 175.85,111.63 175.76,111.68 175.66,111.7 170.66,111.7 170.54,112.13 170.1,112.17 169.96,112.31 169.93,112.35 169.88,112.39 169.19,113.08 169.19,113.1 169.19,113.48 169.19,113.52 173.97,118.31 174.38,118.35 174.53,118.74 175.88,120.08
GND on SVCC (solid shape): outline of 967 points within 62.38,36.77 173.64,179.27
GND on SVCC (solid shape): outline of 1114 points within 162.08,3.73 200.6,120.08
GND on SVCC (solid shape): outline of 2736 points within 3.6,2.03 139.3,116.14
GND on IN1 (solid shape): 198.14,29.44 197.95,29.25 197.29,29.25 197.16,29.38 197.16,58.11 197.29,58.24 198.14,58.24
GND on IN1 (solid shape): 55.22,85.08 55.22,81.73 54.79,81.3 53.22,81.3 53.06,81.45 53.06,85.21 53.22,85.36 54.94,85.36
GND on IN1 (solid shape): 57.89,93.97 57.89,90.62 57.46,90.19 55.88,90.19 55.73,90.34 55.73,94.1 55.88,94.25 57.61,94.25
GND on IN1 (solid shape): 187.93,173.03 187.93,171.84 187.58,171.49 184.31,171.49 183.95,171.85 183.95,173.4 184.18,173.63 187.33,173.63
GND on IN1 (solid shape): 113.12,167.09 113.12,139.98 112.88,139.74 111.82,139.74 110.37,141.19 110.37,166.95 110.88,167.46 112.75,167.46
GND on IN1 (solid shape): 22.4,99.51 22.4,95.67 21.87,95.14 20.3,95.14 19.48,95.96 19.48,99.26 20.5,100.27 21.64,100.27
GND on IN1 (solid shape): 155.07,178.88 155.07,175.46 154.92,175.3 152.17,175.3 150.75,176.72 150.75,177.56 150.9,177.72 150.9,179.04 150.98,179.11 154.84,179.11
GND on IN1 (solid shape): 15.17,30.22 15.17,29.18 14.89,28.9 12.98,28.9 12.68,28.59 11.61,28.59 11.44,28.77 11.54,29.03 11.58,29.3 11.58,30.07 12.01,30.5 14.89,30.5
GND on IN1 (solid shape): 9.56,28.79 9.59,28.79 9.61,28.77 9.64,28.7 9.64,28.62 9.59,28.57 5.9,28.57 4.93,27.6 2.38,27.6 2.08,27.91 2.08,28.59 2.28,28.79
GND on IN1 (solid shape): 16.89,69.56 16.89,58.21 12.98,54.3 12.98,48.61 14.28,47.31 16.82,47.31 17.06,47.07 17.06,46.26 16.82,46.02 14.96,46.02 14.58,45.64 14.58,43.67 15.06,43.19 15.06,42.18 14.7,41.83 12.16,41.83 11.58,42.41 11.58,42.9 10.8,43.92 9.61,43.43 9.59,43.41 9.56,43.41 2.28,43.41 2.08,43.61 2.08,46.65 2.08,46.65 2.08,47.24 7.27,47.24 8.58,46.89 9.36,48 9.36,49.67 9.74,50.06 11.59,50.06 12.45,50.92 12.45,55.14 14.05,56.74 14.05,60.32 12.88,61.49 9.99,61.49 9.36,62.12 9.36,63.2 8.58,64.31 7.27,63.96 1.11,63.96 1.11,64.51 1.11,65.04 1.31,65.25 2.53,65.25 3.02,65.33 3.46,65.56 8.52,65.56 10.93,67.97 11.64,68.27 11.94,68.98 11.94,69.42 11.95,69.46 11.99,69.47 12.28,69.47 12.92,69.66 13.39,70.18 13.42,70.19 16.27,70.19
GND on IN1 (solid shape): outline of 297 points within 186.25,60.74 202.12,195.52
GND on IN1 (solid shape): outline of 637 points within 3.72,86.33 174.32,195.52
GND on IN1 (solid shape): outline of 181 points within 1.78,0.51 198.14,26.76
GND on IN2 (solid shape): 22.28,99.56 22.28,95.8 21.59,95.12 20.32,95.12 19.56,95.88 19.56,99.43 20.45,100.32 21.52,100.32
GND on IN2 (solid shape): 55.22,85.08 55.22,81.73 54.79,81.3 53.22,81.3 53.06,81.45 53.06,85.21 53.22,85.36 54.94,85.36
GND on IN2 (solid shape): 57.89,93.97 57.89,90.62 57.46,90.19 55.88,90.19 55.73,90.34 55.73,94.1 55.88,94.25 57.61,94.25
GND on IN2 (solid shape): 187.84,173.17 187.84,172.2 187.57,171.94 183.88,171.94 183.87,171.95 183.87,173.25 184.28,173.65 187.35,173.65
GND on IN2 (solid shape): 198.14,58.01 198.14,29.51 198.03,29.4 197.73,29.4 197.57,29.56 197.57,57.96 197.67,58.06 198.09,58.06
GND on IN2 (solid shape): 159.67,120.96 159.67,120.95 160.05,120.57 160.05,119.98 158.96,118.89 156.56,118.89 155.53,119.92 155.53,120.72 155.02,121.23 155.02,121.4 155.17,121.56 159.07,121.56
GND on IN2 (solid shape): 155.09,178.78 155.09,175.23 154.92,175.05 152.46,175.05 151.44,176.07 151.04,176.07 150.98,176.3 150.8,176.46 150.78,176.46 150.75,176.51 150.75,177.51 150.98,177.74 150.98,178.86 151.01,178.89 151.03,178.89 151.06,178.91 154.97,178.91
GND on IN2 (solid shape): 15.22,30.19 15.22,29.12 14.58,28.48 13.5,28.48 13.48,28.43 12.44,27.39 2.08,27.39 2.08,28.59 2.28,28.79 9.56,28.79 9.59,28.79 9.61,28.77 10.8,28.28 11.58,29.3 11.58,29.98 12.27,30.68 14,30.68 14.03,30.7 14.71,30.7
GND on IN2 (solid shape): 13.81,48.08 13.81,44.02 15,42.83 15,42.42 14.48,41.9 12.11,41.9 11.58,42.44 11.58,42.9 10.8,43.92 9.61,43.43 9.59,43.41 9.56,43.41 2.28,43.41 2.08,43.61 2.08,46.65 2.08,46.65 2.08,47.24 7.27,47.24 8.58,46.89 9.36,48 9.36,48.65 9.86,49.15 12.74,49.15
GND on IN2 (solid shape): 16.72,69.5 16.72,66.13 18.19,64.66 18.19,63.54 17.28,62.63 9.91,62.63 9.36,63.19 9.36,63.2 8.58,64.31 7.27,63.96 1.11,63.96 1.11,64.51 1.11,65.04 1.31,65.25 2.53,65.25 3.3,65.46 3.85,66.03 8.65,66.03 10.6,67.97 10.93,67.97 11.64,68.27 11.94,68.98 11.94,69.42 11.95,69.46 11.99,69.47 12.28,69.47 12.99,69.7 13.45,70.33 13.48,70.34 15.88,70.34
GND on IN2 (solid shape): outline of 433 points within 186.3,60.47 202.12,195.52
GND on IN2 (solid shape): outline of 729 points within 3.72,86.33 174.09,195.52
GND on IN2 (solid shape): outline of 724 points within 1.62,0.51 198.14,26.7
GND on IN2 (solid shape): outline of 1031 points within 101.34,94.61 121.27,103.2
GND on SGND (solid shape): outline of 2763 points within 1.11,0.51 202.12,195.52
VCC_XD on BOTTOM (solid shape): 35.03,15.94 35.03,15.39 34.7,15.06 33.13,15.06 32.36,14.29 32.03,14.29 31.98,14.34 31.98,15.59 32.57,16.17 34.8,16.17
VDD10 on TOP (solid shape): 30.13,95.97 30.13,95.7 29.98,95.55 29.37,95.55 29.22,95.7 29.22,96.67 29.28,96.73 29.38,96.73
VDD10 on BOTTOM (solid shape): 29.26,101.54 29.26,100.58 29.25,100.54 29.21,100.53 26.09,100.53 25.96,100.4 25.96,97.1 26.76,96.3 26.76,96.29 26.82,96.2 26.91,96.14 26.92,96.14 26.98,96.08 28.55,96.08 28.63,96.08 29.01,96.46 29.41,96.46 29.54,96.34 29.54,96.33 30,95.87 30,95.71 29.52,95.22 28.08,95.22 27.85,94.99 27.68,94.94 27.52,94.85 27.49,94.85 27.46,94.86 27.06,95.04 26.62,94.99 24.73,96.88 24.73,97.09 24.46,97.35 24.46,101.62 24.64,101.8 29.01,101.8
VDDREG/VDD33 on TOP (solid shape): 27.66,102.35 27.66,102.08 27.51,101.92 27.21,101.92 27.01,101.72 27.01,99.97 26.99,99.95 26.84,99.95 26.82,99.97 26.82,101.97 27,102.15 27,102.43 27.08,102.51 27.51,102.51
VDDREG/VDD33 on BOTTOM (solid shape): 32.44,103.62 32.44,102.79 32.41,102.76 32.41,102.61 32.24,102.43 30.46,102.43 30.08,102.05 27.15,102.05 27.12,102.06 27.1,102.1 27.1,103.07 27.23,103.19 28.25,103.19 28.63,103.57 29.52,103.57 29.98,104.03 32.03,104.03
VIN on TOP (solid shape): 49.25,83.97 49.25,80.08 49.18,80 44.05,80 43.61,80.43 43.61,84.47 44.25,85.11 48.11,85.11
VIN on TOP (solid shape): 103.28,141.67 103.28,139.65 103.02,139.39 98.71,139.39 97.18,140.91 97.18,142.94 97.56,143.33 97.56,144.01 97.66,144.27 97.75,144.53 98.07,144.85 100.1,144.85
VIN on TOP (solid shape): 40.36,110.86 40.36,109.87 40.14,109.64 38.74,109.64 38.21,109.11 38.21,108.15 37.98,107.92 36.07,107.92 35.67,108.32 35.67,110.81 36.09,111.23 39.99,111.23
VIN on TOP (solid shape): 140.64,189.81 140.64,186.88 140.35,186.58 137.75,186.58 136.88,185.71 133.59,185.71 133.35,185.95 133.35,186.81 132.9,187.27 132.9,189.98 133.1,190.19 140.26,190.19
VIN on TOP (solid shape): 168.99,184.32 170.9,184.32 171.71,183.51 172.99,183.51 173.09,183.4 173.09,182.52 172.99,182.42 165.1,182.42 164.89,182.63 164.89,184.66 165.04,184.81 168.5,184.81
VIN on TOP (solid shape): 195.3,133.06 195.3,132.1 196.9,130.5 196.9,129.66 196.57,129.33 196.57,127.81 196.42,127.65 187.7,127.65 187.6,127.76 187.6,132.14 187.73,132.28 190.4,132.28 190.73,132.61 190.73,133.14 190.94,133.34 195.03,133.34
VIN on TOP (solid shape): 198.25,179.14 198.25,176.91 198.01,176.68 197.51,176.68 197.06,176.22 194.9,176.22 194.67,176.45 194.67,177.67 194.31,178.02 193.53,178.02 193.16,178.39 193.16,178.8 193.7,179.34 198.04,179.34
VIN on TOP (solid shape): 186.49,149.98 186.49,146.93 186.9,146.53 190.66,146.53 190.89,146.3 192.97,146.3 193.12,146.14 193.12,145.15 192.52,144.56 189.2,144.56 189.19,144.57 181.97,144.57 181.84,144.44 172.67,144.44 172.47,144.64 172.47,146.13 172.69,146.35 180.29,146.35 181.12,147.17 181.12,148.32 181.11,148.33 181.11,150.11 181.46,150.46 186.01,150.46
VIN on TOP (solid shape): 182.07,187.44 182.07,182.01 181.79,181.73 180.84,181.73 180.65,181.78 180.45,181.73 180.14,181.73 179.87,181.88 179.58,181.78 179.51,181.75 179.44,181.78 179.39,181.82 179.32,181.85 179.28,181.9 179.28,185.9 179.3,185.92 180.7,185.92 180.98,186.2 180.98,187.6 181.16,187.78 181.74,187.78
VIN on TOP (solid shape): 73.22,112.1 73.22,110.03 69.88,106.69 61.14,106.69 60.73,107.1 60.73,108.48 60.76,108.49 60.99,108.84 60.76,109.19 60.73,109.21 60.73,110.31 61.28,110.86 61.31,110.85 64.11,111.38 66.43,113.04 66.56,113.19 66.7,113.35 67.69,114.35 70.97,114.35
VIN on TOP (solid shape): 44.17,47.14 44.17,45.46 44.5,45.13 55.95,45.13 56.34,44.74 56.34,42.13 56.01,41.8 51.06,41.8 50.98,41.73 50.98,41.27 50.58,40.86 40.74,40.86 39.8,41.8 39.8,44.29 51.59,44.29 51.59,44.23 51.61,44.17 51.63,44.12 51.65,44.07 51.69,44.02 51.73,43.97 51.77,43.94 51.82,43.91 51.88,43.88 51.94,43.87 51.99,43.86 52.05,43.86 52.11,43.87 52.17,43.88 52.22,43.91 52.27,43.94 52.32,43.97 52.36,44.02 52.39,44.07 52.42,44.12 52.44,44.17 52.45,44.23 52.46,44.29 52.45,44.35 52.44,44.41 52.42,44.46 52.39,44.52 52.36,44.56 52.32,44.61 52.27,44.64 52.22,44.67 52.17,44.7 52.11,44.71 52.05,44.72 51.99,44.72 51.94,44.71 51.88,44.7 51.82,44.67 51.77,44.64 51.73,44.61 51.69,44.56 51.65,44.52 51.63,44.46 51.61,44.41 51.59,44.35 51.59,44.29 39.8,44.29 39.8,47.14 40.01,47.34 43.97,47.34
VIN on BOTTOM (solid shape): 123.78,18.94 123.78,17.73 123.52,17.47 120.42,17.47 120.25,17.64 120.25,18.97 120.42,19.14 123.58,19.14
VIN on BOTTOM (solid shape): 103.28,141.67 103.28,139.39 103.36,139.31 103.36,136.87 102.98,136.49 98.23,136.49 97.98,136.74 97.98,140.11 97.18,140.91 97.18,142.94 97.56,143.33 97.56,144.01 97.66,144.27 97.75,144.53 98.07,144.85 100.1,144.85
VIN on BOTTOM (solid shape): 109.73,166.41 109.73,165.19 109.96,164.97 111.96,164.97 112.09,164.84 112.09,162.71 112.04,162.65 111.15,162.65 111.05,162.55 111.05,161.92 110.92,161.79 109.35,161.79 109.15,161.99 109.15,163.67 107.75,165.06 107.75,166.44 108.26,166.95 109.2,166.95
VIN on BOTTOM (solid shape): 48.54,84.36 48.54,80.17 48.37,80 46.13,80 45.14,79.01 45.14,74.9 45.98,74.06 48.21,74.06 48.31,73.97 48.31,70.6 48.15,70.44 45.28,70.44 45.27,70.43 42.35,70.43 41.23,71.54 41.23,71.57 40.09,72.71 40.09,75.18 40.08,75.18 40.08,80.94 42.72,83.58 42.81,83.64 42.87,83.73 44,84.86 48.04,84.86
VIN on BOTTOM (solid shape): 186.49,149.98 186.49,147.47 186.86,147.1 193.76,147.1 194.16,146.7 194.16,141.39 193.47,140.71 191.57,140.71 191.24,141.04 191.24,141.85 190.73,142.36 188.35,142.36 188.11,142.59 188.11,144.19 187.73,144.57 179.43,144.57 179.25,144.39 179.25,142.99 177.73,141.47 174.4,141.47 173.31,142.56 173.31,146.93 173.99,147.62 180.32,147.62 180.85,148.15 180.85,150.06 181.26,150.46 186.01,150.46
VIN on BOTTOM (solid shape): 73.19,113.6 73.19,110.02 69.73,106.56 63.43,106.56 61.27,108.72 61.27,110.55 61.57,110.85 64.42,111.53 66.7,113.35 66.71,113.35 67.73,114.38 72.4,114.38
VIN on BOTTOM (solid shape): 45.21,49.88 46.99,49.88 47.3,49.57 47.3,45.38 47.57,45.12 48.84,45.12 49.06,44.89 55.82,44.89 56.36,44.34 56.36,42.21 56.03,41.88 51.13,41.88 50.98,41.73 50.98,40.76 50.83,40.61 48.49,40.61 48.24,40.86 40.74,40.86 39.8,41.8 39.8,44.57 51.54,44.57 51.54,43.15 51.61,43.07 51.61,43.02 51.66,43.02 51.66,43.02 52.38,43.02 52.38,43.02 52.53,43.02 52.53,44.55 52.33,44.75 51.71,44.75 51.54,44.57 39.8,44.57 39.8,47.14 39.81,47.14 39.81,50.9 40.21,51.3 43.79,51.3
VIN on SVCC (solid shape): outline of 466 points within 37.75,66.74 66.45,114.57
VIN on SVCC (solid shape): outline of 811 points within 95.68,121.1 199.04,193.99
VIN on IN2 (solid shape): outline of 969 points within 32.48,40.15 47.05,85.35
1.5GFX_DRVH on TOP (solid shape): 137.06,185.08 137.06,184.35 136.98,184.27 135.94,184.27 135.84,184.37 135.84,185.11 135.92,185.18 136.96,185.18
1.5GFX_DRVH on TOP (solid shape): 127.46,190.54 127.46,190.52 127.49,190.52 127.51,190.49 127.51,190.09 127.34,189.92 126.39,189.92 126.38,189.91 126.13,189.91 126.1,189.94 125.27,189.94 125.25,189.96 125.25,190.16 125.3,190.21 126.12,190.21 126.21,190.31 126.23,190.31 126.23,190.33 126.51,190.61 127.4,190.61
1.5GFX_DRVL on TOP (solid shape): 126.29,188.54 126.29,187.75 126.09,187.55 125.4,187.55 125.2,187.75 125.2,188.66 125.25,188.71 126.12,188.71
1.5GFX_DRVL on TOP (solid shape): 129.77,188.61 129.77,187.37 129.7,187.29 128.83,187.29 128.63,187.5 128.63,188.59 128.76,188.71 129.67,188.71
1.5GFX_SW on TOP (solid shape): 128.83,189.94 128.83,189.37 128.38,188.92 128.38,187.39 129.04,186.73 132.54,186.73 132.71,186.57 132.71,185.73 133.2,185.24 135.44,185.24 135.66,185.01 135.66,181.25 135.56,181.14 128.53,181.14 127.69,181.98 127.69,188.44 127.69,188.44 127.69,189.27 127.54,189.43 126.1,189.43 126.1,189.44 125.3,189.44 125.26,189.45 125.25,189.49 125.25,189.65 125.26,189.69 125.3,189.71 126.24,189.71 126.26,189.72 127.34,189.72 127.77,190.14 128.63,190.14
1.5GFX_SW on BOTTOM (solid shape): 135.66,185.69 135.66,181.25 135.56,181.14 129.67,181.14 129.59,181.22 129.59,182.26 129.82,182.49 130.61,182.49 130.89,182.77 130.89,185.51 131.14,185.77 135.59,185.77
1.5GFX_VBST on TOP (solid shape): 128.53,191.51 128.56,191.5 128.58,191.46 128.58,190.72 128.56,190.69 128.53,190.67 127.51,190.67 127.45,190.73 126.38,190.73 126.12,190.47 125.3,190.47 125.26,190.51 125.26,190.99 125.25,191 125.25,191.2 125.56,191.51
1658R-BOOT1 on BOTTOM (solid shape): 188.29,141.55 188.29,141.04 188.12,140.86 187.1,140.86 186.71,140.47 185.67,140.47 185.6,140.53 185.6,140.84 186.52,141.75 188.09,141.75
1658R-BOOT2 on BOTTOM (solid shape): 183.44,140.71 183.44,140.53 183.39,140.48 182.4,140.48 181.82,141.06 180.85,141.06 180.8,141.12 180.8,141.85 180.9,141.95 182.2,141.95
1658R-LGATE1 on BOTTOM (solid shape): 188.47,156.28 188.47,154.47 188.32,154.32 187.3,154.32 187.17,154.45 187.17,156.33 187.25,156.41 188.34,156.41
1658R-LGATE1 on BOTTOM (solid shape): 186.47,142.99 186.47,142.66 186.11,142.31 185.35,142.31 185.04,142 185.04,141.86 185.03,141.86 185.03,140.88 185.02,140.86 184.86,140.86 184.84,140.89 184.84,142.66 185.32,143.15 186.31,143.15
1658R-LGATE2 on BOTTOM (solid shape): 179.58,151.71 179.58,150.41 179.48,150.31 178.59,150.31 178.26,150.64 178.26,151.76 178.36,151.86 179.43,151.86
1658R-LGATE2 on BOTTOM (solid shape): 184.23,142.59 184.23,140.91 184.2,140.89 184.05,140.89 184.03,140.91 184.03,141.86 184.02,141.86 184.02,141.95 183.89,142.09 183.56,142.09 183.21,142.44 183.21,142.83 183.38,142.99 183.82,142.99
1658R-PHASE1 on BOTTOM (solid shape): 186.31,142.06 186.31,141.78 185.4,140.86 185.27,140.86 185.23,140.9 185.23,141.86 185.22,141.86 185.22,141.98 185.35,142.11 186.26,142.11
1658R-PHASE1 on BOTTOM (solid shape): 194.85,159.91 194.85,151.43 193.81,150.39 192.41,150.39 192.14,150.12 192.14,148.11 192.05,148.02 188.98,148.02 188.85,148.15 188.85,149.93 189.38,150.46 189.38,156.38 189.03,156.73 189.03,160.63 189.71,161.31 193.45,161.31
1658R-PHASE2 on BOTTOM (solid shape): 183.21,142.18 183.21,142.18 183.49,141.9 183.75,141.9 183.82,141.83 183.82,140.91 183.8,140.89 183.49,140.89 182.58,141.8 182.55,141.8 182.04,142.31 180.7,142.31 180.52,142.49 180.52,142.97 180.72,143.17 182.22,143.17
1658R-PHASE2 on BOTTOM (solid shape): 177.31,161.12 177.31,149.84 177.2,149.73 177.2,148.77 176.96,148.53 175.92,148.53 175.91,148.53 175.77,148.56 175.63,148.53 175.62,148.53 172.8,148.53 172.42,148.91 172.42,161.08 172.75,161.41 177.02,161.41
1658R-PVCC on BOTTOM (solid shape): 184.79,144.19 184.79,142.99 184.64,142.84 184.64,141.86 184.63,141.86 184.63,140.93 184.59,140.89 184.48,140.89 184.43,140.94 184.43,141.86 184.41,141.89 184.41,142.64 183.82,143.22 183.06,143.22 182.78,143.5 182.78,144.16 182.91,144.29 184.69,144.29
1658R-UGATE1 on BOTTOM (solid shape): 188.09,140.51 188.09,140.25 187.91,140.07 185.7,140.07 185.65,140.12 185.65,140.23 185.69,140.27 186.63,140.27 186.63,140.28 187.25,140.28 187.66,140.68 187.91,140.68
1658R-UGATE1 on BOTTOM (solid shape): 194.21,149.8 194.21,148.28 193.98,148.05 192.79,148.05 192.67,148.17 192.67,148.65 192.66,148.66 192.66,149.73 192.91,149.98 194.03,149.98
1658R-UGATE2 on BOTTOM (solid shape): 179.3,149.75 179.3,148.79 179.1,148.58 177.75,148.58 177.7,148.63 177.7,149.7 177.8,149.8 179.25,149.8
1658R-UGATE2 on BOTTOM (solid shape): 182.38,140.28 182.44,140.28 182.44,140.27 183.37,140.27 183.42,140.23 183.42,140.1 183.39,140.07 181.13,140.07 180.98,140.23 180.98,140.66 181.21,140.89 181.77,140.89
24707_LX on TOP (solid shape): 168.56,189.32 168.56,187.22 168.66,187.11 169.83,187.11 170.51,186.43 170.51,185.21 170.3,184.99 168.95,184.99 168.48,185.47 166.22,185.47 166.07,185.62 166.07,187.14 165.92,187.29 163.53,187.29 163.5,187.32 163.5,188.11 163.55,188.16 164.65,188.16 164.77,188.28 164.77,189.35 164.93,189.5 168.37,189.5
24707_LX on BOTTOM (solid shape): 163.86,186 163.86,185.49 163.75,185.37 163.39,185.37 163.05,185.72 161.47,185.72 161.32,185.87 161.32,186.12 161.57,186.38 163.48,186.38
24707_LX on BOTTOM (solid shape): 168.43,190.29 169.47,190.29 169.52,190.24 169.52,189.65 170.13,189.05 170.13,185.13 169.5,184.5 168.08,184.5 167.49,183.91 165.43,183.91 165.26,184.09 165.26,188.41 166.13,189.29 167.05,189.29 167.31,189.55 167.31,190.32 167.44,190.44 168.28,190.44
24737_BM# on BOTTOM (solid shape): 158.04,188.71 158.04,187.93 158.02,187.9 157.15,187.9 156.77,188.28 156.77,188.69 156.85,188.77 157.99,188.77
24737_DH on TOP (solid shape): 165.89,186.35 165.89,185.44 165.87,185.41 165.05,185.41 164.39,186.07 164.39,186.48 164.6,186.68 165.56,186.68
24737_DH on BOTTOM (solid shape): 163.22,187.14 164.37,187.14 165,186.51 165,186.25 164.75,186 164.24,186 163.73,186.51 161.32,186.51 161.19,186.63 161.95,187.39 162.97,187.39
24737_DL on TOP (solid shape): 164.8,191.28 165.69,191.28 165.89,191.08 165.89,190.39 165.31,189.81 164.49,189.81 164.34,189.96 164.34,190.54 164.22,190.67 164.22,191.2 164.39,191.38 164.7,191.38
