# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DGPU_POK4: length 4.1
  TOP w0.127: Q7.2 164.86,158.93 C53.1 R33.1 163.51,156.7 v3(163.53,156.69)
DGPU_PRSNT: length 10.7
  BOTTOM w0.089: 158.25,87.61 158.98,87.61 R599.2 159.42,88.05 159.42,89.09 159.77,89.44 159.77,91.98 158.63,93.12 158.63,94.78 158.68,94.83 158.68,94.84 158.85,95.01 158.85,95.27 158.67,95.46 158.67,95.46 158.65,95.48 158.65,95.94 U24.AM3
  BOTTOM w0.102: R608.2 158.25,87.61
DGPU_PRSNT#_R: length 3.7
  TOP w0.102: R77.2 171.74,113.18 170.85,112.3 169.87,112.3 v3(169.65,112.07)
  BOTTOM w0.102: U24.F39 169.65,111.73 v3(169.65,112.07)
DGPU_PSI: length 69.6
  IN1 w0.133: v3(169.95,166.67) 170.67,165.95 170.67,157.71 170.44,157.48 170.44,141.04 171.23,140.25 176.12,140.25 176.21,140.33 178.69,140.33 179.52,139.5 179.52,139.28 180.61,138.19 188.87,138.19 189.41,138.73 v3(190.45,138.73)
  BOTTOM w0.127: U19.B4 155.4,168.65 156.03,168.65 156.19,168.8 156.19,169.31 156.31,169.44 157.63,169.44 158.93,168.14 159.77,168.14 160.13,167.79 v2(161.35,167.79) R408.1 163.65,167.33 166.05,167.33 166.19,167.47 167.26,167.47 167.65,167.09 169.54,167.09 v3(169.95,166.67) ; PR173.2 PR189.2 PR176.1 PR166.1 189.77,138.43 190.07,138.73 v3(190.45,138.73)
DGPU_PWM_SLT#: length 4
  BOTTOM w0.102: 174.92,98.72 172.81,98.72 172.81,98.72 172.77,98.76 172.39,98.76 172.08,99.07 171.76,99.07 171.66,99.17 U24.A10
  BOTTOM w0.127: TP106.1 174.92,98.72
DGPU_PWR_EN: length 87.2
  TOP w0.127: PR206.1 165.37,146.75 v2(166.07,146.04) 166.27,145.84 v3(168.28,145.84)
  IN1 w0.133: v3(168.28,145.84) 167.48,145.04 167.48,141.02 168.02,140.48 168.2,140.48 171.22,137.47 172.1,137.47 174.03,135.54 174.03,126.91 175.61,125.33 175.61,121.71 175.97,121.35 175.97,120.02 177.29,118.7 178.29,118.7 178.67,118.33 180.56,118.33 181.35,119.11 182.67,119.11 183.62,118.16 183.62,116.28 185.38,114.52 185.38,112.15 185.86,111.68 185.86,109.21 188.04,107.03 188.04,102.18 187.08,101.22 187.08,96.28 v3(186.73,95.93)
  BOTTOM w0.102: 174.54,99.28 174.39,99.13 173.53,99.13 173.09,99.57 171.9,99.57 171.79,99.68 171.38,99.68 171.17,99.88 170.71,99.88 U24.C12
  BOTTOM w0.127: 174.54,99.28 177.58,99.28 177.73,99.13 179.95,99.13 180.48,98.6 181.63,98.6 182.3,99.27 ; 182.3,99.27 RP7.8 ; 182.3,99.27 182.62,98.95 182.62,98.17 184.48,96.31 186.35,96.31 v3(186.73,95.93)
DGPU_PWROK: length 91.1
  TOP w0.127: v3(169.21,160.61) 169.52,160.92 Q6.3 169.52,161.92 169.96,162.36 R24.1 170.41,163.59 170.41,164.87 R23.2
  IN1 w0.133: v3(173.16,100.63) 177.38,100.63 178.7,101.95 178.7,103.39 180.6,105.29 180.6,105.93 180.15,106.38 180.15,106.69 180.5,107.04 181.76,107.04 184.03,109.31 184.03,110.64 182.31,112.36 182.31,113.14 181.48,113.97 181.48,116.34 180.04,117.78 178.34,117.78 177.97,118.16 176.99,118.16 175.42,119.73 175.42,121.02 174.99,121.45 174.99,125.08 172.98,127.09 172.98,128.37 170.67,130.67 169.43,130.67 167.21,132.89 167.21,145.43 168.91,147.14 168.91,149.24 168.03,150.13 168.03,157.39 168.99,158.36 168.99,160.39 v3(169.21,160.61)
  BOTTOM w0.102: 175.21,101.02 173.55,101.02 v3(173.16,100.63) 172.76,101.02 171.72,101.02 171.64,101.1 171.39,101.1 171.08,100.79 U24.C14
  BOTTOM w0.127: R529.1 176.84,101.67 176.19,101.02 175.21,101.02
DGPU_SELECT#: length 14.6
  BOTTOM w0.102: 174.16,100.73 174.07,100.73 173.52,100.18 172.19,100.18 171.89,100.49 171.14,100.49 U24.B13
  BOTTOM w0.127: RP7.7 182.93,100.26 182.63,100.56 180.85,100.56 180.65,100.76 180.65,101.57 180.37,101.85 TP103.1 179.73,101.49 179.2,100.96 176.63,100.96 176.4,100.73 174.16,100.73
DIMM0_SA0: length 3.8
  TOP w0.127: R323.1 135.2,46.73 135.92,46 v3(135.92,45.26)
  BOTTOM w0.127: v3(135.92,45.26) 135.92,45.34 135.25,46.01 JDIM2.197
DIMM0_SA1: length 3.9
  TOP w0.127: v3(136.64,45.04) 136.46,45.22 136.46,46.18 136.33,46.31 R325.1
  BOTTOM w0.127: JDIM2.201 136.45,45.22 v3(136.64,45.04)
DIMM1_SA0: length 3.9
  TOP w0.127: R297.1 136.46,58.3 135.78,57.62 v3(135.39,57.62)
  BOTTOM w0.127: JDIM1.197 135.25,58.87 135,58.61 135,58.02 v3(135.39,57.62)
DIMM1_SA1: length 5.5
  TOP w0.127: R302.1 135.9,55.64 135.46,56.07 v3(135.41,56.07)
  BOTTOM w0.127: v3(135.41,56.07) 135.41,56.07 136.45,57.12 JDIM1.201
DMI_IREF: length 3.9
  BOTTOM w0.254: U24.BE16 149.17,101.61 R531.2
DMI_RCOMP: length 1.5
  TOP w0.381: v3(154.62,101.69) 154.45,101.52 R138.1
  BOTTOM w0.254: v3(154.62,101.69) 154.62,101.99 U24.AY17
DMI_RXN0: length 34.2
  IN2 w0.089: v3(155.63,103.66) 155.39,103.9 155.39,104.08 155.22,104.26 154.25,104.26 152.6,102.61 152.6,102.3 152.07,101.77 148.53,101.77 148.34,101.96 145.96,101.96 145.49,102.43 145.3,102.43 145.3,102.44 145.26,102.48 145.24,102.48 ; v5(126.93,100.15) 127.17,99.92 127.26,99.92 127.35,100.01 127.35,101.4 127.69,101.75 131.62,101.75 131.65,101.78 131.68,101.78
  IN2 w0.133: 145.24,102.48 141.84,102.48 141.43,102.89 135.94,102.89 134.84,101.78 131.68,101.78
  BOTTOM w0.102: U24.AW22 155.42,103.87 v3(155.63,103.66)
  BOTTOM w0.114: v5(126.93,100.15) 126.92,100.15 126.86,100.15 U27.D18
DMI_RXN1: length 33.7
  IN2 w0.089: v5(127.93,99.15) 127.93,99.63 128.03,99.73 128.25,99.73 128.52,100 128.52,100.41 128.68,100.57 131.62,100.57 131.65,100.53 131.68,100.53 ; v3(156.96,102.68) 156.96,102.69 156.58,103.08 156.55,103.08 154.77,103.08 154.73,103.12 153.98,103.12 153.19,102.33 153.19,101.95 152.38,101.14 147.98,101.14 147.91,101.21 145.26,101.21 145.24,101.19
  IN2 w0.133: 131.68,100.53 135.31,100.53 136.3,101.52 140.85,101.52 141.18,101.19 145.24,101.19
  BOTTOM w0.102: v3(156.96,102.68) 157.21,102.93 U24.AR20
  BOTTOM w0.114: U27.C17 127.4,99.09 127.61,99.31 127.78,99.31 v5(127.93,99.15)
DMI_RXN2: length 33.1
  IN2 w0.089: v3(128.93,99.15) 128.93,99.45 128.99,99.51 129.22,99.51 129.34,99.39 129.34,98.88 129.64,98.57 131.45,98.57 131.49,98.53 131.51,98.53 ; v3(158.26,101.72) 158.05,101.5 158.05,101.45 157.73,101.13 156.2,101.13 156.19,101.12 155.83,101.12 155.83,101.12 155.5,101.12 155.49,101.12 154.21,101.12 153.31,100.22 149.1,100.22 148.61,99.73 148.61,99.67
  IN2 w0.133: 148.61,99.67 148.11,99.18 141.59,99.18 140.94,98.53 131.51,98.53
  BOTTOM w0.102: U24.AP17 157.81,102.17 v3(158.26,101.72)
  BOTTOM w0.114: U27.B17 128.46,98.69 v3(128.93,99.15)
DMI_RXN3: length 29
  IN2 w0.089: v5(129.93,99.15) 130.34,99.57 131.62,99.57 131.65,99.53 131.68,99.53 ; v3(155.66,102.68) 155.66,102.55 155.39,102.28 154.7,102.28 154.52,102.1 154.37,102.1 152.98,100.71 148.53,100.71 148.06,100.25 147.61,100.25 147.56,100.2
  IN2 w0.133: 147.56,100.2 140.82,100.2 140.44,100.58 136.81,100.58 135.76,99.53 131.68,99.53
  BOTTOM w0.102: U24.AV20 155.66,102.81 v3(155.66,102.68)
  BOTTOM w0.114: v5(129.93,99.15) 129.46,98.69 U27.A17
DMI_RXP0: length 34.2
  IN2 w0.089: v3(126.93,99.15) 126.93,99.51 127.16,99.74 127.33,99.74 127.52,99.93 127.52,101.33 127.76,101.57 131.62,101.57 131.65,101.53 131.68,101.53 ; v3(154.98,103.66) 155.21,103.88 155.21,104.01 155.14,104.08 154.33,104.08 152.78,102.53 152.78,102.22 152.15,101.59 148.46,101.59 148.27,101.78 145.89,101.78 145.42,102.25 145.28,102.25 145.25,102.23 145.24,102.23
  IN2 w0.133: 145.24,102.23 141.73,102.23 141.33,102.63 136.05,102.63 135.02,101.6 134.94,101.53 131.68,101.53
  BOTTOM w0.102: v3(154.98,103.66) 154.98,103.99 U24.AY22
  BOTTOM w0.114: v3(126.93,99.15) 126.46,98.69 U27.D17
DMI_RXP1: length 33.7
  IN2 w0.089: v3(127.93,100.15) 127.93,100.02 128.04,99.91 128.18,99.91 128.34,100.07 128.34,100.48 128.6,100.75 131.62,100.75 131.65,100.78 131.68,100.78 ; v3(157.62,102.67) 157.17,103.12 156.79,103.12 156.65,103.25 156.58,103.25 156.56,103.26 154.85,103.26 154.81,103.29 153.9,103.29 153.01,102.4 153.01,102.02 152.3,101.31 148.06,101.31 147.98,101.39 145.29,101.39 145.24,101.44
  IN2 w0.133: 131.68,100.78 135.21,100.78 136.19,101.77 140.95,101.77 141.28,101.44 145.24,101.44
  BOTTOM w0.102: v3(157.62,102.67) 157.62,102.97 U24.AP20
  BOTTOM w0.114: v3(127.93,100.15) 127.46,99.69 U27.C18
DMI_RXP2: length 33.1
  IN2 w0.089: 131.51,98.79 131.49,98.79 131.45,98.75 129.72,98.75 129.52,98.95 129.52,99.46 129.29,99.69 129.01,99.69 128.93,99.77 v5(128.93,100.15) ; 148.43,99.85 148.48,99.85 149.03,100.4 153.24,100.4 154.13,101.29 155.42,101.29 155.42,101.3 155.9,101.3 155.91,101.3 157.65,101.3 157.84,101.49 157.84,101.64 157.76,101.73 v3(157.46,101.73)
  IN2 w0.133: 131.51,98.79 140.83,98.79 141.48,99.43 148.01,99.43 148.43,99.85
  BOTTOM w0.102: v3(157.46,101.73) 157.46,102.09 157.36,102.19 U24.AR17
  BOTTOM w0.114: v5(128.93,100.15) 128.46,99.69 U27.B18
DMI_RXP3: length 29
  IN2 w0.089: v3(155.01,102.68) 154.8,102.47 154.64,102.47 154.44,102.28 154.29,102.28 152.91,100.89 148.46,100.89 147.99,100.42 147.55,100.42 147.52,100.45 ; 131.68,99.78 131.65,99.78 131.62,99.74 130.02,99.74 129.93,99.84 v3(129.93,100.15)
  IN2 w0.133: 131.68,99.78 135.65,99.78 136.7,100.83 140.55,100.83 140.93,100.45 147.52,100.45
  BOTTOM w0.102: U24.AW20 155.26,103.17 155.01,102.92 v3(155.01,102.68)
  BOTTOM w0.127: v3(129.93,100.15) 130.08,100.01 130.08,99.86 129.75,99.54 129.55,99.54 U27.A18
DMI_TXN0: length 34.7
  IN2 w0.089: 131.02,105.75 130.99,105.71 130.39,105.71 130.03,105.35 127.37,105.35 126.34,104.33 126.34,102.83 126.12,102.61 125.99,102.61 125.93,102.67 v5(125.93,103.15)
  IN2 w0.133: 131.02,105.75 131.03,105.75 133.06,105.75 134.62,107.31 134.92,107.61 146.92,107.61 148.62,105.91 149.79,105.91 150.42,105.28 150.42,104.76 v3(150.69,104.49)
  BOTTOM w0.079: 152.54,103.7 152.56,103.7 152.57,103.69 153.27,103.69 U24.BD21
  BOTTOM w0.089: 152.54,103.7 152.35,103.7 152.25,103.8 150.78,103.8 150.29,104.29 150.29,104.39 150.39,104.49 v3(150.69,104.49)
  BOTTOM w0.114: v5(125.93,103.15) 125.84,103.06 125.84,102.86 126.01,102.69 U27.D21
DMI_TXN1: length 33.1
  IN2 w0.089: v3(127.93,103.15) 127.93,102.8 127.84,102.71 127.63,102.71 127.52,102.81 127.52,104.29 127.86,104.63 131.62,104.63 131.65,104.59 131.68,104.59
  IN2 w0.102: v3(148.7,104.4) 148.28,103.98 147.71,103.98 147.58,104.11 147.58,104.25 147.38,104.45 147.38,104.89 147.36,104.91 147.36,104.95 147.33,104.98 147.33,105
  IN2 w0.133: 147.33,105 147.33,105.5 146.41,106.42 141.87,106.42 141.41,105.96 135.38,105.96 134.01,104.59 131.68,104.59
  BOTTOM w0.089: U24.BE20 152.89,103.18 152.81,103.1 152.38,103.1 152.07,103.41 150.55,103.41 150.23,103.73 148.62,103.73 148.37,103.99 148.37,104.32 148.45,104.4 v3(148.7,104.4)
  BOTTOM w0.114: v3(127.93,103.15) 128.03,103.06 128.03,102.8 127.76,102.53 127.55,102.53 U27.C21
DMI_TXN2: length 30.3
  IN2 w0.089: v5(128.93,103.15) 128.93,102.69 129.04,102.58 129.18,102.58 129.34,102.74 129.34,103.49 129.59,103.74 131.62,103.74 131.66,103.78 131.68,103.78
  IN2 w0.102: 147.15,104.07 147.16,104.05 147.16,104.01 147.43,103.75 149.11,103.75 149.64,103.23 149.64,102.79 149.71,102.71 v3(149.97,102.71)
  IN2 w0.133: 147.15,104.07 146.73,104.48 146.73,104.72 145.72,105.73 144.7,105.73 144.35,105.38 142.99,105.38 142.88,105.28 135.68,105.28 135.06,104.65 134.51,104.1 134.18,103.78 131.68,103.78
  BOTTOM w0.079: 153.06,102.1 153.24,102.1 U24.BD17
  BOTTOM w0.089: 153.06,102.1 149.94,102.1 149.71,102.33 149.71,102.45 v3(149.97,102.71)
  BOTTOM w0.114: v5(128.93,103.15) 128.93,102.72 128.83,102.61 128.47,102.61 U27.B21
DMI_TXN3: length 26.9
  IN2 w0.089: v3(129.93,103.15) 129.93,102.86 130.04,102.74 131.62,102.74 131.65,102.78 131.68,102.78
  IN2 w0.102: v3(151.27,102.73) 151.47,102.73 151.53,102.67 151.53,102.42 151.37,102.26 148.96,102.26 148.78,102.45 148.78,102.59 148.3,103.07 147.22,103.07 147.19,103.09 147.17,103.09
  IN2 w0.133: 131.68,102.78 134.46,102.78 135.66,103.98 141.61,103.98 142.17,103.42 145.6,103.42 145.93,103.09 147.17,103.09
  BOTTOM w0.089: U24.BE18 152.61,102.42 152.51,102.32 151.78,102.32 151.76,102.33 151.36,102.73 v3(151.27,102.73)
  BOTTOM w0.127: v3(129.93,103.15) 130.03,103.06 130.03,102.79 129.8,102.56 129.53,102.56 U27.A21
DMI_TXP0: length 34.7
  IN2 w0.089: 131.05,105.5 131.03,105.5 130.99,105.53 130.46,105.53 130.1,105.17 127.44,105.17 126.52,104.25 126.52,102.75 125.93,102.16 v3(125.93,102.15)
  IN2 w0.133: v3(149.89,104.49) 150.17,104.76 150.17,105.17 149.68,105.66 148.51,105.66 146.81,107.36 135.03,107.36 133.17,105.5 131.05,105.5
  BOTTOM w0.079: U24.BB21 153.78,103.64 153.48,103.34 153.47,103.32 153.22,103.32 153.02,103.52 152.57,103.52 152.56,103.52 152.54,103.52
  BOTTOM w0.089: 152.54,103.52 152.28,103.52 152.17,103.62 150.71,103.62 150.11,104.22 150.11,104.26 149.89,104.48 v3(149.89,104.49)
  BOTTOM w0.114: v3(125.93,102.15) U27.D20
DMI_TXP1: length 33
  IN2 w0.089: v5(127.93,102.15) 127.35,102.74 127.35,104.37 127.79,104.81 131.62,104.81 131.65,104.84 131.68,104.84
  IN2 w0.102: 147.58,105 147.58,104.54 147.72,104.4 v3(147.97,104.4)
  IN2 w0.133: 147.58,105 147.58,105.6 146.51,106.67 141.76,106.67 141.3,106.22 135.28,106.22 133.91,104.84 131.68,104.84
  BOTTOM w0.089: v3(147.97,104.4) 148.19,104.17 148.19,103.91 148.55,103.56 150.15,103.56 150.48,103.23 152,103.23 152.3,102.92 153.02,102.92 153.24,103.14 153.71,103.14 U24.BC20
  BOTTOM w0.114: U27.C20 127.46,101.69 v5(127.93,102.15)
DMI_TXP2: length 30.3
  IN2 w0.089: v3(128.93,102.15) 129.18,102.41 129.26,102.41 129.51,102.66 129.51,103.41 129.66,103.56 131.62,103.56 131.66,103.52 131.68,103.52
  IN2 w0.102: v3(149.24,102.71) 149.43,102.91 149.43,103.14 149.03,103.55 147.34,103.55 147.02,103.87 146.98,103.87 146.97,103.89
  IN2 w0.133: 131.68,103.52 134.29,103.52 135.79,105.02 142.98,105.02 143.09,105.13 144.46,105.13 144.81,105.48 145.62,105.48 146.48,104.62 146.48,104.38 146.97,103.89
  BOTTOM w0.079: 152.88,101.92 153,101.92 153.22,101.7 153.47,101.7 153.64,101.87 153.78,102.01 U24.BB17
  BOTTOM w0.089: 152.88,101.92 149.87,101.92 149.53,102.26 149.53,102.41 v3(149.24,102.71)
  BOTTOM w0.114: v3(128.93,102.15) 128.46,101.69 U27.B20
DMI_TXP3: length 26.9
  IN2 w0.089: v5(129.93,102.15) 130.34,102.57 131.62,102.57 131.65,102.53 131.68,102.53
  IN2 w0.102: v3(151.93,102.73) 151.73,102.53 151.73,102.34 151.45,102.06 148.88,102.06 148.57,102.37 148.57,102.5 148.21,102.86 147.22,102.86 147.19,102.84 147.17,102.84
  IN2 w0.133: 131.68,102.53 134.57,102.53 135.76,103.73 141.5,103.73 142.06,103.17 145.5,103.17 145.83,102.84 147.17,102.84
  BOTTOM w0.089: U24.BC18 153.35,102.42 153.05,102.72 152.66,102.72 152.44,102.49 152,102.49 151.93,102.57 v3(151.93,102.73)
  BOTTOM w0.114: U27.A20 129.46,101.69 v5(129.93,102.15)
DMIC_CLK_L: length 99.6
  TOP w0.127: v3(31.75,36.11) 31.92,35.94 31.92,33.72 31.4,33.19 U15.3 ; v3(103.29,5.86) 103.33,5.83 U17.4
  IN1 w0.133: v3(31.75,36.11) 31.78,36.14 34.22,36.14 34.4,35.96 34.4,34.4 35.61,33.19 37.6,33.19 42.9,27.89 42.9,27.29 43.61,26.58 43.61,23.82 43.16,23.36 43.16,20.23 50,13.38 68.62,13.38 70.91,11.1 76.67,11.1 81.14,15.57 95.39,15.57 103.29,7.67 v3(103.29,5.86)
DMIC_DAT_L: length 99.1
  TOP w0.127: U17.5 103.26,3.35 v3(102.35,4.25) ; U15.2 31.8,33.05 32.31,33.56 32.31,35.22 32.71,35.63 v3(33.27,35.63)
  IN1 w0.133: v3(102.35,4.25) 102.59,4.49 102.59,7.82 95.23,15.19 81.31,15.19 76.83,10.71 70.75,10.71 68.48,12.98 49.86,12.98 42.77,20.07 42.77,23.52 43.22,23.98 43.22,26.42 42.51,27.13 42.51,27.72 37.43,32.8 35.45,32.8 33.27,34.98 v3(33.27,35.63)
DNBSWON#: length 28.2
  TOP w0.127: U13.120 172.43,65.44 172.19,65.69 172.19,65.99 171.18,67 v3(171.13,67)
  BOTTOM w0.127: v3(171.13,67) 171.13,67.59 173,69.46 173.28,69.46 173.63,69.81 173.63,71.18 170.2,74.6 170.2,81.48 171.68,82.97 TP140.1 171.68,84.02 171.53,84.17 171.53,85.96 171.97,86.4 171.97,86.74 R604.1
DPB_HPD_Q: length 38.2
  TOP w0.127: v3(169.95,122.95) 169.8,122.8 168.89,122.8 168.56,123.13 166.25,123.13 165.93,123.45 153.52,123.45 R49.2 152.3,122.23 152.3,121.1 151.79,120.59 v2(151.41,120.59) 149.3,120.59 148.45,121.44 Q13.1
  IN1 w0.133: v3(168.41,115.8) 168.41,116.18 171.2,118.98 171.2,121.75 170,122.95 v3(169.95,122.95)
  BOTTOM w0.079: 167.56,113.2 167.8,112.96 167.8,112.75 167.58,112.53 167.58,112.01 U24.K40
  BOTTOM w0.089: 167.56,113.2 167.51,113.25 167.51,113.31 167.18,113.63 167.18,113.99
  BOTTOM w0.102: 167.18,113.99 168.12,114.93 168.12,115.52 v3(168.41,115.8)
DPWROK: length 38.4
  TOP w0.127: R232.2 182.64,84.29 181.27,84.29 180.77,83.79 179.45,83.79 178.47,82.81 178.47,81.93 178.28,81.74 176.91,81.74 176.05,82.6 174.29,82.6 v2(174.27,82.62) 173.41,82.62 v3(173.39,82.6) ; U13.124 170.83,61.84 170.69,61.71 169.1,61.71 168.6,62.2 v3(168.6,63)
  IN1 w0.133: v3(173.39,82.6) 173.39,82.39 167.91,76.91 167.91,72.24 167.91,72.24 167.91,70.11 168.6,69.42 v3(168.6,63)
DPWROK_R: length 33.8
  TOP w0.127: Q25.3 182.57,85 R232.1 182.39,84.82 C215.1 180.56,84.3 180.03,84.3 179.81,84.53 179.81,85.35 180.06,85.61 180.06,87.04 180.42,87.39 180.42,87.85 179.98,88.28 R218.1 179.77,89.37 R197.1 179.43,89.55 v3(176.55,89.55)
  IN1 w0.133: v3(176.55,89.55) 176.71,89.55 178.24,91.08 178.24,92.07 177.15,93.16 176.61,93.16 176,92.55 175.27,92.55 174.03,93.79 172.6,93.79 172.17,94.22 169.51,94.22 167.4,96.33 167.4,99.6 v3(167.34,99.67)
  BOTTOM w0.102: U24.L13 167.19,99.81 v3(167.34,99.67)
DRAMRST_CNTRL: length 60.9
  TOP w0.127: v3(89.49,69.59) 89.92,69.59 v2(90.28,69.23) 91.52,67.99 Q39.2 89.46,66.72 89.34,66.85 Q38.2 85.73,66.85 84.21,65.33 C230.1 R290.1 R289.1 R288.1 ; v3(127.28,71.85) 127.54,71.6 Q35.2 128.58,69.77 130.28,69.77 Q36.2
  BOTTOM w0.127: v3(127.28,71.85) 125.33,69.89 98.84,69.89 98.54,69.59 89.49,69.59 v3(89.49,69.59)
DRAMRST_CNTRL_EC: length 219
  TOP w0.127: U13.78 186.55,53.93 v3(186.72,54.09) ; R289.2 81.05,64.08 82.33,62.81 83.71,62.81 88.5,58.02 88.5,47.28 89.16,46.62 89.16,40.18 81.55,32.57 v3(80.8,32.57)
  IN1 w0.133: v3(186.72,54.09) 185.96,53.34 185.96,51.33 185.98,51.3 185.98,49.35 187.41,47.92 189.06,47.92 189.96,47.03 189.96,18.57 185.79,14.41 185.18,14.41 184,13.22 179.89,13.22 175.98,9.31 173.26,9.31 171.96,10.61 171.96,12.69 170.43,14.22 169.22,14.22 166.14,17.3 159.2,17.3 153.64,22.86 151.13,22.86 150.69,22.42 143.9,22.42 142.39,20.91 136.33,20.91 130.62,15.2 124.72,15.2 124.41,15.51 121.59,15.51 v3(121.29,15.21)
  IN2 w0.133: v3(80.8,32.57) 82.9,30.47 113.82,30.47 v3(114.38,31.03)
  BOTTOM w0.127: v3(114.38,31.03) 115.6,31.03 120.1,26.54 v2(120.1,24.15) 119.87,23.92 119.87,17.29 121.29,15.87 v3(121.29,15.21)
DRAMRST_CNTRL_PCH: length 184.7
  TOP w0.127: v3(81.11,31.29) 81.13,31.29 v2(83.44,33.6) 89.41,39.57 89.41,46.73 88.75,47.39 88.75,58.12 83.81,63.06 82.43,63.06 82.12,63.37 82.12,64.35 R290.2
  IN1 w0.133: v3(81.11,31.29) 81.72,30.68 113.37,30.68 114.19,31.49 114.84,31.49 115.65,30.68 132.54,30.68 139.63,37.77 139.63,39.29 145.41,45.07 145.41,45.16 159.45,59.2 159.45,60.21 159.74,60.51 159.74,74.39 163.35,78 163.35,79.8 163.97,80.41 164.54,80.41 167.62,83.49 167.62,84.66 167.66,84.7 167.66,88.48 167.83,88.64 167.83,88.85 170.23,91.26 170.79,91.26 171.21,90.84 172.32,90.84 173.13,91.65 173.13,92.85 172.69,93.28 172.69,93.3 172.06,93.93 172.04,93.93 172.03,93.95 169.04,93.95 167.99,95 167.72,95 166.44,96.27 166.44,97.4 166.45,97.4 166.45,97.42 v3(166.9,97.87)
  BOTTOM w0.102: U24.N8 166.51,98.27 v3(166.9,97.87)
DSW_WAKE#: length 51.8
  TOP w0.127: v3(170.56,49.6) 170.12,49.15 168.72,49.15 168.35,49.53 U13.30 ; R202.1 168.36,89.02 169.43,89.02 170.15,88.3 170.15,87.38 170.54,86.99 170.54,85.52 169.33,84.31 169.33,82.2 168.33,81.2 v3(167.85,81.2)
  IN2 w0.133: v3(170.56,49.6) 170.71,49.75 170.71,52.29 171.48,53.06 171.48,55.73 170.81,56.39 169.59,56.39 169.44,56.24 168.68,56.24 168.23,56.68 168.23,58.26 165.75,60.75 165.75,61.84 166.51,62.6 166.51,64.76 166.21,65.06 166.21,66.71 166,66.93 166,71.19 167.68,72.88 167.68,75.03 167.78,75.13 167.78,81.12 v3(167.85,81.2)
DSW_WAKE#_R: length 12.1
  TOP w0.127: v3(169.19,90.92) 169.07,90.8 R203.1 R202.2
  IN2 w0.089: v3(165.93,99.2) 166.44,98.7 166.44,98.15
  IN2 w0.133: v3(169.19,90.92) 169.19,91.31 166.44,94.07 166.44,98.15
  BOTTOM w0.102: U24.R11 165.67,99.46 v3(165.93,99.2)
DSWVREN: length 9.3
  BOTTOM w0.102: 174.93,98.06 174.45,98.06 173.9,97.51 172.25,97.51 171.72,98.05 171.23,98.05 171.09,98.18 170.78,98.18 U24.C8
  BOTTOM w0.127: R542.1 178.43,98.33 178.08,97.99 177.01,97.99 R541.2 175.81,98.06 174.93,98.06
E51_TXD: length 3.7
  TOP w0.127: TP69.1 178.9,65.47 177.18,63.76 177.01,63.76 176.83,63.57 U13.109
EC_A20GATE: length 54.9
  TOP w0.127: v3(156.07,92.18) 156.25,92.18 156.64,91.79 156.64,91.36 155.99,90.7 R208.2 ; v3(157.29,68.27) 157.31,68.24 v2(158.09,68.24) 162.69,68.24 163.33,67.61 163.33,66.63 163.54,66.41 165.47,66.41 165.55,66.5 165.55,66.84 166.36,67.64 168.26,67.64 168.77,67.14 168.77,65.18 170.03,63.92 U13.126
  IN1 w0.133: v3(156.07,92.18) 156.66,91.59 156.66,90.92 156.15,90.42 156.15,89.42 155.15,88.42 155.15,82.32 157.11,80.36 157.11,73.45 156.72,73.07 156.72,72.56 157.47,71.81 157.47,68.46 v3(157.29,68.27)
  IN2 w0.133: v3(156.07,92.18) 156.07,92.85 156.85,93.63 156.85,96.74 157.02,96.91 157.02,98.09 157.5,98.57 v3(157.54,98.57)
  BOTTOM w0.102: v3(157.54,98.57) 157.83,98.86 U24.AN10
EC_FB_CLAMP: length 210.7
  TOP w0.127: v3(173.54,52.42) 174.73,51.23 174.73,49.19 175.23,48.68 175.8,48.68 177.11,49.99 178.11,49.99 181.65,53.53 U13.77
  IN1 w0.133: v3(173.54,52.42) 172.4,51.28 171.5,51.28 171.13,51.65 171.13,52.65 171.92,53.44 171.92,56.32 170.82,57.42 170.82,59.68 171.4,60.26 171.4,62.73 174.02,65.35 174.02,68.98 174.41,69.37 174.41,72.51 177.57,75.67 177.57,79.31 181.25,82.99 182.17,82.99 182.6,83.42 182.6,84.33 184.89,86.63 186.6,86.63 190.12,90.14 190.12,96.89 190.68,97.46 190.68,106.32 191.7,107.34 191.7,111.28 188.67,114.3 188.67,115.47 188.67,115.47 188.67,116.2 187.56,117.31 187.56,118.76 186.8,119.53 186.8,121.33 187.33,121.86 v3(187.66,121.86)
  IN2 w0.133: v3(187.66,121.86) 187.98,121.54 191.83,121.54 194.16,123.87 194.16,163.32 193.57,163.91 193.57,167.48 189.92,171.13 183.4,171.13 179.92,174.61 173.97,174.61 172.28,176.29 171.2,176.29 169.93,177.56 167.77,177.56 167.04,178.3 v3(166.84,178.3) 166.84,177.84 167.26,177.41 167.26,176.19 166.37,175.3 166.37,172.02 166.98,171.42 166.98,170.86 165.91,169.79 165.91,167.48 v3(166.37,167.02) 166.89,167.02 167.62,166.29 167.62,162.89 165.69,160.95 v3(164.82,160.95)
  BOTTOM w0.127: R427.1 165.55,160.95 v3(164.82,160.95) ; R383.2 165.58,179.56 v3(166.84,178.3) ; R414.1 168,166.14 167.11,167.02 v3(166.37,167.02)
EC_FPBACK#: length 160
  TOP w0.127: U13.118 173.23,63.9 172.96,64.17 172.96,65.7 172.73,65.94 172.73,66.54 171.47,67.79 169.62,67.79 167.45,69.97 167.45,70.39 166.45,71.39 163.2,71.39 163.03,71.22 163.03,69.77 162.8,69.54 157.71,69.54 155.93,71.32 152.58,71.32 v2(152.53,71.27) 152.53,71.26 152.06,70.8 v3(151.87,70.8) ; v3(105.21,139.13) 107.99,141.91 107.99,151.21 106.17,153.03 Q9.2
  IN1 w0.133: v3(151.87,70.8) 152.77,71.7 152.77,74.49 150.53,76.73 149.91,77.34 149.33,77.92 149.33,82.69 150.1,83.46 150.1,84.31 151.54,85.75 151.54,86.43 150.04,87.93 150.04,88.92 150.68,89.56 152.55,89.56 154.32,91.33 154.32,92.59 153.92,92.99 152.54,92.99 152.27,92.72 150.98,92.72 150.33,93.36 150.33,93.84 149.85,94.33 148.36,94.33 147.13,93.1 143.37,93.1 140.06,96.41 140.06,99.99 136.93,103.13 136.93,109.4 139.55,112.02 139.55,120.48 130.62,129.41 115.35,129.41 105.63,139.13 v3(105.21,139.13)
EC_ODD_EJ: length 82.3
  TOP w0.127: U13.20 168.45,53.53 168.76,53.23 178.35,53.23 179.34,54.22 179.34,55.42 180.48,56.55 180.48,57.24 181.06,57.82 v3(181.59,57.82) ; v3(192.98,108.86) 193.53,109.42 v2(194.39,109.42) R97.2
  BOTTOM w0.127: v3(192.98,108.86) 192.55,108.43 192.55,107.88 191.57,106.9 191.57,103.28 193.39,101.46 193.39,100.91 194.54,99.75 194.54,98.82 193.76,98.04 192.59,98.04 192.17,97.62 192.17,96.61 192.54,96.24 192.54,90.59 188.62,86.68 187.68,86.68 181.47,80.47 181.47,79.52 180.28,78.33 180.28,77.09 179.86,76.67 179.86,75.62 180.17,75.31 180.17,70.76 179.66,70.25 179.66,68.62 181.5,66.78 181.5,63.7 181.4,63.6 181.4,62.09 181.77,61.71 181.77,59.4 181.16,58.79 181.16,58.24 v3(181.59,57.82)
EC_PECR_R: length 10.3
  TOP w0.127: U13.117 173.63,63.66 173.82,63.85 173.82,64.07 173.69,64.2 173.39,64.2 173.23,64.35 173.23,64.57 173.39,64.73 173.61,64.73 173.77,64.89 173.77,65.11 173.61,65.26 173.39,65.26 173.23,65.42 173.23,65.64 173.39,65.8 173.62,65.8 173.77,65.94 173.77,66.15 173.62,66.3 173.27,66.3 173.13,66.44 173.13,66.85 172.44,67.53 172.15,67.53 172.01,67.67 172.01,67.85 172.15,67.99 172.45,67.99 172.57,68.12 172.57,68.29 172.45,68.42 v3(171.91,68.42) R275.1
EC_PWROK: length 291.1
  TOP w0.127: v3(166.57,79.66) 168.41,79.66 170.84,82.09 v2(171.71,82.09) 175.85,82.09 176.7,81.23 178.64,81.23 178.98,81.57 178.98,82.6 179.66,83.29 181.32,83.29 182.07,82.54 183.24,82.54 183.4,82.7 U8.2 183.4,84.22 183.77,84.59 183.77,85.19 184.26,85.68 186.72,85.68 R231.1 187.79,84.61 189.5,84.61 189.81,84.92 189.81,86.43 190.42,87.04 190.42,89.54 189.56,90.39 R193.1 ; v3(168.72,47.4) 169.04,47.08 U13.33 169.23,46.54 168.76,46.07 168.76,45.35 R326.2
  IN1 w0.133: v3(168.72,47.4) 166.64,47.4 165.66,46.42 164.69,46.42 163.96,46.42 163.66,46.12 160.95,46.12 160.56,46.51 155.75,46.51 154.36,45.13 151.64,45.13 146.79,40.28 146.79,37.35 136.23,26.79 114.19,26.79 112.85,28.12 84.88,28.12 76.25,19.49 52.58,19.49 48.07,24 48.07,28.59 47.38,29.28 47.38,29.75 41.13,35.99 41.13,36.83 37.9,40.06 37.9,41.32 38.18,41.6 38.18,53.59 38.79,54.2 38.79,56.99 37.85,57.93 37.85,62.02 38.35,62.52 38.35,69.81 39.09,70.55 39.09,79.62 44.28,84.8 44.28,85.31 44.56,85.59 47.1,85.59 v3(48.47,86.96)
  IN2 w0.133: v3(168.72,47.4) 168.72,48.54 170.2,50.02 170.2,52.5 170.97,53.27 170.97,54.86 170.61,55.22 168.76,55.22 167.72,56.25 167.72,58.05 165.23,60.54 165.23,62.05 165.99,62.82 165.99,64.54 165.69,64.84 165.69,66.5 165.48,66.71 165.48,71.41 167.17,73.09 167.17,75.25 167.26,75.34 167.26,78.97 v3(166.57,79.66)
  BOTTOM w0.127: v3(48.47,86.96) 49.44,87.93 49.44,89.32 PR195.1
EC_RCIN#: length 53.4
  TOP w0.127: U13.4 166.76,59.93 166.23,59.4 164.45,59.4 162.75,61.11 158.49,61.11 v2(156.08,63.51) 155.39,64.21 v3(155.39,65.63) ; v3(153.2,86.26) 153.2,87.43 153.79,88.02 154.37,88.02 155.48,89.12 155.48,89.82 155.09,90.21 R207.1 154.85,90.52 155.84,91.52 v3(156.07,91.52)
  IN1 w0.133: v3(155.39,65.63) 155.55,65.79 155.55,69.06 155.93,69.44 155.93,71.08 155.18,71.83 155.18,73.74 155.26,73.81 155.26,74.51 153.36,76.4 153.36,81.19 152.32,82.22 152.32,84.65 153.2,85.53 v3(153.2,86.26)
  IN2 w0.133: v3(156.07,91.52) 155.82,91.52 155.35,91.99 155.35,93.68 156.33,94.65 156.33,96.04 156.45,96.16 156.45,97.19 v3(156.52,97.26)
  BOTTOM w0.102: v3(156.52,97.26) 156.82,97.26 U24.AT6
ECAGND: length 2
  TOP w0.203: U13.75 184.29,52.73 184.72,53.16 C247.2
  vias: v3(186.59,49.6) v3(186.92,53.16)
EDP_AUX#_C: length 14
  TOP w0.127: R3.2 115.85,178.8 117.55,178.8 118.18,178.17 118.31,178.17 v3(118.6,178.46)
  BOTTOM w0.127: v3(118.6,178.46) 118.37,178.22 117.49,178.22 C348.2 116.38,178.17 115.08,178.17 R385.1 114.53,178.71 114.09,178.26 113.94,178.26 v2(113.36,178.83) 113.36,178.45 113.19,178.28 113.07,178.28 112.83,178.52 112.83,179.08 111.96,179.95 111.79,179.95 111.66,180.08 CN2.22
EDP_AUX_C: length 13.9
  TOP w0.127: v3(118.6,177.7) 118.37,177.93 118.08,177.93 117.45,178.55 115.78,178.55 R4.2
  BOTTOM w0.127: CN2.23 111.63,179.58 111.76,179.71 111.86,179.71 112.59,178.98 112.59,178.42 112.97,178.03 113.3,178.03 113.42,177.92 v2(113.42,177.54) 113.9,178.02 114.01,178.02 R392.1 115.04,177.93 116.52,177.93 C349.2 117.51,177.98 118.31,177.98 v3(118.6,177.7)
EDP_AUXN: length 95.2
  IN2 w0.133: v3(103.31,178.58) 103.04,178.32 103.04,178.21 103.15,178.1 103.61,178.1 104.65,179.14 110.24,179.14 111.38,178 117.48,178 v3(118.65,179.16)
  BOTTOM w0.102: 117.72,118.51 117.72,118.48 117.71,118.46 117.71,118.18 117.99,117.9 117.99,108.76 118.06,108.69 U27.M27
  BOTTOM w0.127: v3(118.65,179.16) 118.15,179.16 C348.1 ; 117.72,118.51 117.72,118.94 116.73,119.94 116.73,134.22 103.05,147.9 103.05,178.32 v3(103.31,178.58)
EDP_AUXP: length 95.2
  IN2 w0.133: v3(118.65,177.01) 118.64,177.01 117.9,177.75 111.27,177.75 110.13,178.89 104.76,178.89 103.72,177.85 103.05,177.85 102.79,178.1 102.79,178.34 v4(102.55,178.58)
  BOTTOM w0.102: U27.N27 117.4,108.69 117.78,109.07 117.78,117.81 117.5,118.09 117.5,118.46 117.48,118.48 117.48,118.51
  BOTTOM w0.127: v3(118.65,177.01) 118.22,177.01 C349.1 ; v4(102.55,178.58) 102.81,178.32 102.81,147.8 116.49,134.12 116.49,119.84 117.48,118.84 117.48,118.51
EDP_HPD: length 63
  IN1 w0.133: v3(104.88,162.22) 103.7,161.04 103.7,142.45 116.02,130.13 v3(118.92,130.13)
  BOTTOM w0.127: CN2.25 109.25,178.58 107.6,176.93 107.6,173.78 104.83,171.01 104.83,162.27 v3(104.88,162.22) ; v3(118.92,130.13) R452.1 118.71,129.28 Q46.2
EDP_HPD_Q: length 19
  IN2 w0.133: v3(117.24,120.97) 116.41,120.15 116.41,110.32 115.93,109.84 v5(115.93,109.15)
  BOTTOM w0.127: U27.P27 v5(115.93,109.15) ; Q46.3 118.91,124.91 R457.1 118.91,123.78 118.43,123.29 118.11,123.29 117.24,122.42 v3(117.24,120.97)
EDP_RCOMP: length 7.1
  TOP w0.508: v3(125.02,106.16) 125.55,106.7 127.36,106.7 127.41,106.75 127.79,106.75 v2(128.35,107.31) 129.19,108.15 130,108.15 R100.1
  BOTTOM w0.254: v3(125.02,106.16) 125.4,105.79 U27.E24
EDP_TX0#_C: length 7.3
  BOTTOM w0.127: C343.2 116.83,180.91 116.69,180.76 116.32,180.76 116.25,180.84 116.25,181.19 115.76,181.68 113.4,181.68 112.16,182.92 111.91,182.92 111.75,183.08 CN2.16
EDP_TX0_C: length 7.3
  BOTTOM w0.127: C346.2 116.83,180.42 116.73,180.52 116.22,180.52 116.01,180.74 116.01,181.09 115.66,181.44 113.3,181.44 112.06,182.68 111.82,182.68 111.72,182.58 CN2.17
EDP_TX1#_C: length 3.3
  BOTTOM w0.127: C345.2 113.56,180.56 113.35,180.56 112.47,181.45 111.87,181.45 111.74,181.58 CN2.19
EDP_TX1_C: length 3.4
  BOTTOM w0.127: CN2.20 111.69,181.08 111.82,181.21 112.37,181.21 113.25,180.32 113.34,180.32 C347.2
EDP_TXN0: length 91.7
  IN2 w0.133: v3(118.36,181.01) 118.11,180.76 117.46,180.76 116.34,181.88 106.56,181.88 105.57,182.87 104.66,182.87 104.15,182.36 104.15,181.81 v4(103.87,181.53)
  BOTTOM w0.102: U27.P35 115.95,116.69 115.83,116.81 115.83,117.58 115.29,118.12 115.29,118.14 115.27,118.16
  BOTTOM w0.127: v4(103.87,181.53) 104.13,181.79 104.13,181.98 104,182.11 103.19,182.11 101.17,180.09 101.17,146.03 115.22,131.99 115.22,118.22 115.27,118.16 ; v3(118.36,181.01) 118.1,180.76 118,180.76 C343.1
EDP_TXN1: length 87.2
  IN2 w0.133: v4(103.54,179.94) 103.79,180.2 103.79,180.57 104.08,180.85 114.09,180.85 114.45,180.49 115.22,180.49 v3(115.47,180.74)
  BOTTOM w0.102: 115.98,118.51 115.98,118.26 116.98,117.25 116.98,116.36 116.87,116.25 116.87,115.82 117,115.69 U27.N34
  BOTTOM w0.127: C345.1 115.03,180.42 115.15,180.42 v3(115.47,180.74) ; v4(103.54,179.94) 103.78,180.19 103.78,180.39 103.71,180.46 103.01,180.46 101.98,179.43 101.98,146.32 115.98,132.33 115.98,118.51
EDP_TXP0: length 91.7
  IN2 w0.133: v3(104.63,181.53) 104.41,181.76 104.41,182.26 104.77,182.62 105.46,182.62 106.45,181.63 116.23,181.63 117.35,180.51 118.09,180.51 v3(118.36,180.25)
  BOTTOM w0.102: U27.R35 115.62,116.91 115.62,117.5 115.15,117.97 115.12,117.97 115.1,117.99
  BOTTOM w0.127: v3(104.63,181.53) 104.37,181.8 104.37,182.08 104.1,182.35 103.09,182.35 100.93,180.19 100.93,145.93 114.97,131.88 114.97,118.12 115.1,117.99 ; C346.1 118,180.52 118.09,180.52 v3(118.36,180.25)
EDP_TXP1: length 87.2
  IN2 w0.133: v3(115.47,179.98) 115.22,180.23 114.35,180.23 113.99,180.59 104.18,180.59 104.05,180.46 104.05,180.2 v3(104.3,179.94)
  BOTTOM w0.102: 115.74,118.51 115.74,118.5 115.76,118.47 115.76,118.42 115.77,118.41 115.77,118.17 116.78,117.17 116.78,116.45 116.67,116.33 116.67,115.95 U27.P34
  BOTTOM w0.127: C347.1 114.97,180.18 115.27,180.18 v3(115.47,179.98) ; 115.74,118.51 115.74,132.23 101.74,146.22 101.74,179.53 102.91,180.7 103.81,180.7 104.02,180.49 104.02,180.22 v3(104.3,179.94)
EDP_VDD_EN: length 115.9
  TOP w0.127: R26.1 105.13,160.13 v2(105.13,159.99) 105.13,159.58 v3(105.47,159.25)
  IN1 w0.133: v3(168.68,110.1) 168.68,110.18 169.74,111.24 171.15,111.24 171.45,111.55 171.45,115.14 171.75,115.44 171.75,121.97 170.72,123.01 170.72,123.24 170.36,123.6 170.36,124.34 170.62,124.6 170.62,127.5 169.73,128.39 168.48,128.39 168.01,128.85 167.58,129.28 166.81,129.28 164.72,131.37 164.72,134.67 163.66,135.73 131.73,135.73 127.72,131.72 116.92,131.72 106,142.64 106,158.71 v3(105.47,159.25)
  BOTTOM w0.102: v3(168.68,110.1) 168.99,109.8 U24.G36
EDP_VDD_EN_R: length 14.7
  TOP w0.127: U2.3 110.02,168.48 v2(107.29,165.75) 105.27,163.73 105.27,162.45 R26.2 R27.2
FANSIG: length 263.3
  TOP w0.127: v3(174.88,43.99) v2(174.88,44.93) 174.83,44.98 U13.47
  IN1 w0.133: v3(57.13,106.04) 44.38,106.04 39.94,101.59 38.44,101.59 38.16,101.31 38.16,101.18 36.86,99.89 36.86,99.28 36.09,98.52 36.09,96.68 35.23,95.82 35.23,86.71 37.39,84.55 37.39,81.61 36.48,80.7 36.48,72.32 35.66,71.5 35.66,64.96 35.25,64.55 35.25,62.94 34.43,62.12 34.43,52.83 35.55,51.72 35.55,48.59 34.43,47.47 34.43,42.3 40.34,36.39 40.34,35.67 46.57,29.44 46.57,28.97 47.28,28.26 47.28,23.68 52.25,18.71 76.6,18.71 85.23,27.34 110.92,27.34 113.39,24.86 135.03,24.86 147.3,37.14 147.3,40.06 150.71,43.48 v3(151.41,43.48)
  BOTTOM w0.127: CN3.2 59.84,109.55 60.13,109.26 60.13,106.76 R510.2 C433.2 57.67,106.58 v3(57.13,106.04) ; v3(151.41,43.48) 152.39,42.5 173.4,42.5 v3(174.88,43.99)
FB_CAL_PD_VDDQ: length 1.8
  TOP w0.381: R20.2 138.98,167.69 139.63,167.04 v3(139.63,167.03)
  BOTTOM w0.127: v3(139.63,167.03) 139.63,167.04 140.03,166.64 U19.D22
FB_CAL_PU_GND: length 1.4
  TOP w0.254: R19.2 137.91,167.94 v3(138.01,167.84)
  BOTTOM w0.102: v3(138.01,167.84) 138.01,167.82 U19.C24
FB_CAL_TERM_GND: length 3.2
  TOP w0.508: v3(137.17,168.64) 137.17,169.12 137.51,169.45 R14.2 138.72,168.76 v3(138.92,168.76)
  BOTTOM w0.254: v3(137.17,168.64) 137.57,168.24 U19.B25
FB_CLAMP: length 12.4
  BOTTOM w0.127: R427.2 165.3,161.81 165.02,162.1 163.7,162.1 R426.1 162.99,161.39 v2(160.61,161.39) 159.37,161.39 158.95,161.81 158.95,162.61 157.79,163.77 157.19,163.77 157,163.96 157,164.33 156.77,164.56 156.4,164.56 156.02,164.94 U19.F3
FB_CLAMP_MON: length 23.3
  BOTTOM w0.127: U19.C6 152.88,167.85 152.88,168.45 153.09,168.65 153.68,168.65 156.07,171.04 159.64,171.04 162.11,173.5 R401.1 162.11,175.64 161.98,175.77 v2(161.98,179.62) 161.98,181.02 162.87,181.91 162.89,181.91 164.01,183.03 Q24.1
FB_CLAMP_REQ#: length 145.6
  TOP w0.127: v3(188.98,52.32) 188.98,51.66 188.22,50.9 184.66,50.9 184.49,50.73 U13.70 ; v3(185.02,133.32) 189.84,133.32 190.2,133.67 v2(195.94,133.67) 196.6,133.67 v3(197.07,133.2)
  IN1 w0.133: v3(197.07,133.2) 197.57,132.7 197.57,125.2 196.51,124.14 195.92,124.14 192.39,120.61 192.39,120.08 192.39,115.84 196.83,111.41 196.83,89.26 195.33,87.76 193.83,87.76 189.19,83.12 187.22,83.12 184.57,80.47 184.57,76.52 187.71,73.38 187.71,65.65 188.45,64.91 188.45,64.18 190.59,62.05 190.73,61.9 190.73,53.81 189.24,52.32 v3(188.98,52.32)
  BOTTOM w0.127: R441.2 168.67,149.54 R733.1 168.79,148.69 168.79,148.05 168.56,147.82 168.2,147.82 167.9,147.52 167.9,147.03 168.48,146.45 169.12,146.45 170.33,145.23 170.33,140.84 175.19,135.99 175.19,134.67 176.88,132.98 184.68,132.98 v3(185.02,133.32)
FB_CLAMP_REQ#_R: length 17.5
  BOTTOM w0.127: U19.A4 156.2,170.25 v2(161.52,170.25) 161.95,170.25 162.44,170.73 163.39,170.73 R405.1 163.97,171.32 165.49,172.84 167.99,172.84 R404.1 168.45,171.4 Q26.1
FBA_CMD0: length 47.7
  TOP w0.127: v3(120.2,166.3) 120.11,166.3 119.97,166.16 119.97,165.97 119.87,165.88 119.69,165.88 119.59,165.98 119.41,165.98 119.19,165.75 119.08,165.75 118.83,166 118.67,166 118.44,165.77 118.27,165.77 118.16,165.89 118.16,166.03 118.29,166.16 118.29,166.47 118.39,166.57 118.52,166.57 VRAM1.L2
  IN2 w0.165: v3(135.32,167.48) 135.32,166.9 134.83,166.41 127.54,166.41 125.79,164.67 124.62,164.67 124.46,164.51 124.46,163.85 124.29,163.67 122.86,163.67 122.05,164.48 121.77,164.48 121.41,164.85 120.31,164.85 119.92,164.46 113.15,164.46 112.97,164.64 112.97,164.89 113.15,165.07 113.47,165.07 113.64,165.23 113.64,166.32 113.83,166.52 114.1,166.52 114.3,166.32 114.3,165.23 114.46,165.07 119.71,165.07 119.89,165.25 119.89,165.5 119.71,165.68 118.6,165.68 118.42,165.86 118.42,166.12 118.6,166.3 v3(120.2,166.3)
  BOTTOM w0.127: VRAM3.L2 123.16,165.95 122.4,165.95 121.86,166.49 121.5,166.49 121.36,166.63 120.77,166.63 120.44,166.3 v3(120.2,166.3)
  BOTTOM w0.152: v3(135.32,167.48) 135.36,167.44 U19.C27
FBA_CMD1: length 7.4
  BOTTOM w0.152: U19.C26 136.4,167.83 135.72,167.83 135.17,168.38 135.17,169.35 136.63,170.81 136.63,171.27 136.83,171.47 TP78.1
FBA_CMD2: length 58.5
  TOP w0.127: VRAM1.K1 117.76,166.96 117.76,166.84 117.86,166.74 118.01,166.74 118.07,166.8 119.73,166.8 120,167.07 120.98,167.07 v3(121.03,167.13)
  TOP w0.152: R21.2 114.79,166.36 v3(115.09,166.36)
  IN2 w0.165: v3(135.54,165.83) 135.25,166.11 135.25,166.32 135.39,166.46 135.6,166.46 135.83,166.22 135.99,166.22 136.11,166.33 136.11,166.49 135.86,166.74 135.86,167.82 135.18,168.5 134.98,168.5 134.84,168.36 134.84,166.95 134.67,166.78 134.43,166.78 134.26,166.95 134.26,168.8 134.06,168.99 133.79,168.99 133.59,168.8 133.59,166.95 133.43,166.78 133.1,166.78 132.93,166.95 132.93,168.8 132.74,168.99 132.47,168.99 132.27,168.8 132.27,166.95 132.11,166.78 131.78,166.78 131.61,166.95 131.61,168.8 131.42,168.99 131.15,168.99 130.95,168.8 130.95,166.95 130.79,166.78 130.46,166.78 130.29,166.95 130.29,167.51 130.1,167.71 129.83,167.71 129.63,167.51 129.63,166.95 129.47,166.78 127.38,166.78 126.29,165.69 124.32,165.69 124.1,165.46 124.1,164.21 123.93,164.04 123.69,164.04 123.52,164.21 123.52,165.51 123.35,165.69 123.11,165.69 122.94,165.51 122.94,164.63 122.78,164.48 122.56,164.48 122.41,164.63 122.41,166.21 122.18,166.44 121.39,166.44 121.21,166.62 121.21,166.93 121.03,167.11 121.03,167.11 ; v3(121.03,167.13) 121.03,167.11 ; 121.03,167.11 120.99,167.07 119.87,167.07 119.51,166.7 118.48,166.7 117.89,166.11 116.66,166.11 116.46,165.91 115.32,165.91 115.09,166.13 v3(115.09,166.36)
  BOTTOM w0.127: VRAM3.K1 123.94,166.73 122.67,166.73 122.02,167.38 121.29,167.38 v3(121.03,167.13)
  BOTTOM w0.152: U19.E24 138.28,165.79 137.84,166.23 135.94,166.23 v3(135.54,165.83)
FBA_CMD3: length 58.9
  TOP w0.127: VRAM1.K9 124.11,167.14 123.71,166.74 122.65,166.74 121.83,167.56 120.55,167.56 v3(120.5,167.51)
  IN2 w0.165: v3(138.79,165.37) 138.65,165.23 138.65,165.07 138.79,164.93 139.96,164.93 140.13,165.1 140.75,165.1 140.89,165.25 140.89,165.55 140.75,165.7 140.2,165.7 140.08,165.82 139.35,165.82 139.19,165.98 139.19,167.01 139,167.2 138.73,167.2 138.54,167.01 138.54,166.8 138.29,166.55 138.29,165.96 138.13,165.81 137.32,165.81 137.17,165.96 136.23,166.89 136.23,167.97 134.84,169.36 133.08,169.36 132.91,169.53 132.91,170.98 132.72,171.18 132.44,171.18 132.25,170.98 132.25,169.31 132.07,169.12 131.81,169.12 131.62,169.31 131.62,170.98 131.43,171.18 131.16,171.18 130.96,170.98 130.96,169.47 130.78,169.28 130.52,169.28 130.33,169.47 130.33,171 130.15,171.18 129.9,171.18 129.72,171 129.72,168.9 129.91,168.71 130.41,168.71 130.58,168.53 130.58,168.28 130.41,168.1 129.7,168.1 128.75,167.15 127.23,167.15 126.14,166.05 122.94,166.05 122.18,166.82 122.18,167.1 121.65,167.63 120.62,167.63 v3(120.5,167.51) 119.79,167.51 119.35,167.07 118.33,167.07 117.77,166.52 115.93,166.52 v3(115.8,166.39)
  BOTTOM w0.127: VRAM3.K9 117.83,167.14 117.71,167.02 117.71,166.84 117.83,166.72 119.66,166.72 119.84,166.9 120.12,166.9 120.3,166.72 120.45,166.72 120.56,166.83 120.56,166.98 120.37,167.16 120.37,167.38 v3(120.5,167.51)
  BOTTOM w0.152: R413.2 114.96,165.55 v3(115.8,166.39) ; v3(138.79,165.37) 138.39,164.97 U19.F24
FBA_CMD4: length 57.3
  TOP w0.127: VRAM1.T7 122.75,162.12 121.86,161.23 120.77,161.23 v3(120.72,161.18) ; VRAM2.T7 119.74,153.85 119.95,153.85 120.12,154.02 120.12,154.23 119.94,154.4 119.29,154.4 119.2,154.49 119.2,154.86 119.31,154.97 119.45,154.97 119.71,154.72 120.02,154.72 120.11,154.81 120.11,155.04 119.99,155.16 v3(119.85,155.16)
  IN1 w0.133: v3(119.85,155.16) 119.85,156.14 119.1,156.89 v3(119.1,158.97) 119.1,161.13 119.56,161.59 120.31,161.59 v3(120.72,161.18)
  BOTTOM w0.127: v3(120.72,161.18) 120.94,161.18 121.1,161.33 121.1,161.55 120.94,161.7 120,161.7 119.55,162.15 VRAM3.T7 ; v3(119.85,155.16) 120.34,155.65 120.67,155.65 121,155.32 121.28,155.32 121.52,155.09 122.04,155.09 122.75,154.38 VRAM4.T7
  BOTTOM w0.152: v3(119.1,158.97) 119.1,158.7 119.28,158.51 120.42,158.51 120.75,158.84 121.78,158.84 123.03,160.09 123.24,160.09 124.89,161.74 126.34,161.74 129.37,164.76 129.37,172.69 129.75,173.07 135.56,173.07 135.82,172.82 135.82,170.96 134.55,169.69 134.55,166.87 134.78,166.64 U19.D27
FBA_CMD5: length 66.2
  TOP w0.127: VRAM1.T2 118.43,162.34 118.33,162.24 118.33,161.53 119.51,160.34 120.54,160.34 v3(120.72,160.17) ; VRAM2.T2 123.56,154.06 123.56,155.56 122.71,156.41 121.52,156.41 121.26,156.67 120.73,156.67 v3(120.66,156.74)
  TOP w0.152: v3(117.21,160.37) 115.84,161.74 R25.1
  IN1 w0.133: v3(120.66,156.74) 120.24,157.16 v3(120.24,158.97) 120.24,159.35 120.35,159.46 120.35,159.89 120.05,160.19 120.05,160.37 120.18,160.51 120.37,160.51 v3(120.72,160.17)
  BOTTOM w0.127: VRAM3.T2 123.55,161.68 122.26,160.39 120.94,160.39 v3(120.72,160.17) ; VRAM4.T2 118.49,154.05 118.37,154.17 118.37,154.35 118.49,154.48 118.66,154.48 118.77,154.59 118.77,154.76 118.66,154.88 118.49,154.88 118.37,155.01 118.37,155.19 118.49,155.31 118.83,155.31 119.77,156.26 120.18,156.26 v3(120.66,156.74)
  BOTTOM w0.152: v3(117.21,160.37) 117.46,160.11 118.62,160.11 119.76,158.97 v3(120.24,158.97) 120.57,159.3 121.29,159.3 121.52,159.53 121.91,159.53 122.97,160.59 123.1,160.59 124.7,162.2 126.15,162.2 128.91,164.95 128.91,171.79 128.78,171.91 128.55,171.91 128.38,172.09 128.38,172.34 128.55,172.52 128.78,172.52 128.91,172.65 128.91,172.88 129.56,173.53 135.75,173.53 136.28,173.01 136.28,170.93 134.89,169.55 134.89,167.24 135.08,167.05 136.62,167.05 136.79,166.88 U19.D26
FBA_CMD6: length 59.3
  TOP w0.127: VRAM1.R3 119.9,162.79 119.9,162.49 119.9,161.99 120.29,161.6 121.64,161.6 v3(121.76,161.72) ; v3(121.78,154.38) 121.78,154.18 121.9,154.06 122.2,154.06 122.56,153.69 122.87,153.69 123.2,153.35 123.2,153.12 123.11,153.02 122.98,153.02 VRAM2.R3
  TOP w0.152: v3(137.99,165.37) 137.53,165.83 136.81,165.83 136.66,165.98 136.66,165.98 136.33,166.31 135.27,166.31 134.27,167.32 134.27,169.11 133.65,169.73 133.65,171.96 133.41,172.2 127.45,172.2 126.98,171.73 126.98,168.42 127.18,168.22 128.5,168.22 129.44,167.28 129.44,165.7 126.38,162.64 126.38,161.78 125.81,161.21 125.49,161.21 124.13,159.85 124.13,159.84 123.14,159.84 122.95,159.65 122.95,159.39 123.14,159.2 v3(123.5,159.2)
  IN1 w0.133: v3(121.76,161.72) 121.6,161.72 121.49,161.83 121.49,162.02 121.62,162.16 121.94,162.16 122.34,161.76 122.34,161.31 122.57,161.08 122.98,161.08 123.26,160.81 123.26,160.49 123.38,160.37 123.6,160.37 123.72,160.25 123.72,160.08 123.6,159.96 123.2,159.96 123.08,159.85 123.08,159.69 123.2,159.57 123.41,159.57 123.5,159.48 v3(123.5,159.2) 123.5,158.26 123.8,157.95 123.8,156.87 123.25,156.31 123.25,155.7 121.93,154.38 v3(121.78,154.38)
  BOTTOM w0.127: v3(121.76,161.72) 121.58,161.72 121.49,161.81 121.49,162.05 121.61,162.17 121.92,162.17 122.12,161.96 122.23,161.96 122.37,162.1 122.37,162.48 122.64,162.75 122.95,162.75 123.06,162.86 123.06,163.03 122.95,163.14 VRAM3.R3 ; v3(121.78,154.38) 121.78,154.23 121.3,153.75 120.84,153.75 120.79,153.7 120.1,153.7 119.65,153.25 VRAM4.R3
  BOTTOM w0.152: U19.F25 137.59,164.97 v3(137.99,165.37)
FBA_CMD7: length 63.5
  TOP w0.127: VRAM1.R2 119.09,162.8 119.09,162.2 118.9,162.02 118.9,161.37 119.62,160.66 121.21,160.66 121.36,160.81 v3(121.88,160.81) ; v3(122.44,155.98) 122.44,154.81 122.55,154.7 122.7,154.7 122.81,154.81 122.81,155.5 122.93,155.62 123.09,155.62 123.2,155.5 123.2,153.78 123.33,153.65 123.79,153.65 123.91,153.53 123.91,153.37 123.79,153.25 VRAM2.R2
  IN1 w0.133: v3(121.88,160.81) 121.88,160.83 122.56,160.15 122.56,159.86 122.43,159.73 122.23,159.73 122.11,159.6 122.11,159.42 122.24,159.29 122.43,159.29 122.56,159.16 v3(122.56,158.81) 122.56,157.72 122.61,157.66 122.61,156.15 v3(122.44,155.98)
  BOTTOM w0.127: VRAM3.R2 123.79,163.39 123.9,163.39 123.96,163.33 123.96,162.8 123.85,162.69 123.23,162.69 123.09,162.55 123.09,162.05 123.24,161.9 123.24,161.72 123.12,161.6 122.94,161.6 122.83,161.7 122.65,161.7 122.53,161.57 122.53,161.39 122.63,161.29 122.63,161.11 122.5,160.98 122.33,160.98 122.22,161.09 122.04,161.09 121.88,160.93 v3(121.88,160.81) ; v3(122.44,155.98) 122.39,156.03 121.71,156.03 121.4,155.73 120.94,155.73 120.77,155.9 119.87,155.9 119.09,155.12 119.09,153.82 118.75,153.47 VRAM4.R2
  BOTTOM w0.152: v3(122.56,158.81) 122.56,158.97 123.24,159.66 123.45,159.66 125.08,161.28 126.53,161.28 129.82,164.57 129.82,172.39 130.05,172.61 135.18,172.61 135.36,172.44 135.36,172.18 135.18,172.01 134.42,172.01 134.24,171.83 134.24,171.58 134.42,171.4 135.21,171.4 135.38,171.22 135.38,170.98 135.21,170.81 134.45,170.81 134.22,170.58 134.22,166.54 135.44,165.31 136.42,165.31 U19.F26
FBA_CMD8: length 60.4
  TOP w0.127: VRAM1.P3 119.9,163.94 120.04,163.8 120.74,163.8 121.25,163.29 v3(121.27,163.29) ; VRAM2.P3 122.44,152.45 122.01,152.88 121.31,152.88 v3(121.12,153.07)
  TOP w0.152: v3(124.78,159.42) 124.78,159.85 125.68,160.75 126,160.75 126.84,161.59 126.84,162.42 129.9,165.48 129.9,167.47 128.58,168.79 128.58,169.55 128.26,169.87 127.64,169.87 127.44,170.07 127.44,171.54 127.64,171.75 132.99,171.75 133.19,171.54 133.19,169.35 133.81,168.73 133.81,167.13 135.08,165.86 135.08,165.64 135.38,165.34 136.61,165.34 137.01,164.94 138.97,164.94 139.42,165.38 v3(139.63,165.38)
  IN1 w0.133: v3(121.27,163.29) 121.08,163.48 119.93,163.48 119.82,163.6 119.82,163.76 119.93,163.87 121.33,163.87 121.91,163.29 122.07,163.29 124.52,160.85 124.52,159.68 v3(124.78,159.42) 124.79,159.4 124.79,158.79 125.15,158.44 125.15,156.65 124.84,156.35 124.84,155.09 124.17,154.41 123.58,154.41 122.1,152.93 121.26,152.93 v3(121.12,153.07)
  BOTTOM w0.127: v3(121.12,153.07) 121.12,152.97 120.94,152.79 120,152.79 119.66,152.45 VRAM4.P3 ; v3(121.27,163.29) 121.5,163.52 121.74,163.52 121.91,163.34 122.08,163.34 122.4,163.66 122.4,163.81 122.53,163.94 VRAM3.P3
  BOTTOM w0.152: U19.F23 v3(139.63,165.38)
FBA_CMD9: length 63
  TOP w0.127: VRAM1.N3 120.73,164.74 121.07,164.41 v3(121.22,164.41) ; v3(121.54,152.17) 121.54,151.96 121.62,151.88 121.85,151.88 122.03,152.06 122.15,152.06 122.29,151.92 122.29,151.79 122.15,151.64 122.15,151.51 122.24,151.42 122.52,151.42 VRAM2.N3
  TOP w0.152: v3(139.61,164.49) 139.39,164.71 139.27,164.71 139.04,164.48 136.76,164.48 v3(136.53,164.71) 136.36,164.88 135.19,164.88 134.62,165.45 134.62,165.67 133.33,166.96 133.33,167.3 133.18,167.45 132.89,167.45 132.73,167.61 132.73,167.84 132.89,168 133.17,168 133.35,168.18 133.35,168.43 133.17,168.61 132.88,168.61 132.73,168.76 132.73,171.09 132.53,171.29 128.06,171.29 127.89,171.12 127.89,170.78 128.06,170.6 128.37,170.6 128.53,170.45 128.53,170.25 129.04,169.74 129.04,168.98 130.35,167.66 130.35,165.29 127.29,162.23 127.29,161.4 126.19,160.29 125.87,160.29 125.68,160.1 v3(125.68,159.78)
  IN1 w0.133: v3(121.22,164.41) 120.87,164.41 120.74,164.54 120.74,164.72 120.87,164.86 121.42,164.86 121.85,164.43 122.03,164.43 124.68,161.77 125.93,161.77 126.05,161.65 126.05,161.48 125.93,161.36 125.81,161.36 125.69,161.24 125.69,161.07 125.81,160.96 126.03,160.96 126.15,160.84 126.15,160.68 126.03,160.56 125.85,160.56 125.75,160.46 125.75,160.31 125.85,160.21 126.01,160.21 126.14,160.09 126.14,159.91 126.01,159.78 v3(125.68,159.78) 125.68,159.56 125.96,159.28 125.96,154.58 125.12,153.74 123.83,153.74 122.26,152.17 v3(121.54,152.17)
  BOTTOM w0.127: v3(121.22,164.41) 121.22,164.52 121.36,164.66 121.68,164.66 121.78,164.56 122.36,164.56 122.55,164.74 VRAM3.N3 ; v3(121.54,152.17) 121.48,152.17 121.04,151.73 120.47,151.73 120.31,151.89 119.9,151.89 119.66,151.65 VRAM4.N3
  BOTTOM w0.152: v3(139.61,164.49) 139.62,164.49 139.62,164.49 139.69,164.49 U19.G22
FBA_CMD10: length 65
  TOP w0.127: v3(121.08,162.15) 121.09,162.15 122.04,162.15 122.64,162.75 122.92,162.75 123.14,162.97 123.14,163.24 123.55,163.65 VRAM1.P8 ; v3(120.26,153.27) 120.26,153.09 120.19,153.02 119.92,153.02 119.75,152.84 119.47,152.84 119.37,152.94 119.19,152.94 119.06,152.81 119.06,152.63 119.19,152.49 119.19,152.32 118.87,151.99 118.48,151.99 118.36,151.87 118.21,151.87 118.11,151.98 118.11,152.12 118.43,152.45 VRAM2.P8
  IN1 w0.133: v3(121.08,162.15) 120.71,162.51 120.72,162.73 120.87,162.89 121.09,162.89 121.59,162.4 122.06,162.4 123.95,160.51 123.95,158.4 v3(124.04,158.32) 124.11,158.25 124.11,156.79 123.55,156.23 123.55,155.55 121.87,153.88 121.51,153.88 121.22,153.59 120.58,153.59 v3(120.26,153.27)
  BOTTOM w0.127: VRAM3.P8 118.75,163.64 118.84,163.54 119.78,163.54 119.95,163.38 119.95,162.9 120.25,162.6 120.62,162.6 v3(121.08,162.15) ; VRAM4.P8 123.35,152.45 122.97,152.83 122.68,152.83 122.36,153.16 122.36,153.58 122.1,153.84 121.76,153.84 121.43,153.5 120.94,153.5 120.7,153.26 120.26,153.26 v3(120.26,153.27)
  BOTTOM w0.152: v3(124.04,158.32) 124.04,157.99 124.3,157.73 125.3,157.73 125.45,157.88 125.45,158.13 124.92,158.67 124.92,158.91 125.33,159.32 125.33,159.49 125.24,159.58 125.24,159.6 125.1,159.74 125.1,160.01 125.46,160.37 125.99,160.37 126.13,160.23 126.13,160.06 126.26,159.92 126.46,159.92 126.6,160.06 126.6,160.24 126.72,160.37 126.91,160.37 130.74,164.2 130.74,171.54 130.9,171.7 133.1,171.7 133.3,171.49 133.3,166.16 134.93,164.53 138.99,164.53 139.19,164.33 U19.G23
FBA_CMD11: length 59.2
  TOP w0.127: v3(121.79,162.87) 121.68,162.98 121.68,163.2 121.93,163.44 122.14,163.44 122.26,163.56 123.12,163.56 123.21,163.65 123.21,163.84 123.11,163.94 VRAM1.P7 ; VRAM2.P7 119.68,152.45 120.02,152.79 120.37,152.79 120.69,153.1 120.69,153.23 120.95,153.49 121.84,153.49 v3(121.92,153.4)
  TOP w0.152: v3(124.69,158.23) 125.61,158.23 125.91,158.54 125.91,159.35 127.75,161.19 127.75,162.04 130.81,165.1 130.81,167.85 130.51,168.15 130.51,168.37 130.81,168.67 130.81,168.91 130.64,169.08 130.41,169.08 130.1,168.78 129.88,168.78 129.49,169.17 129.49,169.47 129.67,169.65 130.63,169.65 130.81,169.83 130.81,170.09 130.63,170.27 129.15,170.27 128.98,170.44 128.98,170.67 129.15,170.83 132.11,170.83 132.27,170.67 132.27,167.37 134.16,165.48 134.16,165.26 135.21,164.22 135.21,163.75 135.36,163.59 135.59,163.59 135.74,163.75 135.74,164.28 135.88,164.42 136.08,164.42 136.5,164 137.71,164 v3(137.99,163.72)
  IN1 w0.133: v3(121.92,153.4) 123.9,155.38 123.9,156.14 124.69,156.93 v3(124.69,158.23) 124.69,158.31 124.22,158.79 124.22,160.72 122.06,162.87 v3(121.79,162.87)
  BOTTOM w0.127: VRAM3.P7 119.78,163.94 120.12,163.61 120.45,163.61 120.84,163.22 120.84,163.11 121.09,162.85 121.77,162.85 v3(121.79,162.87) ; VRAM4.P7 123.01,152.45 123.14,152.32 123.14,152.13 123.01,151.99 122.63,151.99 121.92,152.7 v3(121.92,153.4)
  BOTTOM w0.152: U19.G24 137.99,163.74 v3(137.99,163.72)
