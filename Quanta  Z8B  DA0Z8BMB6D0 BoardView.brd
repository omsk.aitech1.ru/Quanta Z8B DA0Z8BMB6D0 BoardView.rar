# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_A12: length 68.8
  IN1 w0.089: 103.79,80.82 104.97,82 104.97,82.5 105.33,82.86 105.33,84.99 105.49,85.16 v3(105.93,85.16)
  IN1 w0.216: 103.79,80.82 103.79,80.29 95.34,71.84 95.34,70.19 94.01,68.86 94.01,58.93 93.93,58.85 93.93,53.38 93.52,52.97 93.52,49.07 96.63,45.95 96.63,42.83 96.27,42.47 94.8,42.47 94.29,41.95 94.29,39.03 94.85,38.47 97.49,38.47 97.85,38.83 v3(97.85,40.86)
  BOTTOM w0.178: v3(105.93,85.16) 105.93,85.22 U27.AD4
  BOTTOM w0.191: JDIM2.83 101.05,45.8 98.33,43.07 98.33,41.33 v3(97.85,40.86)
M_A_A13: length 62.8
  IN1 w0.089: 117.27,80.74 117.27,81.09 117.33,81.15 117.33,86.45 117.1,86.68 116.59,86.68 116.36,86.91 116.36,87.42 116.23,87.56 115.52,87.56 115.32,87.75 114.68,87.75 114.53,87.91 114.53,88.54 114.32,88.75 113.07,88.75 112.93,88.61 v3(112.93,88.16)
  IN1 w0.216: 117.27,80.74 117.27,67.9 115.49,66.12 115.49,63.88 112.52,60.91 111.83,60.91 111.5,60.57 111.5,59.85 111.31,59.67 110.72,59.67 110.54,59.49 110.54,59.23 110.72,59.05 111.31,59.05 111.5,58.86 111.5,57.75 111.01,57.27 111.01,54.45 110.6,54.04 110.27,54.04 110,53.78 110,50.7 109.86,50.56 109.86,47.88 109.72,47.74 109.72,46.24 109.86,46.1 109.86,43.91 110.06,43.72 v3(110.36,43.72)
  BOTTOM w0.178: v3(112.93,88.16) U27.V7
  BOTTOM w0.191: JDIM2.119 111.85,45.91 112.15,45.61 112.15,44.65 112.58,44.22 112.58,43.66 111.61,42.68 110.78,42.68 110.36,43.11 v3(110.36,43.72)
M_A_A14: length 67.2
  IN1 w0.089: 105.79,80.51 105.79,81.04 106.33,81.58 106.33,82.67 106.51,82.85 106.51,83.25 105.93,83.83 v5(105.93,84.16)
  IN1 w0.216: 105.79,80.51 105.79,79.86 104.26,78.33 104.26,77.66 103.75,77.15 103.75,76.17 104.32,75.6 104.32,75.34 104.13,75.16 103.87,75.16 103.43,75.6 103.18,75.6 102.99,75.42 102.99,75.16 103.43,74.72 103.43,74.46 103.25,74.28 102.99,74.28 102.55,74.72 102.3,74.72 102.11,74.54 102.11,74.28 102.55,73.84 102.55,73.58 102.37,73.4 102.11,73.4 101.67,73.84 101.42,73.84 101.23,73.66 101.23,73.4 101.67,72.96 101.67,72.7 101.49,72.52 101.23,72.52 100.79,72.96 100.53,72.96 100.35,72.78 100.35,72.52 100.79,72.08 100.79,71.82 100.61,71.64 100.35,71.64 99.91,72.08 99.65,72.08 99.47,71.9 99.47,71.64 99.91,71.2 99.91,70.94 99.73,70.76 99.47,70.76 99.03,71.2 98.77,71.2 98.59,71.02 98.59,70.76 99.03,70.32 99.03,70.06 98.85,69.88 98.59,69.88 98.15,70.32 97.89,70.32 97.71,70.14 97.71,69.88 98.15,69.44 98.15,69.18 97.97,69 97.71,69 97.27,69.44 97.01,69.44 96.83,69.26 96.83,69 97.27,68.56 97.27,68.3 97.09,68.12 96.83,68.12 96.39,68.56 96.13,68.56 95.73,68.15 95.73,58.61 95.23,58.12 95.23,52.49 95.36,52.36 95.36,49.65 98.12,46.89 98.12,46.28 97.95,46.11 97.95,42.77 98.34,42.39 98.34,42.22 v3(98.8,41.76)
  BOTTOM w0.178: v5(105.93,84.16) 105.93,84.22 U27.AD3
  BOTTOM w0.191: JDIM2.80 100.15,40.41 v3(98.8,41.76)
M_A_A15: length 66
  IN1 w0.089: 104.47,81.07 105.37,81.97 105.37,82.55 105.5,82.67 106.02,82.67 106.21,82.87 106.21,83.08 106.14,83.16 v3(105.93,83.16)
  IN1 w0.216: 104.47,81.07 104.47,80.16 96.76,72.45 96.76,72.22 97.2,71.78 97.2,71.52 97.02,71.34 96.76,71.34 96.32,71.78 96.09,71.78 95.91,71.6 95.91,71.27 96.3,70.88 96.3,70.34 94.59,68.63 94.59,58.82 94.42,58.65 94.42,53.21 94.09,52.88 94.09,49.3 97.08,46.31 97.08,42.44 96.54,41.89 95.24,41.89 95.06,41.72 95.06,41.23 95.24,41.05 96.31,41.05 96.55,40.81 96.55,40.02 96.3,39.77 95.25,39.77 95.05,39.57 95.05,39.24 95.24,39.05 97.09,39.05 97.28,39.23 97.28,40.96 97.74,41.42 98.2,41.42 v3(98.63,40.99)
  BOTTOM w0.178: U27.AD2 105.93,83.22 v3(105.93,83.16)
  BOTTOM w0.191: v3(98.63,40.99) 98.96,40.99 99.55,40.4 JDIM2.78
M_A_BS#0: length 67.7
  IN1 w0.089: 115.56,81.45 115.56,81.67 115.67,81.78 115.67,82.71 115.78,82.82 116.08,82.82 116.26,83 116.26,83.46 116.06,83.66 115.72,83.66 115.52,83.86 115.52,85.47 115.23,85.75 114.65,85.75 114.44,85.96 114.44,86.51 114.29,86.66 113.58,86.66 113.48,86.56 113.48,85.91 113.36,85.79 113.01,85.79 112.93,85.87 v3(112.93,86.16)
  IN1 w0.216: 115.56,81.45 115.56,68.61 109.42,62.48 109.42,61.94 108.82,61.34 108.82,55.99 108.28,55.45 108.28,48.41 108.01,48.13 108.01,45.97 108.1,45.88 108.1,44.45 108.28,44.27 108.28,41.84 108.63,41.49 109.19,41.49 109.69,40.98 109.69,38.86 109.88,38.68 110.13,38.68 110.32,38.86 110.32,41.27 109.37,42.22 v3(108.87,42.22)
  BOTTOM w0.178: v3(112.93,86.16) 112.93,86.58 112.83,86.69 U27.V5
  BOTTOM w0.191: JDIM2.109 108.85,45.86 109.05,45.67 109.05,44.34 109.43,43.96 109.43,42.42 109.23,42.22 v3(108.87,42.22)
M_A_BS#1: length 69.6
  IN1 w0.089: 114.98,81.45 114.98,81.52 115.33,81.87 115.33,85.32 115.1,85.56 114.53,85.56 v3(113.93,86.16)
  IN1 w0.216: v3(109.12,40.69) 109.12,38.3 109.33,38.09 109.84,38.09 110.04,37.9 110.04,37.63 109.84,37.43 108.69,37.43 108.48,37.64 108.48,41.03 107.78,41.73 107.78,44.18 107.53,44.44 107.53,45.57 107.32,45.78 107.32,48.05 107.88,48.6 107.88,50.44 107.7,50.61 107.7,55.67 108.2,56.17 108.2,57.72 108.02,57.9 106.91,57.9 106.73,58.09 106.73,58.34 106.91,58.53 108.02,58.53 108.2,58.71 108.2,58.97 108.02,59.15 106.52,59.15 106.34,59.33 106.34,59.59 106.52,59.77 108.02,59.77 108.2,59.95 108.2,60.21 108.02,60.39 107.15,60.39 106.97,60.58 106.97,60.83 107.15,61.02 108.02,61.02 108.2,61.2 108.2,61.53 108.85,62.17 108.85,62.71 114.98,68.85 114.98,81.45
  BOTTOM w0.178: v3(113.93,86.16) U27.U5
  BOTTOM w0.191: v3(109.12,40.69) 109.12,40.51 108.55,39.94 JDIM2.108
M_A_BS#2: length 65.5
  IN1 w0.102: 105.01,80.51 105.01,81.2 105.24,81.43 105.82,81.43 105.93,81.53 v3(105.93,82.16)
  IN1 w0.216: v3(97.87,42.14) 97.54,42.47 97.54,46.66 94.66,49.54 94.66,52.85 94.83,53.01 94.83,58.42 95.16,58.75 95.16,68.39 98.77,72.01 98.77,72.26 98.21,72.83 98.21,73.09 98.39,73.27 98.65,73.27 99.21,72.7 99.47,72.7 99.65,72.89 99.65,73.14 99.09,73.71 99.09,73.97 99.27,74.15 99.53,74.15 100.09,73.58 100.35,73.58 100.53,73.77 100.53,74.02 99.97,74.59 99.97,74.85 100.15,75.03 100.41,75.03 100.97,74.46 101.23,74.46 101.41,74.65 101.41,74.9 100.85,75.47 100.85,75.73 101.03,75.91 101.29,75.91 101.85,75.35 102.11,75.35 102.29,75.53 102.29,75.79 101.73,76.35 101.73,76.61 101.91,76.79 102.17,76.79 102.73,76.23 102.99,76.23 103.18,76.41 103.18,76.68 102.64,77.21 102.64,77.52 102.81,77.69 103.48,77.69 103.69,77.89 103.69,78.57 105.01,79.89 105.01,80.51
  BOTTOM w0.178: U27.AD1 106.4,82.05 106.29,81.95 106.14,81.95 v3(105.93,82.16)
  BOTTOM w0.191: JDIM2.79 99.85,45.82 98.53,44.5 97.11,44.5 96.93,44.32 96.93,43.96 97.11,43.78 97.62,43.78 97.87,43.52 v3(97.87,42.14)
M_A_CAS#: length 62.9
  IN1 w0.089: v3(113.93,89.16) 114.38,89.6 115.29,89.6 115.5,89.4 115.5,88.02 115.76,87.75 116.1,87.75 116.41,88.07 116.41,89.48 116.56,89.63 117.33,89.63 117.52,89.44 117.52,81.99 117.84,81.67
  IN1 w0.216: v3(110.36,45.09) 110.3,45.15 110.3,50.35 110.71,50.76 110.71,51.7 112.07,53.06 112.07,59.65 116.06,63.65 116.06,65.89 117.84,67.66 117.84,81.67
  BOTTOM w0.178: U27.U8 v3(113.93,89.16)
  BOTTOM w0.191: JDIM2.115 110.65,45.76 110.8,45.62 111.43,45.62 111.61,45.44 111.61,43.33 111.46,43.18 111.08,43.18 110.9,43.35 110.9,44.95 110.77,45.09 v3(110.36,45.09)
M_A_CKE0: length 57.2
  IN1 w0.089: v3(105.93,90.16) 105.4,89.63 105.4,89.06 105.04,88.69 104.63,88.69 104.33,88.39 104.33,81.99 103.23,80.89 102.7,80.89 102.59,80.78
  IN1 w0.216: v3(95.64,45.16) 95.64,45.26 92.32,48.57 92.32,52.95 93.07,53.7 93.07,58.62 92.82,58.87 92.82,69.36 94.09,70.63 94.09,72.28 102.59,80.78
  BOTTOM w0.178: v3(105.93,90.16) 105.93,90.22 U27.AD9
  BOTTOM w0.191: JDIM2.73 98.05,46 97.21,45.16 v3(95.64,45.16)
M_A_CKE1: length 60.2
  IN1 w0.089: v3(106.93,90.16) 105.43,88.65 105.43,88.08 104.97,87.63 104.84,87.63 104.53,87.32 104.53,87.32 104.52,87.31 104.52,81.9 103.18,80.55
  IN1 w0.216: 103.18,80.55 94.72,72.1 94.72,70.45 93.39,69.12 93.39,53.48 92.9,52.98 92.9,48.81 96.17,45.54 v3(96.17,43.18)
  BOTTOM w0.178: U27.AC9 106.93,90.22 v3(106.93,90.16)
  BOTTOM w0.191: JDIM2.74 98.35,39.72 96.17,41.9 v3(96.17,43.18)
M_A_CLKN0: length 59.3
  IN1 w0.089: 113.02,81.88 113.02,81.88 112.97,81.93 112.97,82.37 112.51,82.84 112.51,84.47 112.59,84.56 113.33,84.56 113.53,84.76 113.53,85.01 113.67,85.16 v3(113.93,85.16)
  IN1 w0.133: v3(105.72,43.46) 105.51,43.67 105.51,44.61 105.36,44.77 105.36,50.51 104.42,51.45 104.42,52.08 104.13,52.37 103.75,52.37 103.62,52.51 103.62,52.78 103.75,52.91 104.13,52.91 104.42,53.2 104.42,56.79 104.07,57.15 104.07,60.1 105,61.04 105,61.65 111.86,68.5 111.86,71.4 112.03,71.58 112.69,71.58 113.02,71.91 113.02,73.49 112.73,73.78 112.09,73.78 111.96,73.91 111.96,74.19 112.09,74.32 112.7,74.32 112.99,74.61 112.99,75.11 112.7,75.41 112.07,75.41 111.93,75.54 111.93,75.81 112.07,75.95 112.73,75.95 113.02,76.24 113.02,81.88
  BOTTOM w0.114: v3(113.93,85.16) U27.U4
  BOTTOM w0.127: JDIM2.103 107.05,45.85 106.89,45.68 106.89,45.36 107.14,45.11 107.14,44.22 106.84,43.92 106.35,43.92 106.05,44.22 106.05,44.43 105.88,44.6 105.62,44.6 105.49,44.48 105.49,43.69 v3(105.72,43.46)
M_A_CLKN1: length 57.8
  IN1 w0.089: v3(113.94,84.24) 113.66,83.96 113.66,82.48 113.78,82.36 113.78,81.9 113.83,81.85 113.83,81.83
  IN1 w0.133: 113.83,81.83 113.83,71.04 113.55,70.76 112.8,70.76 112.67,70.63 112.67,70.36 112.8,70.22 113.51,70.22 113.83,69.91 113.83,69.45 113.49,69.11 112.87,69.11 112.67,68.91 112.67,68.16 105.82,61.31 105.82,60.7 104.88,59.76 104.88,57.53 105.23,57.18 105.23,53.41 105.37,53.28 105.83,53.28 106.13,52.98 106.13,52.48 105.83,52.19 105.37,52.19 105.23,52.06 105.23,51.78 105.37,51.65 105.71,51.65 106.17,51.19 106.17,45.14 106.32,44.98 106.32,44.01 106.56,43.78 106.56,43.09 105.64,42.17 105.64,41.36 105.86,41.14 106.2,41.14 106.43,41.37 v3(106.43,41.88)
  BOTTOM w0.114: U27.U3 113.84,84.24 v3(113.94,84.24)
  BOTTOM w0.127: v3(106.43,41.88) 106.8,41.51 107.28,41.51 107.56,41.23 107.56,40.76 107.21,40.4 107.21,40.02 107.35,39.88 JDIM2.104
M_A_CLKP0: length 59.3
  IN1 w0.089: 112.75,81.88 112.79,81.93 112.79,82.3 112.33,82.76 112.33,84.55 112.52,84.73 113.25,84.73 113.35,84.83 113.35,85.01 113.21,85.16 v5(112.93,85.16)
  IN1 w0.133: 112.75,81.88 112.75,81.88 112.75,76.35 112.61,76.22 111.95,76.22 111.66,75.93 111.66,75.43 111.95,75.13 112.59,75.13 112.72,75 112.72,74.73 112.59,74.59 111.98,74.59 111.69,74.3 111.69,73.8 111.98,73.51 112.61,73.51 112.75,73.37 112.75,72.02 112.57,71.85 111.92,71.85 111.58,71.52 111.58,68.61 104.73,61.76 104.73,61.15 103.79,60.21 103.79,57.04 104.15,56.68 104.15,53.32 104.01,53.18 103.64,53.18 103.34,52.89 103.34,52.39 103.64,52.1 104.01,52.1 104.15,51.97 104.15,51.33 105.09,50.4 105.09,44.65 105.24,44.5 105.24,43.66 v3(105.04,43.46)
  BOTTOM w0.114: U27.V4 v5(112.93,85.16)
  BOTTOM w0.127: v3(105.04,43.46) 105.23,43.65 105.23,44.59 105.51,44.87 106,44.87 106.32,44.54 106.32,44.33 106.46,44.19 106.73,44.19 106.87,44.33 106.87,45 106.62,45.25 106.62,45.68 106.45,45.85 JDIM2.101
M_A_CLKP1: length 57.8
  IN1 w0.089: 113.56,81.83 113.56,81.84 113.61,81.89 113.61,82.29 113.48,82.41 113.48,83.6 v3(112.93,84.16)
  IN1 w0.133: 113.56,81.83 113.56,71.15 113.44,71.04 112.69,71.04 112.4,70.74 112.4,70.24 112.69,69.95 113.4,69.95 113.56,69.79 113.56,69.56 113.38,69.39 112.75,69.39 112.4,69.03 112.4,68.28 105.54,61.42 105.54,60.81 104.6,59.87 104.6,57.42 104.96,57.06 104.96,53.3 105.25,53 105.72,53 105.85,52.87 105.85,52.6 105.72,52.46 105.25,52.46 104.96,52.17 104.96,51.67 105.25,51.38 105.6,51.38 105.9,51.07 105.9,45.02 106.05,44.87 106.05,43.9 106.28,43.67 106.28,43.2 105.36,42.29 105.36,41.25 105.75,40.87 106.15,40.87 v3(106.43,40.59)
  BOTTOM w0.114: v3(112.93,84.16) U27.V3
  BOTTOM w0.127: JDIM2.102 106.75,39.74 106.94,39.93 106.94,40.51 107.3,40.87 107.3,41.12 107.17,41.25 106.56,41.25 106.43,41.12 v3(106.43,40.59)
M_A_CS#0: length 61.9
  IN1 w0.216: v3(118.93,88.16) 118.93,87.9 118.47,87.44 118.47,80.39 118.46,80.39 118.46,67.41 116.69,65.63 116.69,63.39 112.69,59.39 112.69,52.8 111.33,51.44 111.33,48.71 110.93,48.3 110.93,42.07 111.56,41.43 111.56,37.61 111.38,37.43 111.12,37.43 110.94,37.61 v3(110.94,41.09)
  BOTTOM w0.178: v3(118.93,88.16) U27.M7
  BOTTOM w0.191: v3(110.94,41.09) 110.52,41.09 110.35,40.93 JDIM2.114
M_A_CS#1: length 63.1
  IN1 w0.089: 121.43,82 121.43,87.23 121.04,87.62 121.04,88.46 121.43,88.85 121.43,89.54 121.26,89.71 120.81,89.71 120.36,90.16 v3(119.93,90.16)
  IN1 w0.216: 121.43,82 120.84,81.4 120.84,64.32 117.93,61.41 117.93,60.53 117.74,60.34 117.49,60.34 117.3,60.53 117.04,60.53 116.86,60.35 116.86,60.09 117.05,59.9 117.05,59.65 116.86,59.46 116.61,59.46 116.42,59.65 116.16,59.65 115.98,59.47 115.98,59.21 116.42,58.76 116.42,58.51 116.24,58.32 115.98,58.32 115.56,58.75 115.27,58.75 115.04,58.53 115.04,58.24 115.57,57.72 115.57,52.35 113.84,50.62 113.84,48 113.2,47.36 113.2,47.02 113.34,46.88 113.64,46.88 113.84,46.69 113.84,46.46 113.24,45.86 v3(113.24,44.4)
  BOTTOM w0.178: v3(119.93,90.16) U27.L9
  BOTTOM w0.191: v3(113.24,44.4) 113.54,44.09 113.54,43.53 113.69,43.38 113.97,43.38 114.15,43.55 114.15,45.47 113.93,45.69 113.57,45.69 113.36,45.48 113.36,45.22 113.17,45.03 112.9,45.03 112.71,45.22 112.71,45.64 112.45,45.89 JDIM2.121
M_A_DQ0: length 81.7
  IN1 w0.133: v5(94.93,96.16) 94.51,96.58 90.83,96.58 88.07,93.82 80.32,93.82 68.64,82.14 68.64,71.16 67.6,70.12 67.6,60.84 65.87,59.11 65.87,51.98 70.3,47.54 70.3,46.61 72.9,44.01 72.95,44.01 74.05,42.91 v3(74.05,42.14)
  BOTTOM w0.114: v5(94.93,96.16) 94.93,96.22 U27.AR15
  BOTTOM w0.127: JDIM2.6 75.55,39.9 75.29,40.16 75.29,40.9 v3(74.05,42.14)
M_A_DQ1: length 79.8
  IN1 w0.133: v5(93.93,95.16) 91.05,95.16 88.51,92.61 80.76,92.61 70.9,82.76 70.9,79.25 70.39,78.73 70.39,78.41 70.52,78.27 70.77,78.27 70.9,78.14 70.9,77.85 70.77,77.72 70.47,77.72 70.34,77.58 70.34,77.31 70.47,77.18 70.77,77.18 70.9,77.04 70.9,76.51 70.34,75.94 70.34,71.21 68.76,69.64 68.76,60.36 67.09,58.68 67.09,52.42 68.51,51 69.44,51 74.64,45.8 74.64,41.16 v3(74.38,40.9)
  BOTTOM w0.114: U27.AT14 93.93,95.22 v5(93.93,95.16)
  BOTTOM w0.127: v3(74.38,40.9) 74.95,40.32 JDIM2.4
M_A_DQ2: length 85.8
  IN1 w0.089: v3(97.93,95.16) 97.48,94.7 97.48,92.99 97.06,92.58 93.27,92.58 92.98,92.28 91.82,92.28
  IN1 w0.133: v3(79.07,42.16) 78.57,42.67 78.57,43.4 77.71,44.26 77.71,46.29 69.68,54.32 69.68,57.72 71.81,59.85 71.81,67.55 74.13,69.88 74.13,70.26 74,70.4 73.55,70.4 73.42,70.53 73.42,70.8 73.55,70.94 74,70.94 74.13,71.07 74.13,71.34 74,71.48 73.55,71.48 73.42,71.61 73.42,71.88 73.55,72.02 74,72.02 74.13,72.15 74.13,72.42 74,72.56 73.55,72.56 73.42,72.69 73.42,72.96 73.55,73.1 74,73.1 74.13,73.23 74.13,73.5 74,73.63 73.55,73.63 73.42,73.77 73.42,74.04 73.55,74.17 74,74.17 74.13,74.31 74.13,74.58 74,74.71 73.55,74.71 73.42,74.85 73.42,75.12 73.55,75.25 74,75.25 74.13,75.39 74.13,79.64 74.76,80.26 74.76,83.06 81.3,89.6 85.6,89.6 85.91,89.91 89.36,89.91 91.73,92.28 91.82,92.28
  BOTTOM w0.114: v3(97.93,95.16) 97.93,95.22 U27.AM14
  BOTTOM w0.127: v3(79.07,42.16) 79.15,42.08 JDIM2.18
M_A_DQ3: length 84.7
  IN1 w0.089: v3(96.93,95.16) 96.93,94.8 96.53,94.4 96.53,93.08 96.2,92.75 91.82,92.75
  IN1 w0.133: v3(77.33,41.56) 78.08,42.31 78.08,43.33 77.32,44.1 77.32,46.13 69.27,54.18 69.27,57.86 71.43,60.02 71.43,60.43 71.29,60.56 71.02,60.56 70.89,60.7 70.89,60.97 71.02,61.1 71.29,61.1 71.43,61.24 71.43,61.51 71.29,61.64 71.02,61.64 70.89,61.78 70.89,63.2 71.02,63.33 71.29,63.33 71.43,63.47 71.43,63.74 71.29,63.87 71.02,63.87 70.89,64.01 70.89,65.5 71.02,65.63 71.29,65.63 71.43,65.77 71.43,66.04 71.29,66.17 71.02,66.17 70.89,66.31 70.89,67.18 73.03,69.32 73.03,75.51 73.16,75.64 73.61,75.64 73.75,75.77 73.75,76.05 73.61,76.18 73.16,76.18 73.03,76.31 73.03,76.59 73.16,76.72 73.61,76.72 73.75,76.85 73.75,79.8 74.37,80.42 74.37,83.22 81.29,90.14 85.53,90.14 85.78,90.39 89.3,90.39 91.66,92.75 91.82,92.75
  BOTTOM w0.114: U27.AN14 96.93,95.22 v3(96.93,95.16)
  BOTTOM w0.127: JDIM2.16 78.55,40.72 77.72,41.56 v3(77.33,41.56)
M_A_DQ4: length 79.8
  IN1 w0.133: v3(72.83,44.78) 70.69,46.91 70.69,48.65 69.12,50.22 68.18,50.22 66.27,52.13 66.27,58.97 67.99,60.68 67.99,69.96 69.56,71.54 69.56,71.92 69.43,72.06 69.16,72.06 69.02,72.19 69.02,72.46 69.16,72.6 69.43,72.6 69.56,72.73 69.56,73 69.43,73.14 69.16,73.14 69.02,73.27 69.02,73.54 69.16,73.68 69.43,73.68 69.56,73.81 69.56,74.08 69.43,74.21 69.16,74.21 69.02,74.35 69.02,74.62 69.16,74.75 69.43,74.75 69.56,74.89 69.56,82.52 80.44,93.39 88.19,93.39 90.95,96.16 v3(93.93,96.16)
  BOTTOM w0.114: v3(93.93,96.16) 93.93,96.22 U27.AT15
  BOTTOM w0.127: v3(72.83,44.78) 73.11,44.5 74.1,44.5 75.25,45.65 JDIM2.5
M_A_DQ5: length 81.3
  IN1 w0.133: v3(74.15,43.56) 74.15,43.58 74.21,43.63 74.21,45.69 69.28,50.61 68.34,50.61 66.68,52.27 66.68,58.83 68.37,60.52 68.37,69.8 69.95,71.37 69.95,80.08 70.08,80.21 70.38,80.21 70.51,80.35 70.51,80.62 70.38,80.75 70.08,80.75 69.95,80.89 69.95,81.16 70.08,81.29 70.38,81.29 70.51,81.43 70.51,81.7 70.38,81.83 70.08,81.83 69.95,81.97 69.95,82.35 80.6,93 88.35,93 90.97,95.63 94.45,95.63 94.93,95.16 v3(94.93,95.16)
  BOTTOM w0.114: v3(94.93,95.16) 94.93,95.22 U27.AR14
  BOTTOM w0.127: v3(74.15,43.56) 74.59,43.56 75.85,44.83 JDIM2.7
M_A_DQ6: length 84.2
  IN1 w0.089: v3(96.93,96.16) 96.33,95.56 96.33,94.97 96.03,94.66 95.75,94.66 95.44,94.36 95.44,93.96 95.23,93.75 93.4,93.75 93.18,93.53 91.82,93.53
  IN1 w0.133: v3(77.55,43.22) 76.67,43.22 76.48,43.4 76.48,44.28 76,44.77 76,46.36 68.46,53.9 68.46,58.14 70.11,59.8 70.11,69.08 72.25,71.22 72.25,71.61 72.12,71.74 71.82,71.74 71.69,71.87 71.69,72.15 71.82,72.28 72.12,72.28 72.25,72.41 72.25,72.69 72.12,72.82 71.82,72.82 71.69,72.95 71.69,73.22 71.82,73.36 72.12,73.36 72.25,73.49 72.25,73.76 72.12,73.9 71.82,73.9 71.69,74.03 71.69,74.3 71.82,74.44 72.12,74.44 72.25,74.57 72.25,74.84 72.12,74.98 71.82,74.98 71.69,75.11 71.69,75.38 71.82,75.52 72.12,75.52 72.25,75.65 72.25,82.2 81.32,91.26 89.07,91.26 91.34,93.53 91.82,93.53
  BOTTOM w0.114: v3(96.93,96.16) 96.93,96.22 U27.AN15
  BOTTOM w0.127: v3(77.55,43.22) 77.55,44.67 78.85,45.97 JDIM2.17
M_A_DQ7: length 84.9
  IN1 w0.089: v3(97.93,96.16) 97.38,95.6 96.74,95.6 96.51,95.37 96.51,94.82 96.33,94.64 96.33,93.95 95.95,93.57 93.7,93.57 93.28,93.14 91.82,93.14
  IN1 w0.133: v3(76.74,44.88) 76.38,45.24 76.38,46.52 68.86,54.04 68.86,58 70.5,59.64 70.5,68.09 72.64,70.23 72.64,76.97 72.78,77.11 73.23,77.11 73.36,77.24 73.36,77.51 73.23,77.65 72.78,77.65 72.64,77.78 72.64,78.05 72.78,78.19 73.23,78.19 73.36,78.32 73.36,78.59 73.23,78.73 72.78,78.73 72.64,78.86 72.64,79.13 72.78,79.27 73.23,79.27 73.36,79.4 73.36,79.67 73.23,79.81 72.78,79.81 72.64,79.94 72.64,80.21 72.78,80.35 73.75,80.35 73.88,80.48 73.88,80.87 73.75,81 72.78,81 72.64,81.13 72.64,81.41 72.78,81.54 73.72,81.54 73.85,81.67 73.85,81.95 73.72,82.08 73.22,82.08 73.09,82.21 73.09,82.49 73.22,82.62 73.67,82.62 73.82,82.77 73.82,83.21 81.48,90.87 89.23,90.87 91.5,93.14 91.82,93.14
  BOTTOM w0.114: v3(97.93,96.16) 97.93,96.22 U27.AM15
  BOTTOM w0.127: v3(76.74,44.88) 77.27,44.88 78.25,45.86 JDIM2.15
M_A_DQ8: length 76.6
  IN1 w0.089: v3(97.93,90.16) 97.46,90.62 96.89,90.62 96.52,91 96.52,91.13 95.92,91.73 91.95,91.73 91.82,91.61
  IN1 w0.133: v3(79.08,43.7) 78.25,44.53 78.25,46.51 70.24,54.53 70.24,57.51 72.35,59.63 72.35,67.33 74.67,69.65 74.67,79.42 75.49,80.24 75.49,83.03 81.25,88.79 89.01,88.79 91.82,91.61
  BOTTOM w0.114: v3(97.93,90.16) 97.93,90.22 U27.AM9
  BOTTOM w0.127: JDIM2.23 80.65,45.28 v3(79.08,43.7)
M_A_DQ9: length 75.2
  IN1 w0.089: v3(96.93,90.16) 96.44,90.65 95.68,90.65 95.41,90.92 95.41,91.36 95.21,91.56 93.6,91.56 93.25,91.2 91.97,91.2 91.82,91.06
  IN1 w0.133: 91.82,91.06 89.12,88.36 81.37,88.36 75.99,82.98 75.99,76.69 75.06,75.75 75.06,69.49 72.74,67.17 72.74,59.47 70.64,57.37 70.64,54.79 75.32,50.12 75.97,50.12 77.29,48.8 77.29,48.61 77.09,48.41 77.09,48.22 77.29,48.03 77.48,48.03 77.68,48.23 77.87,48.23 78.06,48.03 78.06,47.84 77.86,47.64 77.86,47.46 78.05,47.26 78.24,47.26 78.44,47.46 78.63,47.46 79.24,46.85 79.24,46.51 78.64,45.91 78.64,45.31 v3(78.98,44.97)
  BOTTOM w0.114: U27.AN9 96.93,90.22 v3(96.93,90.16)
  BOTTOM w0.127: JDIM2.21 80.05,45.2 79.83,44.97 v3(78.98,44.97)
M_A_DQ10: length 74.6
  IN1 w0.089: 91.82,86.38 93.11,87.66 94.1,87.66 94.33,87.89 94.33,88.29 94.61,88.56 96.9,88.56 97.5,89.16 v3(97.93,89.16)
  IN1 w0.133: v3(83.44,44.26) 83.44,44.7 82.53,45.61 82.53,48.24 78,52.77 78,67.77 79.73,69.51 79.73,82.07 82.26,84.6 85.83,84.6 85.93,84.5 85.93,83.17 86.06,83.04 86.33,83.04 86.47,83.17 86.47,84.51 86.6,84.64 86.87,84.64 87.01,84.51 87.01,83.15 87.14,83.01 87.41,83.01 87.55,83.15 87.55,84.51 87.68,84.64 87.95,84.64 88.09,84.51 88.09,83.3 88.22,83.17 88.49,83.17 88.63,83.3 88.63,84.51 88.76,84.64 90.08,84.64 91.82,86.38
  BOTTOM w0.114: U27.AM8 97.93,89.22 v3(97.93,89.16)
  BOTTOM w0.127: v3(83.44,44.26) 83.87,44.26 84.02,44.41 84.02,45.36 84.25,45.59 JDIM2.35
M_A_DQ11: length 74.3
  IN1 w0.089: 91.82,86.93 93.31,88.42 93.59,88.42 93.74,88.56 94.26,88.56 94.45,88.75 96.53,88.75 v3(96.93,89.16)
  IN1 w0.133: 91.82,86.93 90.18,85.29 82.4,85.29 79.33,82.21 79.33,71.82 78.27,70.76 78.27,68.59 76.99,67.32 76.99,66.74 77.17,66.57 77.46,66.57 77.61,66.41 77.61,66.18 77.48,66.05 77,66.05 76.86,65.91 76.86,65.64 77,65.51 77.48,65.51 77.61,65.37 77.61,65.09 77.48,64.96 77,64.96 76.86,64.83 76.86,64.55 77,64.42 77.48,64.42 77.61,64.29 77.61,64.01 77.48,63.88 77,63.88 76.86,63.75 76.86,63.47 77,63.34 77.48,63.34 77.61,63.21 77.61,62.93 77.48,62.8 76.72,62.8 76.59,62.67 76.59,62.39 76.72,62.26 77.48,62.26 77.61,62.13 77.61,52.59 82.14,48.05 82.14,45.45 82.91,44.68 82.91,43.14 83.25,42.8 v3(83.45,42.8)
  BOTTOM w0.114: v3(96.93,89.16) 96.93,89.22 U27.AN8
  BOTTOM w0.127: JDIM2.36 84.55,41.7 v3(83.45,42.8)
M_A_DQ12: length 73.6
  IN1 w0.089: v3(94.93,90.16) 94.93,90.44 94.61,90.75 92.07,90.75 91.82,90.51
  IN1 w0.133: v3(80.35,40.21) 79.63,40.93 79.63,47.01 75.52,51.12 75.13,51.12 73.51,52.74 73.51,53.36 72.32,54.55 71.78,54.55 71.05,55.29 71.05,57.23 73.13,59.31 73.13,67.01 75.47,69.35 75.47,75.61 76.38,76.53 76.38,82.82 81.44,87.88 89.19,87.88 91.82,90.51
  BOTTOM w0.114: U27.AR9 94.93,90.22 v3(94.93,90.16)
  BOTTOM w0.127: v3(80.35,40.21) 80.35,40.21 JDIM2.22
M_A_DQ13: length 72.5
  IN1 w0.089: 91.82,89.96 92.23,90.37 93.72,90.37 v3(93.93,90.16)
  IN1 w0.133: v3(80.4,41.5) 80.02,41.89 80.02,47.17 74.46,52.73 74.46,59.04 74.33,59.17 73.65,59.17 73.52,59.31 73.52,59.58 73.65,59.71 74.28,59.71 74.41,59.85 74.41,60.12 74.28,60.25 73.65,60.25 73.52,60.39 73.52,60.66 73.65,60.79 74.17,60.79 74.38,61 74.38,62.14 73.52,63 73.52,66.85 75.87,69.21 75.87,75.47 77.09,76.69 77.09,82.99 81.6,87.49 89.35,87.49 91.82,89.96
  BOTTOM w0.114: v3(93.93,90.16) 93.93,90.22 U27.AT9
  BOTTOM w0.127: JDIM2.24 80.95,41.29 80.74,41.5 v3(80.4,41.5)
M_A_DQ14: length 72.8
  IN1 w0.089: 91.82,87.48 93.1,88.75 94.17,88.75 94.57,89.16 v3(94.93,89.16)
  IN1 w0.133: 91.82,87.48 90.04,85.69 82.26,85.69 78.85,82.28 78.85,72.96 77.65,71.76 77.65,68.52 76.47,67.35 76.47,63.62 76.2,63.34 76.2,61.87 76.33,61.74 77.09,61.74 77.22,61.61 77.22,61.33 77.09,61.2 76.33,61.2 76.2,61.07 76.2,60.79 76.33,60.66 77.09,60.66 77.22,60.53 77.22,60.25 77.09,60.12 76.33,60.12 76.2,59.99 76.2,59.71 76.33,59.58 77.09,59.58 77.22,59.45 77.22,59.17 77.09,59.04 76.33,59.04 76.2,58.91 76.2,56.54 76.65,56.09 76.65,53.57 76.9,53.32 76.9,52.75 81.76,47.89 81.76,45.29 82.53,44.52 82.53,42.81 82.73,42.6 82.73,41.6 v3(83.39,40.94)
  BOTTOM w0.114: U27.AR8 94.93,89.22 v3(94.93,89.16)
  BOTTOM w0.127: v3(83.39,40.94) 83.64,40.94 83.95,40.63 JDIM2.34
M_A_DQ15: length 72.4
  IN1 w0.089: 91.82,88.02 92.95,89.16 v3(93.93,89.16)
  IN1 w0.133: v3(82.07,41.4) 82.07,42.35 82.12,42.4 82.12,44.38 81.37,45.13 81.37,47.73 76.51,52.59 76.51,53.16 76.26,53.4 76.26,55.93 75.81,56.38 75.81,63.5 76.09,63.78 76.09,65.09 75.95,65.22 75.49,65.22 75.38,65.33 75.38,65.64 75.5,65.76 75.95,65.76 76.09,65.89 76.09,66.17 75.95,66.3 75.46,66.3 75.33,66.43 75.33,66.71 75.46,66.84 75.95,66.84 76.09,66.97 76.09,67.51 77.25,68.67 77.25,71.9 78.47,73.12 78.47,82.45 82.16,86.14 89.94,86.14 91.82,88.02
  BOTTOM w0.114: v3(93.93,89.16) 93.93,89.22 U27.AT8
  BOTTOM w0.127: v3(82.07,41.4) 82.07,42.03 82.99,42.95 82.99,44.4 83.72,45.13 83.72,45.72 83.65,45.8 JDIM2.33
M_A_DQ16: length 66.4
  IN1 w0.089: v3(100.93,90.16) 100.5,90.16 100.09,89.75 99.96,89.75 99.53,89.32 99.53,88.92 99.16,88.56 98.76,88.56 98.53,88.32 98.53,87.92 98.17,87.56 97.76,87.56 97.53,87.32 97.53,86.91 97.17,86.56 96.76,86.56 96.53,86.32 96.53,85.86 96.22,85.56 93.63,85.56 91.82,83.75
  IN1 w0.133: 91.82,83.75 89.11,81.03 89.11,79.09 83.11,73.1 83.11,72.52 82.35,71.76 82.35,71.01 82.17,70.83 81.63,70.83 81.5,70.7 81.5,70.41 81.63,70.28 82.24,70.28 82.38,70.15 82.38,69.87 82.24,69.74 81.63,69.74 81.5,69.61 81.5,67.84 80.41,66.75 80.41,53.17 82.21,51.37 82.58,51.37 83.62,50.33 83.62,49.57 84.31,48.88 84.31,46.24 85.82,44.73 v3(85.82,43.45)
  BOTTOM w0.114: U27.AJ9 100.93,90.22 v3(100.93,90.16)
  BOTTOM w0.127: v3(85.82,43.45) 86.05,43.68 JDIM2.41
M_A_DQ17: length 65.6
  IN1 w0.089: 91.82,84.44 93.12,85.75 96.09,85.75 96.34,86 96.34,86.4 96.68,86.75 97.09,86.75 97.34,87 97.34,87.4 97.68,87.75 98.09,87.75 98.34,88 98.34,88.4 98.68,88.75 99.09,88.75 99.34,89 99.34,89.47 99.93,90.06 v3(99.93,90.16)
  IN1 w0.133: v3(86.06,40.99) 85.63,41.42 85.63,42.3 85.34,42.58 85.34,44.66 83.92,46.08 83.92,48.72 83.21,49.43 83.21,50.17 82.41,50.98 82.05,50.98 80.02,53.01 80.02,66.91 81.11,68 81.11,71.07 82.71,72.66 82.71,73.32 88.72,79.34 88.72,81.34 91.82,84.44
  BOTTOM w0.114: v3(99.93,90.16) 99.93,90.22 U27.AK9
  BOTTOM w0.127: JDIM2.42 86.35,40.7 v3(86.06,40.99)
M_A_DQ18: length 64.1
  IN1 w0.089: v5(100.93,87.16) 100.52,86.75 99.96,86.75 99.53,86.32 99.53,85.92 99.16,85.56 98.76,85.56 98.52,85.31 98.52,84.91 98.17,84.56 97.71,84.56 97.52,84.37 97.52,83.91 97.17,83.56 96.73,83.56 95.74,82.58 94.21,82.58 93.32,81.68
  IN1 w0.133: v3(88.43,43.17) 89.13,43.87 89.13,44.98 87.17,46.94 87.17,50.34 84.97,52.55 84.97,62.41 84.81,62.56 84.15,62.56 84.01,62.7 84.01,62.97 84.15,63.1 84.83,63.1 84.97,63.24 84.97,63.51 84.83,63.64 84.15,63.64 84.01,63.78 84.01,64.06 84.15,64.2 84.83,64.2 84.97,64.33 84.97,64.6 84.83,64.74 84.15,64.74 84.01,64.87 84.01,66.8 84.94,67.72 84.94,70.79 85.69,71.54 85.69,72.12 87.15,73.58 91.62,78.05 91.62,79.99 93.32,81.68
  BOTTOM w0.114: U27.AJ6 100.93,87.22 v5(100.93,87.16)
  BOTTOM w0.127: v3(88.43,43.17) 88.62,43.17 89.16,43.71 89.16,44.29 89.45,44.59 89.45,45.69 89.65,45.89 JDIM2.53
M_A_DQ19: length 64.1
  IN1 w0.089: v3(99.93,87.16) 99.93,86.99 99.88,86.94 99.88,86.94 99.34,86.4 99.34,86.04 99.04,85.75 98.68,85.75 98.33,85.39 98.33,84.99 98.1,84.75 97.63,84.75 97.33,84.45 97.33,83.99 97.1,83.75 96.63,83.75 95.63,82.75 93.84,82.75 93.04,81.96
  IN1 w0.133: v3(88.45,43.82) 88.78,44.15 88.78,44.78 86.79,46.78 86.79,50.18 84.58,52.39 84.58,58.7 84.41,58.87 83.62,58.87 83.5,58.99 83.5,59.24 83.7,59.44 84.4,59.44 84.54,59.57 84.54,59.85 84.4,59.98 83.66,59.98 83.5,60.14 83.5,60.36 83.66,60.52 84.42,60.52 84.55,60.65 84.55,60.93 84.42,61.06 83.66,61.06 83.5,61.22 83.5,61.5 83.63,61.64 84.4,61.64 84.54,61.77 84.54,62.04 84.4,62.18 83.63,62.18 83.5,62.31 83.5,62.65 83.63,62.78 83.63,66.96 84.18,67.51 84.5,67.83 84.5,70.9 85.3,71.7 85.3,72.28 91.23,78.21 91.23,80.15 93.04,81.96
  BOTTOM w0.114: v3(99.93,87.16) 99.93,87.22 U27.AK6
  BOTTOM w0.127: JDIM2.51 89.05,44.87 88.78,44.6 88.78,44.15 v3(88.45,43.82)
M_A_DQ20: length 67.2
  IN1 w0.089: v3(100.93,91.16) 100.52,90.75 99.96,90.75 99.53,90.32 99.53,89.92 99.16,89.56 98.76,89.56 98.53,89.32 98.53,88.92 98.17,88.56 97.76,88.56 97.53,88.32 97.53,87.91 97.17,87.56 96.76,87.56 96.53,87.32 96.53,86.86 96.22,86.56 93.31,86.56 91.82,85.07
  IN1 w0.133: v3(85.12,41.89) 84.96,42.05 84.96,44.5 83.46,46 83.46,48.62 79.63,52.45 79.63,67.07 80.73,68.16 80.73,72 88.33,79.6 88.33,81.58 91.82,85.07
  BOTTOM w0.114: U27.AJ10 100.93,91.22 v3(100.93,91.16)
  BOTTOM w0.127: v3(85.12,41.89) 85.57,41.44 85.57,40.03 85.75,39.85 JDIM2.40
M_A_DQ21: length 66.1
  IN1 w0.089: 91.82,85.62 92.96,86.75 96.15,86.75 96.34,86.94 96.34,87.4 96.68,87.75 97.1,87.75 97.34,87.99 97.34,88.4 97.68,88.75 98.09,88.75 98.34,89 98.34,89.4 98.68,89.75 99.09,89.75 99.34,90 99.34,90.57 99.64,90.87 99.65,90.87 v3(99.93,91.16)
  IN1 w0.133: v3(84.5,43.54) 84,44.03 84,44.91 83.07,45.84 83.07,48.46 78.54,53 78.54,66.52 80.32,68.3 80.32,72.23 87.95,79.86 87.95,81.74 91.82,85.62
  BOTTOM w0.114: v3(99.93,91.16) 99.93,91.22 U27.AK10
  BOTTOM w0.127: v3(84.5,43.54) 85.45,44.49 JDIM2.39
M_A_DQ22: length 64.7
  IN1 w0.089: 92.77,82.23 94.1,83.56 96.17,83.56 96.52,83.91 96.52,84.37 96.71,84.56 97.17,84.56 97.52,84.91 97.52,85.31 97.76,85.56 98.17,85.56 98.53,85.92 98.53,86.32 98.76,86.56 99.16,86.56 99.53,86.92 99.53,87.32 99.96,87.75 100.52,87.75 v3(100.93,88.16)
  IN1 w0.133: v3(88.45,41.81) 87.91,42.35 87.91,45.1 86.16,46.86 86.16,50.26 83.45,52.97 83.45,58.25 83.11,58.58 83.11,61.86 82.98,61.99 82.75,61.99 82.62,62.12 82.62,62.4 82.75,62.53 82.98,62.53 83.11,62.66 83.11,62.94 82.98,63.07 82.75,63.07 82.62,63.2 82.62,64.39 82.75,64.52 82.98,64.52 83.11,64.66 83.11,64.93 82.98,65.06 82.75,65.06 82.62,65.2 82.62,65.55 82.75,65.68 82.98,65.68 83.11,65.81 83.11,65.98 82.78,66.31 82.78,66.66 84.12,67.99 84.12,71.06 84.92,71.86 84.92,72.44 90.85,78.37 90.85,80.31 92.77,82.23
  BOTTOM w0.114: U27.AJ7 100.93,88.22 v3(100.93,88.16)
  BOTTOM w0.127: v3(88.45,41.81) 89.35,40.91 JDIM2.52
M_A_DQ23: length 63.9
  IN1 w0.089: 92.49,82.51 93.74,83.75 96.1,83.75 96.33,83.99 96.33,84.43 96.65,84.75 97.1,84.75 97.33,84.99 97.33,85.39 97.68,85.75 98.09,85.75 98.34,86 98.34,86.4 98.68,86.75 99.09,86.75 99.34,87 99.34,87.4 99.88,87.94 99.88,87.94 99.93,87.99 99.93,88.15 v5(99.93,88.16)
  IN1 w0.133: 92.49,82.51 90.46,80.47 90.46,78.53 84.47,72.54 84.47,71.96 83.73,71.22 83.73,68.16 82.23,66.65 82.23,61.19 82.36,61.06 82.59,61.06 82.73,60.93 82.73,60.65 82.59,60.52 82.36,60.52 82.23,60.39 82.23,60.11 82.36,59.98 82.59,59.98 82.73,59.85 82.73,59.58 82.59,59.44 82.36,59.44 82.23,59.31 82.23,59.02 82.35,58.9 82.58,58.9 82.73,58.75 82.73,58.42 83.06,58.09 83.06,52.81 85.66,50.21 85.66,46.8 87.64,44.83 87.64,41.69 v3(88.48,40.85)
  BOTTOM w0.114: v5(99.93,88.16) 99.93,88.16 99.93,88.22 U27.AK7
  BOTTOM w0.127: JDIM2.50 88.75,39.88 88.9,40.02 88.9,40.43 v3(88.48,40.85)
M_A_DQ24: length 59.6
  IN1 w0.089: v3(103.93,85.16) 103.65,84.87 103.65,84.87 103.33,84.56 101.64,84.56 101.4,84.32 101.4,83.99 101.1,83.69 100.77,83.69 100.41,83.33 100.41,82.92 100.13,82.64 99.72,82.64 99.42,82.34 99.42,82.06 97.95,80.59 97.64,80.59
  IN1 w0.133: 97.64,80.59 96.77,80.59 90.63,74.45 90.63,73.08 90.37,72.81 89.28,72.81 88.15,71.68 88.15,63.73 88.02,63.6 87.54,63.6 87.41,63.47 87.41,63.19 87.54,63.06 88.02,63.06 88.15,62.93 88.15,62.65 88.02,62.52 87.54,62.52 87.41,62.39 87.41,62.11 87.54,61.98 88.02,61.98 88.15,61.85 88.15,61.57 88.02,61.44 87.54,61.44 87.41,61.31 87.41,61.03 87.54,60.9 88.02,60.9 88.15,60.77 88.15,51.77 88.88,51.05 88.88,47.64 91.06,45.45 91.06,44.65 v3(90.42,44)
  BOTTOM w0.114: U27.AF4 103.93,85.22 v3(103.93,85.16)
  BOTTOM w0.127: v3(90.42,44) 91.06,44.64 91.06,45.43 91.45,45.83 JDIM2.59
M_A_DQ25: length 60.3
  IN1 w0.089: 97.37,81.1 98.37,82.09 98.37,82.28 98.71,82.62 99.09,82.62 99.39,82.92 99.39,83.36 99.67,83.64 100,83.64 100.49,84.12 100.49,84.37 100.87,84.75 103.18,84.75 103.43,85.01 103.43,86.05 103.54,86.16 v3(103.93,86.16)
  IN1 w0.133: v3(90.51,45.31) 90.51,45.46 88.49,47.48 88.49,50.89 86.98,52.4 86.98,64.02 87.11,64.16 87.6,64.16 87.74,64.29 87.74,64.56 87.6,64.7 87.11,64.7 86.98,64.83 86.98,65.1 87.11,65.24 87.6,65.24 87.74,65.37 87.74,65.64 87.6,65.78 87.11,65.78 86.98,65.91 86.98,66.18 87.11,66.32 87.6,66.32 87.74,66.45 87.74,66.72 87.6,66.86 87.11,66.86 86.98,66.99 86.98,67.26 87.11,67.4 87.58,67.4 87.71,67.53 87.71,67.8 87.58,67.94 87.11,67.94 86.98,68.07 86.98,68.34 87.11,68.48 87.58,68.48 87.71,68.61 87.71,68.88 87.58,69.02 87.11,69.02 86.98,69.15 86.98,69.74 87.51,70.27 87.51,72.08 96.53,81.1 97.37,81.1
  BOTTOM w0.114: U27.AF5 103.93,86.22 v3(103.93,86.16)
  BOTTOM w0.127: JDIM2.57 90.85,45.66 v3(90.51,45.31)
M_A_DQ26: length 56.4
  IN1 w0.133: v3(94.8,44.04) 94.49,44.36 94.49,45.58 91.52,48.56 91.52,53.37 91.93,53.77 91.93,64.45 91.79,64.59 90.82,64.59 90.68,64.72 90.68,64.99 90.82,65.13 91.95,65.13 92.08,65.26 92.08,65.53 91.95,65.67 90.82,65.67 90.68,65.8 90.68,66.07 90.82,66.21 91.92,66.21 92.05,66.34 92.05,66.61 91.92,66.75 90.82,66.75 90.68,66.88 90.68,67.27 90.82,67.4 91.8,67.4 92.03,67.63 92.03,69.39 93.51,70.87 93.51,73.22 100.09,79.8 100.43,79.8 101.88,81.25 103.02,81.25 v3(103.93,82.16)
  BOTTOM w0.102: v3(103.93,82.16) 104.4,82.62 U27.AF1
  BOTTOM w0.127: JDIM2.69 94.45,44.39 v3(94.8,44.04)
M_A_DQ27: length 57.1
  IN1 w0.089: v3(103.93,83.16) 103.42,82.64 103.42,81.99 103.02,81.6 101.8,81.6
  IN1 w0.133: 101.8,81.6 100.4,80.21 99.95,80.21 93.12,73.38 93.12,71.03 91.64,69.55 91.64,68.77 90.3,67.43 90.3,64.2 90.43,64.07 91.29,64.07 91.42,63.93 91.42,63.66 91.29,63.53 90.43,63.53 90.3,63.4 90.3,63.12 90.43,62.99 91.39,62.99 91.52,62.86 91.52,53.92 91.13,53.53 91.13,48.39 94.1,45.42 94.1,42.66 v3(93.66,42.22)
  BOTTOM w0.114: v3(103.93,83.16) 103.93,83.22 U27.AF2
  BOTTOM w0.127: v3(93.66,42.22) 94.23,42.22 94.65,41.8 94.65,40.05 94.75,39.94 JDIM2.70
M_A_DQ28: length 58.6
  IN1 w0.089: 96.92,81.58 97.53,82.19 97.53,82.4 97.78,82.64 98.25,82.64 98.52,82.91 98.52,83.32 98.77,83.56 99.17,83.56 99.52,83.91 99.52,84.34 99.74,84.56 100.16,84.56 100.52,84.93 100.52,85.31 100.77,85.56 102.52,85.56 v3(102.93,85.16)
  IN1 w0.133: 96.92,81.58 96.46,81.58 87.12,72.24 87.12,70.43 86.59,69.9 86.59,52.23 88.1,50.72 88.1,47.32 89.99,45.43 89.99,42.58 90.72,41.86 90.72,40.6 v3(90.38,40.26)
  BOTTOM w0.114: v3(102.93,85.16) 102.93,85.22 U27.AG4
  BOTTOM w0.127: JDIM2.56 90.55,40.09 v3(90.38,40.26)
M_A_DQ29: length 60.6
  IN1 w0.089: v3(102.93,86.16) 102.52,85.74 100.7,85.74 100.33,85.37 100.33,84.99 100.1,84.75 99.52,84.75 99.33,84.56 99.33,83.99 99.1,83.75 98.57,83.75 98.33,83.51 98.33,82.99 98.19,82.85 97.39,82.85 97.26,82.72 96.6,82.72 96.35,82.47
  IN1 w0.133: v3(90.16,41.68) 89.61,42.23 89.61,45.26 87.71,47.16 87.71,50.56 85.51,52.77 85.51,70.48 85.75,70.73 86.43,70.73 86.74,71.04 86.74,72.4 96.35,82.01 96.35,82.47
  BOTTOM w0.114: v3(102.93,86.16) 102.93,86.22 U27.AG5
  BOTTOM w0.127: v3(90.16,41.68) 91.15,40.69 JDIM2.58
M_A_DQ30: length 55.3
  IN1 w0.133: v3(102.93,82.16) 102.73,81.96 101.76,81.96 100.44,80.64 99.79,80.64 92.73,73.58 92.73,71.19 91.25,69.71 91.25,68.93 89.91,67.59 89.91,62.73 90.04,62.6 91,62.6 91.13,62.47 91.13,62.19 91,62.06 90.04,62.06 89.91,61.93 89.91,61.66 90.04,61.52 91,61.52 91.13,61.39 91.13,61.12 91,60.98 90.04,60.98 89.91,60.85 89.91,60.58 90.04,60.44 90.98,60.44 91.11,60.31 91.11,54.06 90.45,53.4 90.45,52.11 90.74,51.82 90.74,48.23 93.72,45.26 93.72,44.56 93.3,44.15 v3(93.3,44.15)
  BOTTOM w0.114: v3(102.93,82.16) 102.93,82.22 U27.AG1
  BOTTOM w0.127: JDIM2.67 93.85,44.7 v3(93.3,44.15)
M_A_DQ31: length 55.9
  IN1 w0.133: v3(93.56,40.92) 93.53,40.92 92.77,41.69 92.77,45.66 90.36,48.07 90.36,51.48 89.98,51.86 89.98,56.32 90.53,56.87 90.53,58.59 90.4,58.72 89.65,58.72 89.52,58.85 89.52,59.13 89.65,59.26 90.4,59.26 90.53,59.39 90.53,59.67 90.4,59.8 89.65,59.8 89.52,59.93 89.52,67.75 90.87,69.09 90.87,69.87 92.34,71.35 92.34,73.74 99.57,80.97 100.42,80.97 102.1,82.64 102.41,82.64 v3(102.93,83.16)
  BOTTOM w0.114: U27.AG2 102.93,83.22 v3(102.93,83.16)
  BOTTOM w0.127: JDIM2.68 94.15,40.49 93.72,40.92 v3(93.56,40.92)
M_A_DQ32: length 48.6
  IN1 w0.089: v3(121.93,82.16) 121.93,81.68 121.72,81.47
  IN1 w0.133: 121.72,81.47 121.42,81.17 121.42,63.82 118.51,60.91 118.51,60.28 117.41,59.19 117.41,58.67 116.76,58.02 116.76,52.72 114.83,50.79 114.83,48.29 114.42,47.88 114.42,46.22 113.76,45.56 113.76,41.99 114.49,41.26 114.49,40.58 114.66,40.41 v3(115.33,40.41)
  BOTTOM w0.114: U27.J1 v3(121.93,82.16)
  BOTTOM w0.127: JDIM2.130 115.15,40.23 v3(115.33,40.41)
M_A_DQ33: length 50.4
  IN1 w0.089: v3(121.93,83.16) 122.33,82.75 122.33,81.5 121.81,80.98 121.81,80.37
  IN1 w0.133: 121.81,80.37 121.81,63.66 118.89,60.75 118.89,60.12 117.8,59.03 117.8,58.51 117.15,57.86 117.15,52.56 115.22,50.63 115.22,48.13 114.8,47.72 114.8,46.06 114.15,45.4 114.15,42.15 114.57,41.72 115.86,41.72 v3(116.11,41.46)
  BOTTOM w0.114: U27.J2 v3(121.93,83.16)
  BOTTOM w0.127: JDIM2.132 115.75,41.11 v3(116.11,41.46)
M_A_DQ34: length 53
  IN1 w0.089: v3(121.93,86.16) 122.2,86.16 122.35,86 122.35,85.09 122.71,84.73 123.19,84.73 123.53,84.39 123.53,83.99 123.91,83.61 123.91,83.05 124.68,82.27 124.68,81.57 124.54,81.43
  IN1 w0.133: v3(117.79,44.78) 117.45,44.78 117.32,44.91 117.32,45.61 117.5,45.8 117.5,46.05 117.33,46.22 117.33,46.43 117.56,46.66 117.71,46.66 117.97,46.39 118.25,46.39 118.42,46.56 118.42,46.81 118.14,47.09 118.14,47.24 118.42,47.52 118.42,50.19 121.21,52.98 121.21,53.15 121.13,53.23 120.87,53.23 120.74,53.37 120.74,53.64 120.87,53.77 121.16,53.77 121.29,53.9 121.29,56.48 121.16,56.62 120.9,56.62 120.77,56.75 120.77,57.02 120.9,57.16 121.16,57.16 121.29,57.29 121.29,57.55 121.16,57.68 120.91,57.68 120.78,57.8 120.78,58.08 120.91,58.21 121.14,58.21 121.29,58.36 121.29,58.96 121.41,59.08 121.41,59.71 124.32,62.62 124.32,81.21 124.54,81.43
  BOTTOM w0.114: U27.J5 v3(121.93,86.16)
  BOTTOM w0.127: v3(117.79,44.78) 118.45,45.45 JDIM2.141
M_A_DQ35: length 52.3
  IN1 w0.089: 125.09,80.89 125.31,81.11 125.31,82.21 124.53,82.99 124.53,84.39 124.17,84.75 123.77,84.75 123.53,84.99 123.53,85.56 v3(122.93,86.16)
  IN1 w0.133: v3(118.17,40.23) 118.66,40.73 118.66,45.46 119.2,46 119.2,49.87 122.07,52.74 122.07,58.64 122.27,58.85 122.27,59.47 125.09,62.3 125.09,80.89
  BOTTOM w0.114: v3(122.93,86.16) U27.H5
  BOTTOM w0.127: v3(118.17,40.23) 118.15,40.22 JDIM2.140
M_A_DQ36: length 50.3
  IN1 w0.089: v3(122.93,83.16) 122.53,82.75 122.53,81.14 122.19,80.81 122.19,80.33
  IN1 w0.133: 122.19,80.33 122.19,63.5 119.28,60.59 119.28,59.96 118.19,58.87 118.19,53.05 116.21,51.07 116.21,48.32 115.19,47.3 115.19,45.9 114.53,45.24 114.53,42.41 v3(114.77,42.18)
  BOTTOM w0.114: U27.H2 v3(122.93,83.16)
  BOTTOM w0.127: JDIM2.129 114.85,45.81 114.71,45.67 114.71,43.15 114.61,43.05 114.61,42.33 v3(114.77,42.18)
M_A_DQ37: length 48.5
  IN1 w0.089: v5(122.93,82.16) 122.93,81.06 122.58,80.71 122.58,80.33
  IN1 w0.133: v3(115.08,42.75) 114.92,42.9 114.92,45.08 115.25,45.41 115.58,45.74 115.58,47.14 116.64,48.2 116.64,50.96 118.57,52.89 118.57,58.71 119.67,59.8 119.67,60.43 122.58,63.34 122.58,80.33
  BOTTOM w0.102: v5(122.93,82.16) 122.76,81.98 122.48,81.98 122.4,82.07 U27.H1
  BOTTOM w0.127: v3(115.08,42.75) 114.96,42.86 114.96,45.2 115.45,45.68 JDIM2.131
M_A_DQ38: length 52.3
  IN1 w0.089: v3(121.93,85.16) 122.53,84.56 123.1,84.56 123.33,84.32 123.33,83.86 123.72,83.47 123.72,82.93 124.35,82.3 124.35,81.77 124.25,81.67
  IN1 w0.133: 124.25,81.67 123.93,81.35 123.93,62.78 121.02,59.87 121.02,59.24 120.38,58.6 120.38,56.64 120.35,56.61 120.35,52.75 118.03,50.43 118.03,47.68 116.93,46.58 116.93,43.19 117.07,43.05 117.37,43.05 v3(117.79,43.46)
  BOTTOM w0.114: U27.J4 v3(121.93,85.16)
  BOTTOM w0.127: JDIM2.143 119.05,46.02 118.72,45.69 118.72,44.4 v3(117.79,43.46)
M_A_DQ39: length 51.7
  IN1 w0.089: 124.86,81.26 125.02,81.43 125.02,82.21 124.33,82.9 124.33,84.32 124.1,84.56 123.63,84.56 123.35,84.84 123.35,85.06 123.25,85.16 v3(122.93,85.16)
  IN1 w0.133: 124.86,81.26 124.71,81.11 124.71,62.46 121.89,59.64 121.89,59.01 121.68,58.8 121.68,52.9 118.81,50.03 118.81,46.16 118.27,45.62 118.27,41.84 v3(117.97,41.53)
  BOTTOM w0.114: v3(122.93,85.16) U27.H4
  BOTTOM w0.127: JDIM2.142 118.75,40.74 v3(117.97,41.53)
M_A_DQ40: length 52.9
  IN1 w0.089: v3(124.93,84.16) 124.93,83.8 125.36,83.36 125.36,83.15 126.02,82.5 126.02,81.48
  IN1 w0.133: 126.02,81.48 126.02,67.1 126.16,66.96 126.47,66.96 126.61,66.83 126.61,66.56 126.47,66.42 126.16,66.42 126.02,66.29 126.02,66.02 126.16,65.88 126.47,65.88 126.61,65.75 126.61,65.48 126.47,65.34 126.16,65.34 126.02,65.21 126.02,64.94 126.16,64.8 126.47,64.8 126.61,64.67 126.61,64.4 126.47,64.26 126.16,64.26 126.02,64.13 126.02,63.86 126.16,63.72 126.47,63.72 126.61,63.59 126.61,61.04 123.46,57.9 123.46,55.08 122.99,54.61 122.99,52.35 120.12,49.48 120.12,44.73 119.2,43.81 119.2,40.9 v3(119.74,40.36)
  BOTTOM w0.114: v3(124.93,84.16) 124.87,84.16 U27.F2
  BOTTOM w0.127: JDIM2.146 119.95,40.15 v3(119.74,40.36)
M_A_DQ41: length 52
  IN1 w0.102: 125.63,81.43 125.63,82.45 v3(124.93,83.16)
  IN1 w0.133: 125.63,81.43 125.63,63.48 125.77,63.34 126.09,63.34 126.22,63.21 126.22,62.94 126.09,62.8 125.77,62.8 125.63,62.67 125.63,62.4 125.77,62.26 126.09,62.26 126.22,62.13 126.22,61.86 126.09,61.72 125.56,61.72 125.45,61.62 125.45,61.44 125.84,61.06 125.84,60.82 125.67,60.65 125.43,60.65 124.93,61.15 124.71,61.15 124.55,60.99 124.55,60.77 125.06,60.26 125.06,60.04 124.9,59.88 124.67,59.88 124.18,60.37 123.96,60.37 123.8,60.21 123.8,59.99 124.29,59.5 124.29,59.28 124.13,59.12 123.91,59.12 123.41,59.62 123.18,59.62 123.02,59.46 123.02,59.24 123.33,58.93 123.33,58.76 123.17,58.59 122.94,58.59 122.8,58.45 122.8,58.25 123.07,57.97 123.07,55.24 122.6,54.77 122.6,52.51 119.74,49.64 119.74,44.99 v3(119.44,44.7)
  BOTTOM w0.114: U27.F1 124.87,83.16 v3(124.93,83.16)
  BOTTOM w0.127: JDIM2.147 120.25,45.51 v3(119.44,44.7)
M_A_DQ42: length 52.4
  IN1 w0.089: v3(126.93,84.16) 127.03,84.16 127.63,83.56 128.1,83.56 128.33,83.32 128.33,82.6 128.22,82.49 128.22,81.48
  IN1 w0.133: v3(123.55,40.23) 122.3,40.23 122.1,40.43 122.1,41.46 122.59,41.94 122.59,42.84 122.25,43.18 122.25,46.97 122.62,47.33 122.62,47.52 122.42,47.72 122.42,47.94 122.58,48.1 122.8,48.1 123,47.9 123.19,47.9 123.43,48.14 123.43,49.55 126.91,53.03 126.91,58.24 128.73,60.07 128.73,74.36 128.22,74.87 128.22,81.48
  BOTTOM w0.114: U27.D2 126.87,84.16 v3(126.93,84.16)
  BOTTOM w0.127: JDIM2.158 123.55,40.23 v3(123.55,40.23)
M_A_DQ43: length 53.1
  IN1 w0.089: 128.6,81.48 128.6,83.32 128.17,83.75 127.77,83.75 127.53,83.99 127.53,84.56 v3(126.93,85.16)
  IN1 w0.133: v3(123.58,41.81) 123.04,42.35 123.04,43.05 122.64,43.45 122.64,46.81 124.16,48.33 124.16,48.51 123.82,48.86 123.82,49.08 123.98,49.24 124.2,49.24 124.52,48.91 124.75,48.91 124.91,49.07 124.91,49.29 124.44,49.76 124.44,50.01 127.46,53.03 127.46,58.23 129.12,59.89 129.12,74.52 128.6,75.03 128.6,81.48
  BOTTOM w0.114: U27.D3 126.87,85.16 v3(126.93,85.16)
  BOTTOM w0.127: v3(123.58,41.81) 124.15,41.24 JDIM2.160
M_A_DQ44: length 50.9
  IN1 w0.089: v3(126.93,83.16) 126.8,83.02 126.8,81.48
  IN1 w0.133: v3(119.82,41.84) 119.61,42.04 119.61,42.24 120.9,43.53 120.9,49.16 124.47,52.73 124.47,57.81 127.38,60.72 127.38,71.19 127.26,71.31 126.96,71.31 126.8,71.47 126.8,72.18 126.93,72.31 127.25,72.31 127.38,72.44 127.38,72.72 127.25,72.85 126.93,72.85 126.8,72.98 126.8,73.25 126.93,73.39 127.25,73.39 127.38,73.52 127.38,73.79 127.25,73.93 126.93,73.93 126.8,74.06 126.8,81.48
  BOTTOM w0.114: U27.D1 126.87,83.16 v3(126.93,83.16)
  BOTTOM w0.127: v3(119.82,41.84) 120.55,41.1 JDIM2.148
M_A_DQ45: length 54.3
  IN1 w0.089: v3(124.93,85.16) 125.33,85.16 125.49,85 125.49,83.88 125.76,83.61 126.19,83.61 126.41,83.39 126.41,81.48
  IN1 w0.133: 126.41,81.48 126.41,70.74 126.52,70.63 126.82,70.63 126.99,70.45 126.99,70.18 126.86,70.04 126.54,70.04 126.41,69.91 126.41,69.64 126.54,69.5 126.86,69.5 126.99,69.37 126.99,69.1 126.86,68.96 126.54,68.96 126.41,68.83 126.41,68.56 126.54,68.42 126.86,68.42 126.99,68.29 126.99,68.02 126.86,67.88 126.54,67.88 126.41,67.75 126.41,67.48 126.54,67.34 126.86,67.34 126.99,67.21 126.99,60.88 124.08,57.97 124.08,52.89 120.51,49.32 120.51,43.74 120.15,43.38 v3(119.77,43.38)
  BOTTOM w0.114: U27.F3 124.87,85.16 v3(124.93,85.16)
  BOTTOM w0.127: v3(119.77,43.38) 120.43,43.38 120.85,43.8 JDIM2.149
M_A_DQ46: length 53.2
  IN1 w0.089: v3(127.93,85.16) 128.33,84.75 128.33,84.06 128.99,83.4 128.99,81.88
  IN1 w0.133: v3(123.53,43.97) 122.94,44.55 122.94,45.7 123.17,45.92 123.17,46.79 125.31,48.93 125.31,50.34 127.84,52.87 127.84,58.06 129.51,59.72 129.51,74.68 128.99,75.19 128.99,75.58 129.12,75.71 129.38,75.71 129.51,75.85 129.51,76.12 129.38,76.25 129.12,76.25 128.99,76.39 128.99,76.66 129.12,76.79 129.38,76.79 129.51,76.93 129.51,77.2 129.38,77.33 129.12,77.33 128.99,77.47 128.99,77.74 129.12,77.87 129.38,77.87 129.51,78.01 129.51,78.28 129.38,78.41 129.12,78.41 128.99,78.55 128.99,78.82 129.12,78.95 129.38,78.95 129.51,79.09 129.51,79.36 129.38,79.49 129.12,79.49 128.99,79.63 128.99,79.91 129.12,80.05 129.38,80.05 129.51,80.18 129.51,80.45 129.38,80.59 129.12,80.59 128.99,80.72 128.99,81.88
  BOTTOM w0.114: v3(127.93,85.16) 127.87,85.16 U27.C3
  BOTTOM w0.127: v3(123.53,43.97) 124.14,43.97 124.46,44.29 124.46,45.39 123.85,46 JDIM2.159
M_A_DQ47: length 51.4
  IN1 w0.089: v3(128.93,85.16) 128.93,84.96 129.39,84.5 129.39,84.47
  IN1 w0.133: 129.39,84.47 129.39,83.38 129.53,83.25 129.76,83.25 129.9,83.11 129.9,82.84 129.76,82.71 129.51,82.71 129.38,82.57 129.38,82.3 129.51,82.17 129.76,82.17 129.9,82.03 129.9,81.76 129.76,81.63 129.51,81.63 129.38,81.49 129.38,81.22 129.51,81.09 129.76,81.09 129.9,80.95 129.9,59.55 128.82,58.47 128.82,57.52 128.96,57.37 129.38,57.37 129.51,57.24 129.51,56.97 129.38,56.83 128.95,56.83 128.81,56.69 128.81,55.77 128.95,55.64 129.15,55.64 129.28,55.5 129.28,55.23 129.15,55.1 128.97,55.1 128.86,54.99 128.86,54.42 129.16,54.12 129.16,53.05 128.77,52.66 128.18,52.66 127.99,52.47 127.99,52.28 128.12,52.15 128.12,51.96 127.93,51.76 127.74,51.76 127.61,51.9 127.42,51.9 127.22,51.7 127.22,51.51 127.36,51.38 127.36,51.19 127.16,51 126.97,51 126.84,51.13 126.65,51.13 126.46,50.94 126.46,50.75 126.59,50.62 126.59,50.43 126.4,50.24 126.21,50.24 126.08,50.37 125.89,50.37 125.7,50.18 125.7,49.99 126.19,49.49 126.19,49.26 123.7,46.77 123.7,45.76 v3(123.43,45.49)
  BOTTOM w0.114: U27.B3 128.4,85.03 128.63,85.26 128.83,85.26 128.93,85.16 v3(128.93,85.16)
  BOTTOM w0.127: v3(123.43,45.49) 123.25,45.67 JDIM2.157
M_A_DQ48: length 57.3
  IN1 w0.089: 130.72,85.58 130.55,85.75 129.71,85.75 129.52,85.94 129.52,86.4 128.93,86.99 v3(128.93,87.16)
  IN1 w0.133: 130.72,85.58 131.6,84.7 131.6,67.51 131.73,67.38 132.23,67.38 132.36,67.24 132.36,66.97 132.23,66.84 131.73,66.84 131.6,66.7 131.6,66.43 131.73,66.3 132.23,66.3 132.36,66.16 132.36,65.89 132.23,65.76 131.73,65.76 131.6,65.62 131.6,65.35 131.73,65.22 132.23,65.22 132.36,65.09 132.36,59.55 131.85,59.04 131.85,58.09 131.73,57.97 131.43,57.97 131.28,57.82 131.28,57.55 131.42,57.41 131.77,57.41 131.88,57.31 131.88,53.31 128.78,50.21 128.78,48.61 125.92,45.75 125.92,43.71 125.74,43.54 v3(125.05,43.54)
  BOTTOM w0.114: v3(128.93,87.16) 128.87,87.16 U27.B5
  BOTTOM w0.127: JDIM2.165 125.65,45.98 125.96,45.67 125.96,44.45 v3(125.05,43.54)
M_A_DQ49: length 59.1
  IN1 w0.089: v3(125.93,88.16) 125.93,87.78 126.01,87.7 127.41,87.7 127.5,87.61 127.5,86.9 127.84,86.56 129.09,86.56 129.33,86.32 129.33,85.86 129.63,85.56 130.19,85.56 130.45,85.3
  IN1 w0.133: 130.45,85.3 131.21,84.54 131.21,64.96 131.34,64.83 131.84,64.83 131.97,64.7 131.97,64.42 131.84,64.29 131.34,64.29 131.21,64.16 131.21,63.89 131.34,63.75 131.84,63.75 131.97,63.62 131.97,59.72 130.89,58.64 130.89,57.13 131,57.03 131.38,57.03 131.49,56.92 131.49,56.6 131.37,56.48 131.01,56.48 130.89,56.37 130.89,52.87 128.39,50.37 128.39,48.77 127.47,47.85 127.28,47.85 127.08,48.06 126.85,48.06 126.61,47.82 126.61,47.64 126.82,47.42 126.82,47.2 126.67,47.04 126.44,47.04 126.23,47.25 126.04,47.25 125.85,47.06 125.85,46.87 126.06,46.66 126.06,46.44 125.9,46.28 125.68,46.28 125.47,46.49 125.28,46.49 125.07,46.28 125.07,46.04 125.56,45.56 125.56,45.01 125.41,44.86 v3(125.08,44.86)
  BOTTOM w0.114: v3(125.93,88.16) 125.87,88.16 U27.E6
  BOTTOM w0.127: v3(125.08,44.86) 125.49,45.27 125.49,45.63 125.05,46.07 JDIM2.163
M_A_DQ50: length 56.4
  IN1 w0.089: v3(129.93,87.16) 131.07,87.16 131.6,86.62
  IN1 w0.133: 131.6,86.62 132.95,85.27 132.95,70.55 133.08,70.42 133.58,70.42 133.71,70.28 133.71,70.01 133.58,69.88 133.08,69.88 132.95,69.74 132.95,69.47 133.08,69.34 133.58,69.34 133.71,69.2 133.71,68.93 133.58,68.8 133.26,68.8 133.13,68.66 133.13,68.39 133.26,68.26 133.58,68.26 133.71,68.12 133.71,53.23 130.67,50.19 130.67,48.58 128.15,46.07 127.75,45.66 127.75,43.52 128.1,43.17 v3(128.1,40.8)
  BOTTOM w0.114: v3(129.93,87.16) 129.87,87.16 U27.A5
  BOTTOM w0.127: v3(128.1,40.8) 128.35,40.54 JDIM2.174
M_A_DQ51: length 59
  IN1 w0.089: v3(126.93,88.16) 127.44,88.66 131.2,88.66 131.6,88.27
  IN1 w0.133: v3(129.41,40.84) 129.61,41.05 129.61,45.88 132.52,48.79 132.52,50.39 134.88,52.75 134.88,78.77 134.11,79.53 134.11,85.76 131.6,88.27
  BOTTOM w0.114: U27.D6 126.87,88.16 v3(126.93,88.16)
  BOTTOM w0.127: v3(129.41,40.84) 128.95,40.39 JDIM2.176
M_A_DQ52: length 57.7
  IN1 w0.089: v3(126.93,87.16) 127.39,86.7 127.39,86.02 127.66,85.75 129.17,85.75 129.52,85.4 129.52,85.4 129.61,85.31 129.89,85.31 130.17,85.03
  IN1 w0.133: 130.17,85.03 130.82,84.38 130.82,63.5 130.96,63.36 131.45,63.36 131.59,63.23 131.59,62.96 131.45,62.82 130.96,62.82 130.82,62.69 130.82,62.42 130.96,62.28 131.45,62.28 131.59,62.15 131.59,59.9 130.5,58.81 130.5,53.03 128,50.53 128,49.03 127.56,48.59 126.83,48.59 124.69,46.44 124.69,45.84 124.57,45.72 124.57,42.55 v3(124.95,42.17)
  BOTTOM w0.114: U27.D5 126.87,87.16 v3(126.93,87.16)
  BOTTOM w0.127: JDIM2.166 125.95,41.54 125.33,42.17 v3(124.95,42.17)
M_A_DQ53: length 57.9
  IN1 w0.089: v3(125.93,87.16) 126.34,86.74 126.34,86.1 126.89,85.56 129.1,85.56 129.9,84.75
  IN1 w0.133: v3(125.05,40.87) 124.24,41.68 124.24,46.55 126.88,49.19 126.88,49.96 130.12,53.19 130.12,58.99 130.44,59.3 130.44,60.14 130.57,60.28 131.07,60.28 131.2,60.41 131.2,60.68 131.07,60.82 130.57,60.82 130.44,60.95 130.44,61.22 130.57,61.36 131.07,61.36 131.2,61.49 131.2,61.76 131.07,61.9 130.57,61.9 130.44,62.03 130.44,84.21 129.9,84.75
  BOTTOM w0.114: v3(125.93,87.16) 125.87,87.16 U27.E5
  BOTTOM w0.127: v3(125.05,40.87) 125.06,40.87 125.56,40.38 125.56,39.98 125.35,39.77 JDIM2.164
M_A_DQ54: length 58.2
  IN1 w0.089: 131.6,87.17 131.07,87.7 129.56,87.7 129.1,88.16 v3(128.93,88.16)
  IN1 w0.133: 131.6,87.17 133.34,85.43 133.34,75.26 133.47,75.12 133.97,75.12 134.1,74.99 134.1,74.72 133.97,74.58 133.47,74.58 133.34,74.45 133.34,74.18 133.47,74.04 133.97,74.04 134.1,73.91 134.1,73.64 133.97,73.5 133.47,73.5 133.34,73.37 133.34,73.1 133.47,72.96 133.97,72.96 134.1,72.83 134.1,72.56 133.97,72.42 133.47,72.42 133.34,72.29 133.34,72.02 133.47,71.88 133.97,71.88 134.1,71.75 134.1,71.48 133.97,71.34 133.47,71.34 133.34,71.21 133.34,70.94 133.47,70.8 133.97,70.8 134.1,70.67 134.1,53.07 131.06,50.03 131.06,48.42 128.84,46.2 128.84,44.78 128.69,44.63 v3(128.19,44.63)
  BOTTOM w0.114: U27.B6 128.87,88.16 v3(128.93,88.16)
  BOTTOM w0.127: v3(128.19,44.63) 128.51,44.63 128.83,44.94 128.83,45.71 128.65,45.88 JDIM2.175
