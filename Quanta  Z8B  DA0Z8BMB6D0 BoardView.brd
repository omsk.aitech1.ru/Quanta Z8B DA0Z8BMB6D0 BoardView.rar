# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_RXN2: length 9.8
  BOTTOM w0.102: 150.47,97.97 150.49,97.99 150.51,97.99 150.55,98.03 150.56,98.03 151.39,98.86 153.03,98.86 153.22,99.05 153.47,99.05 153.76,98.76 U24.BB9
  BOTTOM w0.127: TP116.1 147.98,94.43 148.51,94.96 148.51,95.32 149.53,96.34 149.53,97.05 150.45,97.97 150.47,97.97
SATA_RXN4: length 7.9
  BOTTOM w0.079: 152.24,100.48 152.26,100.48 152.3,100.44 153.01,100.44 153.25,100.69 153.46,100.69 153.56,100.59 153.56,100.44 153.49,100.36 U24.BD13
  BOTTOM w0.127: TP108.1 147.9,98.34 149.56,100 149.72,100 150.19,100.48 152.24,100.48
SATA_RXN5: length 113.6
  TOP w0.127: C311.2 191.01,33.48 190.55,33.48 C312.2 189.35,33.53 187.53,33.53 187.14,33.93 187.14,34.41 186.47,35.08 186.19,35.08 v3(186.01,34.9)
  IN2 w0.133: v3(186.01,34.9) 185.8,35.1 185.01,35.1 184.48,35.63 184.48,39.69 181.83,42.34 159.3,42.34 157.41,44.23 157.41,51.68 156.53,52.56 156.53,56.9 157.77,58.14 157.77,70.05 154.57,73.25 153.97,73.25 151.92,75.3 151.92,78.95 v4(151.7,79.18)
  BOTTOM w0.089: 151.98,101.28 152,101.26 152.88,101.26 153.24,100.9 153.69,100.9 U24.BC14
  BOTTOM w0.127: v4(151.7,79.18) 151.88,79.35 151.88,80.28 150.32,81.84 148.54,81.84 146.89,83.49 146.89,90.3 144.68,92.52 144.68,94.13 145.83,95.28 145.83,98.12 148.48,100.78 149.3,100.78 149.81,101.29 151.97,101.29 151.98,101.28
SATA_RXN5_C: length 4.1
  TOP w0.127: C311.1 192.57,33.48 195.44,33.48 CN11.5
SATA_RXN5_CN: length 13.3
  TOP w0.127: v3(188.06,32.91) C312.1
  BOTTOM w0.127: v3(188.06,32.91) 188.06,33.49 188.17,33.6 188.9,33.6 189.64,32.86 189.64,31.89 v2(189.11,31.36) 189.64,30.83 189.64,28.08 187.49,25.93 187.49,25.31 187.36,25.18 CN13.5
SATA_RXP0: length 161.3
  IN2 w0.133: v4(162.14,44.71) 162.42,44.99 162.42,45.42 158.95,48.89 158.95,52.32 158.07,53.2 158.07,55.51 159.33,56.78 159.33,71.81 154.31,76.83 154.31,77.57 v3(154.05,77.83)
  BOTTOM w0.102: 150.83,97.05 150.86,97.08 150.88,97.08 152.05,98.25 152.79,98.25 U24.BE8
  BOTTOM w0.127: v4(162.14,44.71) 162.44,45.01 162.44,45.24 162.72,45.52 165.06,45.52 166.58,44 171.15,44 172.66,45.51 178.71,45.51 180.36,43.85 181.22,43 181.61,42.6 183.83,42.6 184.54,41.89 188.72,41.89 191.96,45.13 191.96,46.39 193.71,48.13 193.71,59.48 192.05,61.14 192.05,61.47 190.68,62.83 190.68,64.83 189.57,65.95 189.57,66.61 184.33,71.85 183.78,71.85 182.73,72.9 182.73,80.99 187.91,86.18 188.85,86.18 193.04,90.37 193.04,93.73 194.05,94.73 195.28,94.73 195.46,94.91 C494.2 ; v3(154.05,77.83) 154.31,78.1 154.31,78.91 150.54,82.68 148.81,82.68 147.77,83.72 147.77,91.57 149.56,93.36 149.56,95.28 150.31,96.03 150.31,96.53 150.83,97.05
SATA_RXP0_C: length 4.3
  BOTTOM w0.127: CN6.6 199.58,94.66 196.78,94.66 C494.1
SATA_RXP1: length 5.8
  BOTTOM w0.102: U24.BE10 152.75,99.31 151.18,99.31 150.82,98.95 150.51,98.95 150.49,98.93 150.47,98.93
  BOTTOM w0.127: 150.47,98.93 148.98,97.44 148.98,96.64 TP112.1
SATA_RXP2: length 7.3
  BOTTOM w0.102: 150.64,97.8 150.65,97.81 150.65,97.83 151.48,98.66 153.26,98.66 U24.BD9
  BOTTOM w0.127: TP115.1 148.77,94.77 148.77,95.21 149.79,96.23 149.79,96.94 150.64,97.8
SATA_RXP4: length 9.6
  BOTTOM w0.079: U24.BB13 153.78,100.39 153.45,100.06 153.24,100.06 153.02,100.28 152.4,100.28 152.35,100.23 152.24,100.23
  BOTTOM w0.127: TP111.1 147.58,97.43 147.58,97.68 147.98,98.09 148,98.09 149.67,99.75 149.82,99.75 150.3,100.23 152.24,100.23
SATA_RXP5: length 113.6
  TOP w0.127: C310.2 191.03,33.73 190.56,33.73 C309.2 189.98,33.88 189.87,33.77 187.63,33.77 187.38,34.03 187.38,34.51 186.57,35.32 186.14,35.32 186.01,35.46 v3(186.01,35.66)
  IN2 w0.133: v3(186.01,35.66) 186.01,35.43 185.93,35.36 185.11,35.36 184.74,35.73 184.74,39.8 181.94,42.6 159.41,42.6 157.67,44.34 157.67,51.78 156.78,52.67 156.78,56.79 158.03,58.04 158.03,70.16 154.68,73.51 154.08,73.51 152.18,75.41 152.18,79.07 152.28,79.18 v3(152.46,79.18)
  BOTTOM w0.089: 151.95,101.05 151.97,101.05 152,101.08 152.32,101.08 152.37,101.03 152.37,100.68 152.42,100.63 152.53,100.63 152.58,100.68 152.58,101.02 152.64,101.08 152.81,101.08 152.89,101 U24.BE14
  BOTTOM w0.127: v3(152.46,79.18) 152.27,79.18 152.12,79.32 152.12,80.38 150.42,82.09 148.64,82.09 147.14,83.59 147.14,90.4 144.92,92.62 144.92,94.03 146.07,95.18 146.07,98.02 148.58,100.54 149.4,100.54 149.91,101.05 151.95,101.05
SATA_RXP5_C: length 4.1
  TOP w0.127: CN11.6 195.35,33.72 192.57,33.72 C310.1
SATA_RXP5_CN: length 13.3
  TOP w0.127: v3(188.11,34.31) C309.1
  BOTTOM w0.127: CN13.6 187.86,25.18 187.73,25.31 187.73,25.83 189.88,27.98 189.88,30.86 v2(190.38,31.36) 189.88,31.86 189.88,32.96 189,33.84 188.28,33.84 188.11,34.01 v3(188.11,34.31)
SATA_TXN0: length 157.2
  IN2 w0.133: v3(155.51,97.74) 155.51,97.65 154.88,97.02 153.67,97.02 152.1,95.45 152.1,93.44 150.72,92.06 150.72,87.85 151.88,86.68 151.88,85.88 150.53,84.53 150.53,83.64 153.5,80.67 153.5,76.46 156.56,73.4 156.56,72.72 158.82,70.46 158.82,57.28 157.55,56.01 157.55,52.99 158.43,52.1 158.43,47.91 160.33,46.01 160.33,45 v3(160.56,44.77)
  BOTTOM w0.102: U24.AW8 155.5,98.2 155.5,97.76 v3(155.51,97.74)
  BOTTOM w0.127: v3(160.56,44.77) 160.3,44.52 160.3,44.29 161.35,43.25 171.47,43.25 172.98,44.76 178.4,44.76 179.96,43.19 181.02,42.13 181.3,41.85 183.52,41.85 184.23,41.14 189.13,41.14 192.71,44.72 192.71,46.07 194.46,47.81 194.46,59.79 192.8,61.45 192.8,61.78 191.46,63.12 191.46,65.12 190.44,66.13 190.44,66.79 185.77,71.47 185.77,74.74 183.53,76.98 183.53,80.72 188.22,85.41 189.16,85.41 194.5,90.75 195.23,90.75 195.46,90.99 C498.2
SATA_TXN0_C: length 4.2
  BOTTOM w0.127: CN6.3 199.58,90.85 196.65,90.85 C498.1
SATA_TXN1: length 12.4
  IN2 w0.089: 153.4,98.07 153.42,98.08 153.42,98.13 153.45,98.16 153.45,98.16 153.76,98.48 154.47,98.48 154.6,98.36 155.2,98.36 v3(155.61,98.76)
  IN2 w0.133: v3(148.55,93.1) 148.76,93.32 149.39,93.32 150.42,94.35 150.42,95.05 153.34,97.97 153.34,98 153.4,98.07
  BOTTOM w0.102: U24.AV10 156.02,99.25 155.61,98.84 v3(155.61,98.76)
  BOTTOM w0.127: TP119.1 147.38,92.7 147.78,93.1 v3(148.55,93.1)
SATA_TXN2: length 8.2
  TOP w0.102: v3(154.99,99.75) 154.99,99.69 154.5,99.21 153.79,99.21 153.59,99 152.16,99 152.14,99.02 152.12,99.02
  TOP w0.127: 152.12,99.02 151.89,99.02 150.22,97.35 149.87,97.35 149.7,97.52 TP42.1
  BOTTOM w0.102: U24.AY13 154.68,100.23 154.6,100.15 154.6,99.88 154.73,99.75 v3(154.99,99.75)
SATA_TXN4: length 11.6
  TOP w0.127: v3(148.36,97.07) 148.1,97.34 147.29,97.34 147.07,97.12 TP43.1
  IN2 w0.089: v3(155.66,100.72) 155.29,100.72 154.67,100.1 153.87,100.1 153.52,99.75 151.42,99.75 151.11,99.43
  IN2 w0.133: 151.11,99.43 148.97,97.3 148.59,97.3 v3(148.36,97.07)
  BOTTOM w0.102: U24.AV15 156.02,101.07 155.67,100.72 v3(155.66,100.72)
SATA_TXN5: length 114.4
  TOP w0.127: v4(186.03,33.52) 186.25,33.3 186.67,33.3 187.28,32.69 187.28,30.66 188,29.94 189.44,29.94 C314.2 190.54,29.91 191.02,29.91 C315.2
  IN2 w0.089: 152.44,98.7 152.44,98.76 152.72,99.03 154.52,99.03 154.66,99.17 156.32,99.17 157.37,100.21 157.53,100.21 v3(158.08,100.76)
  IN2 w0.133: v4(186.03,33.52) 185.67,33.16 185.13,33.16 183.95,34.33 183.95,39.49 181.62,41.83 159.03,41.83 156.9,43.96 156.9,51.47 156.01,52.35 156.01,64.18 156.76,64.93 156.76,70.34 155.12,71.98 154.29,71.98 151.41,74.86 151.41,77.67 150.96,78.12 150.96,81.78 149.63,83.11 149.63,85.74 149.43,85.94 149.43,88.24 149.48,88.29 149.48,90.18 147.65,92.01 147.65,93.91 152.44,98.7
  BOTTOM w0.102: U24.AP15 157.71,101.11 157.71,101 157.95,100.76 v3(158.08,100.76)
SATA_TXN5_C: length 4.1
  TOP w0.127: CN11.3 195.38,30.47 194.82,29.91 192.57,29.91 C315.1
SATA_TXN5_CN: length 8.6
  TOP w0.127: v3(188.24,30.47) C314.1
  BOTTOM w0.127: CN13.3 186.36,25.18 186.23,25.3 186.23,25.8 189.08,28.65 189.08,29.84 188.83,30.09 188.44,30.09 188.24,30.28 v3(188.24,30.47)
SATA_TXP0: length 157.2
  IN2 w0.133: v3(154.86,97.76) 154.86,97.42 154.71,97.27 153.57,97.27 151.84,95.55 151.84,93.54 150.46,92.16 150.46,87.74 151.62,86.58 151.62,85.99 150.27,84.63 150.27,83.53 153.24,80.56 153.24,76.35 156.3,73.29 156.3,72.62 158.56,70.36 158.56,57.38 157.3,56.12 157.3,52.88 158.18,52 158.18,47.8 160.08,45.91 160.08,45.05 v4(159.8,44.77)
  BOTTOM w0.102: v3(154.86,97.76) 154.86,98.25 U24.AY8
  BOTTOM w0.127: C499.2 195.06,90.51 194.6,90.51 189.26,85.17 188.32,85.17 183.77,80.62 183.77,77.08 186.01,74.84 186.01,71.57 190.68,66.89 190.68,66.23 191.7,65.22 191.7,63.22 193.04,61.88 193.04,61.55 194.7,59.89 194.7,47.71 192.96,45.97 192.96,44.62 189.23,40.9 184.13,40.9 183.42,41.61 181.2,41.61 180.92,41.89 179.79,43.02 178.3,44.52 173.08,44.52 171.57,43.01 161.25,43.01 160.06,44.19 160.06,44.51 v4(159.8,44.77)
SATA_TXP0_C: length 4.3
  BOTTOM w0.127: C499.1 196.74,90.61 199.58,90.61 CN6.2
SATA_TXP1: length 13.3
  IN2 w0.089: 153.22,98.25 153.24,98.26 153.29,98.26 153.69,98.66 154.55,98.66 154.67,98.53 154.91,98.53 154.96,98.59 v3(154.96,98.77)
  IN2 w0.133: 153.22,98.25 150.14,95.17 150.14,94.46 149.28,93.59 148.82,93.59 v3(148.55,93.87)
  BOTTOM w0.102: U24.AW10 155.26,99.26 154.96,98.96 v3(154.96,98.77)
  BOTTOM w0.127: TP118.1 147.15,93.16 147.85,93.87 v3(148.55,93.87)
SATA_TXP2: length 8.2
  TOP w0.102: 152.12,98.78 152.14,98.78 152.15,98.79 152.21,98.79 152.22,98.8 153.67,98.8 153.87,99 154.59,99 154.83,99.25 155.16,99.25 v3(155.66,99.75)
  TOP w0.127: TP44.1 149.76,96.96 149.9,97.09 150.32,97.09 151.99,98.77 152,98.77 152.01,98.78 152.12,98.78
  BOTTOM w0.102: v3(155.66,99.75) 155.66,100 U24.AW13
SATA_TXP4: length 11.6
  TOP w0.127: v3(148.36,97.78) 148.17,97.59 147.31,97.59 147.07,97.84 TP40.1
  IN2 w0.089: v3(154.63,100.71) 154.74,100.61 154.74,100.46 154.59,100.31 153.84,100.31 153.45,99.93 151.21,99.93 150.72,99.43
  IN2 w0.133: v3(148.36,97.78) 148.57,97.57 148.86,97.57 150.72,99.43
  BOTTOM w0.102: v3(154.63,100.71) 154.78,100.71 155.05,100.44 155.18,100.44 155.26,100.51 155.26,101.05 U24.AW15
SATA_TXP5: length 114.4
  TOP w0.127: C317.2 191.02,29.67 190.59,29.67 C320.2 189.38,29.7 187.9,29.7 187.04,30.56 187.04,32.59 186.57,33.06 186.34,33.06 v3(186.03,32.76)
  IN2 w0.089: 152.27,98.88 152.28,98.9 152.34,98.9 152.65,99.21 154.45,99.21 154.58,99.35 156.25,99.35 157.41,100.51 v3(157.41,100.72)
  IN2 w0.133: 152.27,98.88 148,94.62 147.4,94.02 147.4,91.9 149.23,90.07 149.23,88.4 149.18,88.35 149.18,85.84 149.38,85.64 149.38,83 150.7,81.68 150.7,78.02 151.15,77.57 151.15,74.75 154.19,71.72 155.02,71.72 156.5,70.24 156.5,65.03 155.76,64.28 155.76,52.25 156.64,51.36 156.64,43.86 156.72,43.78 158.93,41.57 181.51,41.57 183.7,39.39 183.7,34.23 185.02,32.9 185.89,32.9 v3(186.03,32.76)
  BOTTOM w0.102: v3(157.41,100.72) 157.21,100.92 U24.AR15
SATA_TXP5_C: length 4.1
  TOP w0.127: CN11.2 195.44,29.67 192.57,29.67 C317.1
SATA_TXP5_CN: length 8.6
  TOP w0.127: v3(188.27,29.08) C320.1
  BOTTOM w0.127: CN13.2 185.86,25.18 185.99,25.32 185.99,25.9 188.84,28.75 188.84,29.74 188.73,29.85 188.41,29.85 188.27,29.7 v3(188.27,29.08)
SB_ACDC: length 202.3
  TOP w0.127: v3(174.09,52.77) 173.9,52.97 168.61,52.97 168.45,53.13 U13.21
  IN1 w0.133: v3(174.09,52.77) 174.09,53.64 174.26,53.8 174.26,59.47 173.19,60.53 173.19,62.65 174.07,63.53 176.17,63.53 176.82,64.18 176.82,65.84 176.11,66.55 176.11,67.09 175.55,67.65 175.55,69.74 175.44,69.85 175.44,70.49 179.12,74.17 179.12,80.32 181.51,82.71 182.28,82.71 182.87,83.3 182.87,84.22 185,86.36 187.67,86.36 192.34,91.02 192.34,95.21 193.26,96.13 193.26,98.04 192.57,98.73 192.57,100.59 193.25,101.27 193.25,101.99 191.82,103.43 191.82,106.32 192.5,107.01 192.5,111.44 192.49,111.45 192.49,111.61 189.47,114.63 189.47,117.87 189,118.33 188.18,118.33 187.83,118.68 187.83,118.88 187.41,119.3 v3(187.41,121.25) ; v3(176.31,175.3) 173.39,178.22 168.16,178.22 167.06,179.32 166.15,179.32 165.21,178.38 158.96,178.38 155.59,181.75 153.76,181.75 152.59,182.92 150.17,182.92 149.39,182.14 v3(149.39,181.89)
  IN2 w0.133: v3(187.41,121.25) 188.15,120.51 190.72,120.51 190.89,120.33 191.41,120.33 191.72,120.64 191.72,121.04 194.49,123.82 194.49,163.4 193.9,163.99 193.9,167.62 190.06,171.46 183.53,171.46 179.9,175.09 176.52,175.09 v3(176.31,175.3)
  BOTTOM w0.127: v3(149.39,181.89) 149.39,182.03 149.89,182.53 149.89,185.25 PR18.1
SD_CD#_R: length 3.3
  TOP w0.127: CN1.10 20.45,20.39 v3(20.48,20.41)
  BOTTOM w0.127: R703.2 20.47,19.65 v3(20.48,19.65) 20.6,19.78 20.6,20.29 v3(20.48,20.41)
SD_CDZ: length 12.6
  IN2 w0.133: v3(29.21,17.6) 21.43,17.6 v3(21.08,17.24)
  BOTTOM w0.127: R703.1 v3(21.08,17.24) ; v3(29.21,17.6) 29.21,16.93 29.71,16.44 C542.1 29.85,16.22 30.64,15.43 U32.21
SD_CLK: length 22.3
  BOTTOM w0.127: U32.14 28.21,11.94 28.13,11.86 28.13,11.29 27.8,10.97 C556.1 26.73,11.26 26.48,11.52 23.7,11.52 23.55,11.67 23.55,15.94 v2(24.03,16.43) 24.9,17.29 24.9,20.69 25.01,20.8 25.37,20.8 25.53,20.63 25.53,16.92 25.7,16.75 26.18,16.75 26.32,16.89 R706.1
SD_CLK_R: length 15.9
  TOP w0.127: CN1.5 28.37,16.04 28.22,15.89 25.86,15.89 25.71,16.05 25.71,17.05 25.95,17.29 26.34,17.29 26.55,17.09 26.55,16.68 26.62,16.6 27.36,16.6 27.46,16.7 27.46,19.05 v3(27.26,19.25)
  BOTTOM w0.127: R706.2 26.32,19.2 26.48,19.36 26.48,20.5 26.65,20.67 27.13,20.67 27.26,20.54 v3(27.26,19.25)
SD_CMD: length 34.8
  IN2 w0.133: v3(35.82,17.52) 34.37,16.07 34.37,15.41 34.57,15.21 35.64,15.21 35.85,15.41 35.85,16.07 36.05,16.27 39.29,16.27 39.45,16.11 39.45,15.88 39.29,15.72 36.62,15.72 36.45,15.54 36.45,15.3 36.62,15.13 39.23,15.13 39.4,14.96 39.4,14.72 39.23,14.55 30.44,14.55 27.71,11.81 v3(27.71,11.53)
  BOTTOM w0.127: R700.1 37.49,18.6 37.7,18.4 37.7,18.1 37.49,17.9 36.2,17.9 v3(35.82,17.52) ; v3(27.71,11.53) 27.71,11.95 28.2,12.44 U32.15
SD_CMD_R: length 3.3
  TOP w0.127: v3(36.87,20.23) 36.12,20.23 35.87,19.98 CN1.2
  BOTTOM w0.127: R700.2 36.81,20.23 v3(36.87,20.23)
SD_D0/MS_D6: length 31
  BOTTOM w0.127: U32.13 28.6,11.44 27.93,10.78 27.93,10.6 28.54,9.99 28.54,9.81 28.34,9.61 28.16,9.61 27.39,10.38 27.16,10.38 C561.1 26.73,9.49 26.66,9.42 26.01,9.42 25.89,9.29 25.89,8.98 25.99,8.88 26.8,8.88 26.9,8.78 26.9,8.51 26.74,8.35 25.46,8.35 25.33,8.48 25.33,9.29 25.2,9.42 24.92,9.42 24.8,9.29 24.8,8.48 24.67,8.35 24.39,8.35 24.26,8.48 24.26,9.99 24.13,10.12 23.86,10.12 23.73,9.99 23.73,8.48 23.6,8.35 23.32,8.35 23.2,8.48 23.2,10.05 23.07,10.18 22.79,10.18 22.66,10.05 22.66,8.48 22.53,8.35 22.28,8.35 22.13,8.5 v2(22.13,14.32) 22.13,16.5 23.4,17.77 R705.1
SD_D1/MS_D7: length 32.6
  BOTTOM w0.127: R704.1 22.13,17.46 22.13,17.11 21.54,16.53 21.54,14.31 21.29,14.05 20.47,14.05 20.32,13.89 20.32,13.67 20.47,13.52 21.35,13.52 21.49,13.38 21.49,13.1 21.37,12.97 20.15,12.97 19.99,12.82 19.99,12.6 20.15,12.44 21.37,12.44 21.49,12.31 v2(21.49,11.65) 21.49,11.28 21.37,11.16 20.12,11.16 19.97,11 19.97,10.78 20.12,10.62 21.37,10.62 21.49,10.5 21.49,10.11 21.37,9.99 19,9.99 18.84,9.83 18.84,9.61 19,9.45 21.37,9.45 21.49,9.33 21.49,8.17 21.7,7.97 27.51,7.97 27.72,8.17 27.72,8.78 TP173.1 27.98,9.04 C562.1 29.64,9.77 U32.12
SD_D2/MS_D5: length 35.6
  IN2 w0.133: v3(27.79,13.58) 29.27,15.06 29.27,16.62 30.16,17.51 30.5,17.51 30.63,17.64 30.63,18.6 30.76,18.74 31.04,18.74 31.17,18.6 31.17,17.64 31.3,17.51 31.59,17.51 31.72,17.64 31.72,18.63 31.86,18.76 32.13,18.76 32.26,18.63 32.26,17.64 32.4,17.51 32.67,17.51 32.8,17.64 32.8,18.63 32.94,18.76 33.21,18.76 33.34,18.63 33.34,17.64 33.47,17.51 33.76,17.51 33.94,17.69 33.94,18.38 34.06,18.51 34.6,18.51 34.78,18.69 35.32,18.69 35.45,18.82 35.45,19.67 35.58,19.8 35.86,19.8 35.99,19.67 35.99,18.82 36.12,18.69 36.4,18.69 36.53,18.82 36.53,19.63 36.66,19.77 36.94,19.77 37.07,19.63 37.07,18.82 37.2,18.69 37.48,18.69 37.61,18.82 37.61,19.65 37.74,19.79 38.02,19.79 38.15,19.65 38.15,18.82 38.28,18.69 38.56,18.69 38.69,18.82 38.69,19.45 38.82,19.58 39.1,19.58 39.23,19.45 39.23,18.04 39.58,17.69 v3(40.79,17.69)
  BOTTOM w0.127: R701.1 v3(40.79,17.69) ; U32.17 28.36,13.44 27.92,13 C553.1 26.73,13.21 27.11,13.58 v3(27.79,13.58)
SD_D3/MS_D4: length 35.1
  IN2 w0.133: v3(27.26,12.54) 27.66,12.54 29.66,14.53 29.66,16.46 29.79,16.59 30.08,16.59 30.2,16.47 30.2,15.19 30.36,15.03 30.59,15.03 30.74,15.18 30.74,16.42 30.91,16.59 31.15,16.59 31.28,16.45 31.28,15.09 31.41,14.95 31.69,14.95 31.82,15.09 31.82,16.39 31.95,16.52 32.23,16.52 32.36,16.39 32.36,15.09 32.49,14.95 32.77,14.95 32.9,15.09 32.9,17.03 33.03,17.16 33.31,17.16 33.44,17.03 33.44,15.09 33.57,14.95 33.85,14.95 33.98,15.09 33.98,17.18 35.03,18.23 36.08,18.23 36.22,18.1 36.22,17.76 36.38,17.6 36.6,17.6 36.76,17.76 36.76,18.1 36.89,18.23 37.16,18.23 37.3,18.1 37.3,17.46 37.46,17.3 37.68,17.3 37.84,17.46 37.84,18.1 37.97,18.23 38.23,18.23 38.38,18.08 v3(38.38,17.65)
  BOTTOM w0.127: v3(27.26,12.54) 27,12.54 26.73,12.27 C555.1 27.33,11.98 28.3,12.94 U32.16 ; R699.1 v3(38.38,17.65)
SD_D4/MS_D0: length 2.8
  BOTTOM w0.127: TP175.1 31.02,8.42 31.02,9.73 31.14,9.85 U32.9
SD_D5/MS_D2: length 1.3
  BOTTOM w0.127: TP170.1 31.64,9.38 U32.8
SD_D6/MS_D3: length 1.9
  BOTTOM w0.127: U32.7 32.14,9.64 32.52,9.26 TP171.1
SD_D7/MS_CLK: length 3
  BOTTOM w0.127: U32.6 33.39,11.44 33.66,11.17 33.66,9.92 TP172.1
SD_DATA0_R: length 7.2
  TOP w0.127: v3(23.4,20.34) 23.78,20.34 24.31,19.8 24.31,17.8 24.13,17.62 23.56,17.62 23.37,17.8 CN1.7
  BOTTOM w0.127: R705.2 v3(23.4,20.34)
SD_DATA1_R: length 5.7
  TOP w0.127: CN1.8 21.23,19 21.04,19.2 21.04,20 21.36,20.33 v3(21.74,20.33)
  BOTTOM w0.127: v3(21.74,20.33) 21.74,19.68 21.97,19.46 22.53,19.46 22.68,19.31 22.68,18.74 22.56,18.62 R704.2
SD_DATA2_R: length 2.6
  TOP w0.127: v3(40.78,20.42) 40.87,20.33 CN1.9
  BOTTOM w0.127: R701.2 40.91,19.5 40.91,20.29 v3(40.78,20.42)
SD_DATA3_R: length 3.1
  TOP w0.127: CN1.1 38.37,19.81 38.57,20.01 39.32,20.01 v3(39.37,19.95)
  BOTTOM w0.127: v3(39.37,19.95) 38.82,19.95 R699.2
SD_GPIO0: length 2.3
  BOTTOM w0.127: U32.20 30.14,15.32 29,16.45 TP165.1
SD_WP/MS_D1: length 26.1
  BOTTOM w0.127: U32.10 30.64,8.55 TP174.1 29.67,7.59 20.1,7.59 18.46,9.23 18.46,9.99 19.61,11.14 19.61,13.73 21.11,15.23 21.11,16.53 20.4,17.24 19.8,17.24 R702.1
SD_WP_R: length 3.8
  TOP w0.127: CN1.11 19.25,20.52 v3(19.36,20.63)
  BOTTOM w0.127: v3(19.36,20.63) 19.08,20.35 19.08,18.75 R702.2
SGPIO: length 3.5
  TOP w0.102: R153.1 152.83,98.06
  TOP w0.127: R162.1 151,96.84 v2(151.79,97.63) 152.09,97.34 R157.1 152.83,98.06
SIO_EXT_SCI#: length 89.4
  TOP w0.127: v3(159.83,52.21) 160.12,51.93 165,51.93 165.41,52.33 U13.23
  IN1 w0.089: v3(169.39,100.72) 169.38,100.71 169.38,100.71
  IN1 w0.133: 169.38,100.71 171.19,100.71 172.24,99.66 173.03,99.66 173.44,99.25 173.65,99.25 173.7,99.2 174.08,99.2 174.13,99.25 178.16,99.25 179.41,98.01 181.97,98.01 183.82,96.15 185.65,96.15 v3(186.14,95.66) 186.14,94.87 186.05,94.77 186.05,92.98 185.45,92.38 184.84,92.38 184.11,93.11 182.65,93.11 180.68,91.14 179.53,91.14 176.33,87.95 174.26,87.95 173.42,88.79 172.84,88.79 172.58,88.53 172.58,88.14 172.63,88.09 172.63,87.6 171.28,86.24 171.28,82.44 168.37,79.54 168.37,79.08 167.08,77.79 167.08,73.45 164.07,70.44 164.07,65.1 163.6,64.63 163.6,58.72 161.62,56.75 161.62,54 v3(159.83,52.21)
  BOTTOM w0.102: v3(169.39,100.72) 168.99,101.13 U24.G15
  BOTTOM w0.127: R551.1 186.26,95.55 v3(186.14,95.66)
SIO_EXT_SMI#: length 87
  TOP w0.127: U13.15 166.74,55.53 166.63,55.41 166.63,55.06 166.16,54.59 166.16,53.82 165.72,53.38 164.55,53.38 163.82,54.11 163.56,54.11 163.44,54.22 162.3,54.22 161.95,54.56 v3(160.7,54.56)
  IN1 w0.089: v3(169.34,99.74) 169.54,99.74 169.96,99.32 170.98,99.32 171.35,98.95
  IN1 w0.133: v3(160.7,54.56) 161.27,55.13 161.27,56.78 163.33,58.83 163.33,64.27 162.25,65.34 162.25,69.47 162.76,69.98 162.76,73.85 168.1,79.19 168.1,79.66 170.93,82.48 170.93,87.96 172.03,89.07 176.03,89.07 176.05,89.09 176.05,89.09 177.09,89.09 179.42,91.42 180.57,91.42 182.54,93.38 184.22,93.38 184.88,92.72 185.4,92.72 185.73,93.05 185.73,93.63 v3(185.51,93.85) 184.47,94.89 182.95,94.89 181.47,96.36 179.17,96.36 178.15,97.38 172.23,97.38 171.71,97.9 171.71,98.59 171.35,98.95
  BOTTOM w0.102: v3(169.34,99.74) 169.58,99.99 U24.F13
  BOTTOM w0.127: R559.1 185.02,92.5 185.56,93.04 185.56,93.8 v3(185.51,93.85)
SKTOCC#: length 7.4
  TOP w0.127: TP16.1 94.26,116.19 95.85,114.6 v3(95.85,114.31)
  BOTTOM w0.127: U27.AP32 96.4,113.76 v3(95.85,114.31)
SLEEVE: length 8.2
  TOP w0.254: Q44.6 24.72,24.12 v3(24.62,24.03)
  IN2 w1.016: 21.75,23.36 23.95,23.36 v3(24.62,24.03) 25.87,25.28 25.87,26.2 26.53,26.87 26.82,26.87
  vias: v2(19.51,24.63) v3(19.71,26.21) v3(19.74,25.55) v3(20.17,23.92) v3(20.83,23.92) v3(25.97,29.1)
SLEEVE_R:
  vias: v3(15.9,28.06) v3(16.64,25.77)
SLP_A#: length 36.7
  TOP w0.127: v3(180.66,60.2) 181.23,60.77 U13.98
  BOTTOM w0.127: v3(180.66,60.2) 180.66,61.31 179.2,62.77 179.2,66.24 178.21,67.22 178.21,69.61 177.67,70.15 177.67,70.73 173.59,74.81 173.59,80.25 175.51,82.17 175.51,84.03 176.62,85.14 176.62,86.89 TP130.1 177.88,88.15 R583.2
SLP_S5#: length 56.5
  TOP w0.127: U13.99 180.83,61.24 179.76,60.17 179.76,59.33 178.74,58.3 178.74,57.76 176.78,55.8 174.94,55.8 173.9,54.75 170.42,54.75 v3(170.36,54.69) ; R212.2 163.9,89.43 163.41,88.94 163.41,88.62 163.26,88.46 163.26,87.3 TP57.1 163.51,86.49 163.51,81.85 163.24,81.58 v3(162.44,81.58)
  IN2 w0.133: v3(170.36,54.69) 170.35,54.7 168.54,54.7 167.18,56.06 167.18,57.68 164.59,60.27 164.59,64.61 164.11,65.09 164.11,66.78 164.43,67.1 164.43,72.61 162.86,74.18 162.86,81.16 162.44,81.58 v3(162.44,81.58)
SLP_SUS#: length 90.5
  TOP w0.127: v3(179.3,49.26) 180.6,49.26 182.47,51.13 U13.71
  IN1 w0.133: v3(176.06,86.38) 176.06,86.46 179.55,89.95 180.6,89.95 182.98,92.32 183.78,92.32 184.51,91.59 185.78,91.59 188.14,93.96 188.14,101.06 188.83,101.74 188.83,107.36 188.53,107.66 187.23,108.96 187.23,110.62 v3(187.38,110.77)
  BOTTOM w0.127: v3(179.3,49.26) 179.75,49.72 179.75,51.73 179.85,51.82 179.85,54.29 180.37,54.81 180.72,54.81 181.05,55.14 181.05,55.79 179.53,57.31 179.53,61.66 178.69,62.5 178.69,65.49 177.53,66.65 177.53,67.25 176.71,68.06 176.47,68.31 176.47,69.52 176.46,69.52 176.46,71.01 v2(175.87,71.6) 175.87,71.8 173.08,74.6 173.08,80.46 175,82.38 175,84.24 176.06,85.3 v3(176.06,86.38) 176.06,87.1 176.71,87.75 R588.2 ; 185.75,113.61 187.33,112.03 187.33,110.83 v3(187.38,110.77) ; 185.75,113.61 185.75,114.27 Q48.2 ; 185.75,113.61 184.51,112.36 Q50.2
SM_INTRUDER#: length 6.3
  TOP w0.127: R158.2 175.85,97.15 v2(175.8,97.2) 175.16,97.83 174.22,97.83 v3(173.83,98.22)
  BOTTOM w0.102: v3(173.83,98.22) 173.33,97.72 172.34,97.72 171.7,98.35 U24.A8
SM_RCOMP_0: length 11.9
  TOP w0.381: R252.1 v2(90.73,77.26) 90.73,77.62 95.14,82.02 95.14,82.54 95.93,83.33 v3(95.93,84.16)
  BOTTOM w0.254: v3(95.93,84.16) 96.4,84.62 U27.AP3
SM_RCOMP_1: length 12.6
  TOP w0.381: R253.1 v2(89.51,75.71) 89.51,78.33 93.03,81.85 93.03,82.26 v3(94.93,84.16)
  BOTTOM w0.305: v3(94.93,84.16) U27.AR3
SM_RCOMP_2: length 9.7
  TOP w0.381: v3(96.92,83.15) 96.92,82.95 96.35,82.38 96.35,81.79 v2(93.15,78.58) 91.95,77.39 R251.1
  BOTTOM w0.305: v3(96.92,83.15) 96.92,83.16 U27.AP2
SMB_ME0_CLK: length 7
  TOP w0.089: v3(164.98,97.91) 165.54,97.34 165.54,97.08 166.05,96.57 166.05,95.04 166.14,94.95 166.14,94.72 166.1,94.69 166.1,94.66
  TOP w0.127: 166.1,94.66 166.1,93.98 166.71,93.37 166.71,92.81 166.52,92.62 R186.2
  BOTTOM w0.102: v3(164.98,97.91) 164.82,97.91 U24.U8
SMB_ME0_DAT: length 6.7
  TOP w0.089: v3(165.93,97.9) 166.4,97.43 166.4,97.03 166.23,96.85 166.23,95.11 166.31,95.03 166.31,94.72 166.35,94.69 166.35,94.66
  TOP w0.127: 166.35,94.66 166.35,94.09 166.96,93.47 166.96,92.88 167.22,92.62 R187.2
  BOTTOM w0.102: v3(165.93,97.9) 165.92,97.9 165.69,97.67 U24.R7
SMB_ME1_CLK: length 20
  TOP w0.127: Q27.3 175.13,86.81 R224.2 173.85,86.1 172.85,85.11 172.19,85.11 v3(172.04,85.26)
  IN2 w0.089: v3(167.88,97.24) 167.54,96.9 167.54,95.7 167.58,95.66 167.58,95.65
  IN2 w0.133: v3(172.04,85.26) 171.87,85.09 171.56,85.09 171.33,85.32 171.33,86.66 170.54,87.45 170.54,89.23 170.04,89.74 170.04,91.9 168.64,93.29 168.64,94.2 167.58,95.26 167.58,95.65
  BOTTOM w0.102: U24.K6 167.72,97.07 v3(167.88,97.24)
SMB_ME1_DAT: length 22.7
  TOP w0.127: Q29.3 175.61,84.4 174.71,85.31 R230.2 173.41,85.31 172.96,84.85 172.34,84.85 v3(172.07,84.58)
  IN2 w0.089: 167.32,95.65 167.32,95.66 167.36,95.7 167.36,98.72 v3(166.89,99.19)
  IN2 w0.133: v3(172.07,84.58) 171.81,84.83 171.45,84.83 171.07,85.21 171.07,86.56 170.28,87.34 170.28,89.12 169.78,89.63 169.78,91.79 168.38,93.19 168.38,94.1 167.32,95.15 167.32,95.65
  BOTTOM w0.102: U24.N11 166.68,99.19 v3(166.89,99.19)
SMB_PCH_CLK: length 79.3
  TOP w0.127: Q22.3 182.14,93.6 181.55,93.01 181.55,92 180.8,91.26 178.72,91.26 R196.2 177.91,91.16 177.34,91.16 v4(177.31,91.13)
  IN1 w0.133: v4(177.31,91.13) 177.13,91.31 175.37,91.31 173.64,89.58 171.13,89.58 170.41,88.86 170.41,87.68 169.58,86.85 169.58,83.89 169.62,83.86 169.62,81.9 167.44,79.72 167.44,79.26 161.74,73.56 161.74,65.13 162.81,64.06 162.81,60.25 162.23,59.67 162.23,59.12 159.34,56.22 159.34,54.03 v3(158.79,53.48)
  IN2 w0.089: v3(165.93,98.55) 165.53,98.95 165.53,99.37 165.58,99.41 165.58,100.03 165.8,100.26 166.34,100.26 166.37,100.22 166.47,100.12 168.5,100.12 168.51,100.13 168.99,100.13 169.01,100.15 169.88,100.15 169.95,100.21 170.07,100.21
  IN2 w0.133: 170.07,100.21 170.33,100.21 170.46,100.08 170.61,100.08 171.56,99.13 171.56,98.08 174.27,95.37 174.27,92.36 175.26,91.36 177.07,91.36 v4(177.31,91.13)
  BOTTOM w0.102: U24.R10 165.63,98.86 165.93,98.56 v3(165.93,98.55)
  BOTTOM w0.127: Q55.3 v3(158.79,53.48)
SMB_PCH_DAT: length 82.8
  TOP w0.127: v3(177.4,91.87) 177.41,91.87 178.02,91.87 178.26,92.11 R180.2 178.86,91.51 180.69,91.51 181.29,92.11 181.29,93.12 183.05,94.87 185.81,94.87 Q23.3
  IN1 w0.133: v3(158.79,54.16) 159.08,54.44 159.08,56.33 161.97,59.23 161.97,59.78 162.55,60.36 162.55,63.95 161.48,65.03 161.48,73.66 167.18,79.37 167.18,79.83 169.35,82.01 169.35,83.75 169.32,83.78 169.32,86.95 170.15,87.78 170.15,88.97 171.03,89.84 173.53,89.84 175.26,91.57 177.09,91.57 v3(177.4,91.87)
  IN2 w0.089: v3(164.98,99.22) 165.4,99.64 165.4,100.11 165.54,100.24 165.73,100.44 165.95,100.44 165.95,100.44 166.41,100.44 166.55,100.3 168.43,100.3 168.44,100.31 168.92,100.31 168.93,100.32 169.81,100.32 169.87,100.39 169.98,100.39 170.06,100.47 170.07,100.47
  IN2 w0.133: v3(177.4,91.87) 177.15,91.62 175.37,91.62 174.53,92.46 174.53,95.48 171.82,98.19 171.82,99.24 170.72,100.34 170.57,100.34 170.44,100.47 170.07,100.47
  BOTTOM w0.102: U24.U11 164.71,99.22 v3(164.98,99.22)
  BOTTOM w0.127: Q54.3 v3(158.79,54.16)
SMB_RUN_CLK: length 106.6
  TOP w0.127: v3(184.52,88.95) 183.92,89.55 R199.1 184.28,90.36 Q22.1
  IN1 w0.133: v3(184.52,88.95) 184.08,88.95 182.73,87.6 182.73,87.35 179.52,84.14 177.57,84.14 172.25,78.82 172.25,71.86 171.54,71.15 171.54,68.96 172.33,68.18 172.33,65.08 v3(171.38,64.13) 170.58,63.34 170.58,60.6 168.06,58.07 168.06,52.75 164.51,49.2 163.47,49.2 162.68,48.42 160.85,48.42 160.55,48.12 155.08,48.12 153.7,46.73 150.94,46.73 143.18,38.97 143.18,38.16 141.53,36.52 v3(141.28,36.52)
  BOTTOM w0.127: R672.2 172.08,64.13 v3(171.38,64.13) ; v3(141.28,36.52) 137.57,36.52 136.75,37.34 JDIM2.202 136.75,39.95 136.6,40.11 136.6,42.43 139.37,45.2 139.37,48.31 137.98,49.7 136.84,49.7 136.6,49.94 136.6,50.39 136.75,50.55 JDIM1.202
SMB_RUN_DAT: length 111.4
  TOP w0.127: v4(185.22,89.26) 185.26,89.3 186.35,89.3 R198.1 187.25,90.01 188.09,90.85 Q23.1
  IN1 w0.133: v4(185.22,89.26) 184.97,89.51 184.25,89.51 182.32,87.58 182.32,87.34 179.44,84.46 177.51,84.46 170.01,76.96 170.01,72.48 171.03,71.46 171.03,69.09 171.59,68.53 171.59,65.78 170.31,64.5 170.31,62.83 170.12,62.65 v3(170.12,60.91) 170.12,60.52 167.78,58.18 167.78,52.87 164.39,49.48 163.36,49.48 162.57,48.69 160.74,48.69 160.43,48.39 154.97,48.39 154.3,47.72 151.54,47.72 142.9,39.08 142.9,38.37 141.51,36.98 141.09,36.98 140.54,36.43 v3(140.54,35.98)
  BOTTOM w0.127: v3(170.12,60.91) 171.34,62.12 171.34,62.54 R671.2 ; v3(140.54,35.98) 137.49,35.98 136.15,37.33 JDIM2.200 136.15,39.95 136.31,40.11 136.31,42.55 139.07,45.32 139.07,48.19 137.85,49.4 136.72,49.4 136.31,49.81 136.31,50.27 136.31,50.27 136.31,50.39 136.15,50.55 JDIM1.200
SMB_XDP_CLK: length 4.7
  BOTTOM w0.127: Q55.1 156.41,52.51 R678.1 154.8,50.89 TP162.1 154.13,52.22 TP161.1
SMB_XDP_DAT: length 6.2
  BOTTOM w0.127: Q54.1 153.99,56.45 TP158.1 154.32,55.47 TP160.1 155.12,54.26 R677.1
SMBALERT#: length 6.4
  TOP w0.127: v3(166.91,97.22) 166.46,96.77 166.46,96.37 166.67,96.15 166.67,95.39 166.86,95.2 166.86,94.3 167.47,93.68 167.48,93.68 v3(167.57,93.59) 168.54,92.62 R188.2
  BOTTOM w0.102: v3(166.91,97.22) 166.91,97.22 166.46,97.67 U24.N7
SMDDR_VREF_DQ0_M1: length 1
  TOP w0.762: R313.2 v2(72.06,51.89)
SMDDR_VREF_DQ1_M1:
  vias: v2(71.94,63.52)
SP_PLLVDD: length 1.4
  BOTTOM w0.381: v3(153.77,158.74) 153.77,158.76 U19.N6 U19.M6
  vias: v3(154.13,158.16)
SPI_CLK: length 3.2
  BOTTOM w0.127: R645.2 145.43,79.27 R648.2 146.59,79.26 U30.6
SPI_CS0#: length 3.5
  BOTTOM w0.127: U30.1 149.13,68.55 149.41,68.27 R661.2 R660.2
SPI_CS0#_UR_ME: length 53
  TOP w0.127: U13.101 180.03,60.96 179.26,60.19 179.26,59.54 177.92,58.21 176.64,58.21 173.69,55.26 169.42,55.26 168.98,55.7 v3(168.98,56.98)
  BOTTOM w0.127: v3(168.98,56.98) 168.57,57.39 163.34,57.39 162.29,58.44 153.72,58.44 151.58,60.58 151.58,60.97 152.06,61.44 152.06,61.68 151.89,61.85 151.65,61.85 151.11,61.31 150.85,61.31 150.66,61.5 150.66,61.75 151.14,62.23 151.14,62.47 150.96,62.65 150.72,62.65 150.37,62.3 150.02,62.3 149.35,62.97 149.35,63.19 149.51,63.35 150.63,63.35 150.78,63.51 150.78,63.73 150.63,63.88 148.91,63.88 148.77,64.02 148.77,64.22 148.91,64.37 150.65,64.37 150.8,64.52 150.8,64.73 150.65,64.89 149.39,64.89 v2(148.95,65.32) 148.95,66.38 R661.1
SPI_HD#: length 3.6
  BOTTOM w0.127: R644.2 148.3,79.27 R649.1 147.86,79.26 U30.7
SPI_SI: length 4.4
  BOTTOM w0.127: U30.5 145.32,77.59 144.73,78.17 v2(143.95,78.17) 143.95,78.63 144.1,78.78 R647.2 R646.2
SPI_SO: length 3.8
  BOTTOM w0.127: U30.2 147.86,68.6 R659.2 R658.2
SPI_WP#: length 6.3
  BOTTOM w0.127: R663.2 144.33,65.75 R657.2 144.79,66.83 144.93,66.97 144.93,67.71 145.52,68.29 146.1,68.29 146.59,68.78 U30.3
SPKR: length 197.6
  TOP w0.254: 157.13,94.39 157.13,95.45 157.99,96.31 157.99,97.96 v3(158.47,98.44)
  TOP w0.381: 157.13,90.21 156.89,90.21 156.56,89.88 156.56,88.33 155,86.77 v2(155,82.75) 155,81.82 v3(155,81.82) ; 157.13,90.21 157.13,94.38 157.13,94.39 ; 157.13,90.21 R209.1 ; D12.2 30.87,38.8 32.72,40.66 39.2,40.66 v3(39.31,40.77)
  IN1 w0.381: v3(39.31,40.77) 40.61,40.77 41.36,40.02 41.36,39.07 42.98,37.44 42.98,36.63 44.39,35.22 45.74,35.22 48,32.96 49.05,32.96 50.08,31.93 50.08,25.13 50.91,24.31 54.08,24.31 56.22,26.45 65.81,26.45 68.69,29.33 71.06,29.33 77.05,35.31 84.46,35.31 85.31,34.46 95.52,34.46 96.32,33.66 111.62,33.66 112.27,34.31 122.63,34.31 124.56,36.23 131.69,36.23 137.25,41.8 137.25,42.63 140.14,45.52 140.5,45.52 148.11,53.13 149.07,53.13 151.85,55.91 151.85,55.94 156.52,60.62 156.52,64.04 157.17,64.69 157.17,66.64 156.7,67.11 156.7,68.59 157.07,68.96 157.07,71.64 156.33,72.39 156.33,73.28 156.71,73.66 156.71,80.1 155,81.82 v3(155,81.82)
  BOTTOM w0.254: v3(158.47,98.44) 158.6,98.44 158.97,98.8 U24.AL10
SRTC_RST#: length 10.1
  TOP w0.127: v3(173.18,98.15) 173.18,96.67 v2(173.18,96.67) 173.18,96.23 173.75,95.66 173.75,94.68 173.46,94.38 173.46,93.91 C204.1 173.84,93.85 173.84,94.13 174.09,94.38 175.3,94.38 R173.2
  BOTTOM w0.102: U24.B9 171.14,98.86 171.97,98.86 172.28,98.56 172.68,98.56 173.09,98.15 v3(173.18,98.15)
STP_A16OVR: length 2.6
  TOP w0.127: R167.2 157.63,95.44 158.37,96.18 158.37,96.71 v3(158.51,96.84)
  BOTTOM w0.102: v3(158.51,96.84) 158.74,96.84 U24.AL6
STRAP0: length 8.9
  BOTTOM w0.127: R418.1 165.28,164.76 163.69,164.76 R415.1 161.36,165.23 v2(161.35,165.25) 161.22,165.25 159.7,166.77 157.7,166.77 157.57,166.64 U19.D1
STRAP1: length 10.5
  BOTTOM w0.127: U19.D2 156.85,166.64 157.23,166.26 157.55,166.26 157.8,166.52 158.99,166.52 161.45,164.05 v2(162.13,164.05) 162.14,164.04 R420.1 163.84,163.39 164.97,163.39 R421.1
STRAP2: length 14.4
  BOTTOM w0.127: U19.E4 154.99,165.48 155.41,165.06 155.41,164.78 155.67,164.52 155.95,164.52 156.21,164.26 156.21,163.98 156.46,163.73 156.8,163.73 157.01,163.52 157.64,163.52 158.55,162.61 158.55,161.33 159.6,160.28 v2(162.16,160.28) 163.11,160.28 R429.2 163.66,160.83 164.27,160.83 164.95,160.14 R430.2
STRAP3: length 11.8
  BOTTOM w0.127: R423.1 165.14,162.35 163.66,162.35 R422.1 162.15,162.85 v2(162.08,162.78) 161.7,163.16 161.7,163.44 158.88,166.26 157.91,166.26 157.65,166.01 157.13,166.01 156.96,166.17 156.17,166.17 U19.E3
STRAP4: length 10.6
  BOTTOM w0.127: R411.1 164.61,166.77 163.66,166.77 R410.2 162.14,166.3 v2(162.13,166.31) 160.73,166.31 159.98,167.06 156.21,167.06 U19.D3
SUS_PWR_ACK: length 31.4
  TOP w0.127: v3(164.57,65.93) 165.68,65.93 R281.1 166.02,65.02 166.73,64.31 v2(167.14,64.31) 167.26,64.43 168.09,64.43 168.59,63.92 168.88,63.92 169.23,63.57 U13.128
  IN1 w0.133: v3(173.15,86.19) 173.15,83.91 168.69,79.44 168.69,79 167.36,77.67 167.36,73.34 164.57,70.56 164.57,65.93 v3(164.57,65.93)
  BOTTOM w0.127: v3(173.15,86.19) 173.25,86.52 173.25,86.87 R605.2
SUS_STAT#: length 3
  TOP w0.089: TP47.1 165.6,95.33 165.6,96.73 165.07,97.26 v3(164.97,97.26)
  BOTTOM w0.102: U24.U7 164.87,97.26 v3(164.97,97.26)
SUSACK#: length 38.5
  TOP w0.127: U13.2 166.82,60.73 166.6,60.95 166.42,60.95 165.89,61.48 v2(165.89,62.43) 165.89,62.81 163.61,65.1 v3(163.61,65.45)
  BOTTOM w0.127: R624.1 172.82,83.39 170.71,81.27 170.71,74.82 174.13,71.39 174.13,69.76 174.93,68.96 174.93,68.14 172.67,65.88 166.2,65.88 165.77,65.45 v3(163.61,65.45)
SUSACK#_R: length 18.9
  IN1 w0.133: v3(165.94,97.25) 166.17,97.02 166.17,95.99 167.44,94.72 167.61,94.72 167.71,94.72 168.78,93.66 171.94,93.66 172.42,93.19 172.42,92.6 171.61,91.8 v3(171.61,91.3)
  BOTTOM w0.102: U24.R6 165.76,97.07 v3(165.94,97.25) ; 172.34,90.71 172.32,90.71 171.73,91.3 v3(171.61,91.3)
  BOTTOM w0.127: R624.2 172.47,85.78 172.47,86.39 172.63,86.54 172.63,86.68 172.63,88.65 173.26,89.28 R581.1 172.93,89.43 172.53,89.82 172.53,90.52 172.34,90.71
SUSB#: length 41.6
  TOP w0.127: v3(180.53,55.45) 180.61,55.53 U13.82
  BOTTOM w0.127: v3(180.53,55.45) 179.02,56.97 179.02,60.3 178.18,61.14 178.18,65.28 177.02,66.44 177.02,67.04 176.5,67.56 176.5,67.56 175.95,68.11 175.95,69.38 175.15,70.18 175.15,71.81 172.57,74.39 172.57,80.67 174.49,82.59 174.49,84.45 175.5,85.45 TP133.1 175.96,87.81 175.96,88.64 175.55,89.05 R582.2
SUSC#: length 49.6
  TOP w0.127: v3(181.56,56.2) 182.04,56.2 182.32,55.93 U13.83
  BOTTOM w0.127: R548.2 180.1,96.16 180.85,96.16 181.12,95.89 181.12,91.95 TP127.1 178.39,89.23 178.39,87.88 177.13,86.61 177.13,84.93 176.39,84.19 176.39,82.34 174.1,80.04 174.1,75.02 178.18,70.94 178.18,70.48 178.72,69.94 178.72,67.44 179.71,66.45 179.71,63.04 181.26,61.49 181.26,59.61 180.66,59 180.66,56.91 181.36,56.2 v3(181.56,56.2)
SUSCLK: length 2.2
  TOP w0.127: R221.1 164.58,88.41 164.58,88.98 165.03,89.43 R213.2
SUSD: length 69
  IN1 w0.133: v3(130.81,18.43) 134.74,22.37 142.03,22.37 144.01,24.35 146.99,24.35 148.87,26.23 156.14,26.23 157.83,24.54 157.83,21.37 159.53,19.66 165.6,19.66 169.52,15.74 171.14,15.74 172.97,13.91 v3(173.51,13.91)
  BOTTOM w0.127: v3(173.51,13.91) 173.11,14.32 PQ42.2 ; PQ52.3 130.63,9.4 PR215.2 131.99,9.86 PR216.2 133.18,9.86 PC163.2 133.93,10.61 133.93,12.57 v2(131.73,14.78) 131.73,17.51 v3(130.81,18.43)
SUSLED#: length 131.7
  TOP w0.203: U13.28 166.42,50.33 166.17,50.08
  TOP w0.254: 166.17,50.08 165.1,49.02 165.1,46.88 164.74,46.52 146.66,46.52 144.5,44.37 144.5,33.04 136.37,24.91 82.35,24.91 67.06,9.62 67.06,8.4 65.94,7.28 v2(64.62,7.28) 64.37,7.28 v3(63.91,7.74)
  BOTTOM w0.254: R721.1 v3(63.91,7.74) R725.1
SUSON: length 185.8
  TOP w0.127: v3(154.45,69.64) 155.18,69.64 155.79,69.03 163.66,69.03 164.39,69.76 165.87,69.76 165.91,69.8 166.89,69.8 169.3,67.39 169.3,66.03 169.87,65.46 R282.1 169.87,65.01 171.23,63.64 U13.123
  IN1 w0.133: v3(146.27,56.07) 147.28,56.07 149.63,58.42 149.63,59.05 152.8,62.22 152.8,68 v3(154.45,69.64) ; v3(121.59,13.79) 121.59,10.61 124.41,7.79 129.04,7.79 129.28,8.03 v3(130.03,8.03) 130.24,8.03 135.41,13.2 v3(136.17,13.2)
  BOTTOM w0.127: v3(146.27,56.07) 146.88,55.46 146.88,53.39 147.7,52.57 147.7,42.21 145.61,40.11 145.61,37.11 146.12,36.61 146.12,29.13 136.2,19.21 v2(136.2,17.65) 136.2,13.23 v3(136.17,13.2) ; v3(121.59,13.79) 121.59,14.27 112.48,23.39 109.69,23.39 107.12,20.81 80.26,20.81 77.69,18.24 64.38,18.24 60.08,22.55 60.08,26 59.08,26.99 PR78.2 ; PQ51.2 129.59,7.59 v3(130.03,8.03)
SV_DET: length 8
  BOTTOM w0.102: U24.D13 170.65,100.39 170.93,100.11 170.94,100.1 171.19,100.1 171.19,100.11 171.21,100.11 171.39,100.28 171.79,100.28 172.09,99.98 173.63,99.98 173.93,100.27 174.14,100.27
  BOTTOM w0.127: R536.1 177.16,100.48 175.56,100.48 R538.1 174.85,100.27 174.14,100.27
SYS_HWPG: length 268.9
  TOP w0.127: v3(40.87,54.96) 40.87,54.73 40.47,54.32 39.2,54.32 36.02,51.15 36.02,49.75 35.3,49.03 30.95,49.03 v3(30.89,48.97) ; D6.1 v3(193.12,57.09)
  IN1 w0.133: v3(193.12,57.09) 193.12,53.19 191.04,51.11 191.04,17.98 186.39,13.34 185.67,13.34 184.48,12.16 180.34,12.16 175.81,7.64 173.31,7.64 170.87,10.08 170.87,11.06 166.52,15.41 159.58,15.41 153.19,21.8 151.58,21.8 151.13,21.35 149.14,21.35 147.49,19.7 137.87,19.7 132.71,14.54 120.57,14.54 120.38,14.35 120.38,9.5 116.97,6.09 110.39,6.09 107.68,8.8 102.71,8.8 95.55,15.96 80.98,15.96 76.51,11.49 71.07,11.49 68.79,13.77 50.22,13.77 43.54,20.45 43.54,23.2 44,23.66 44,26.74 43.29,27.45 43.29,28.06 37.77,33.57 35.77,33.57 34.79,34.56 34.79,36.12 34.5,36.41 34.5,36.62 30.74,40.38 30.74,47.62 30.48,47.87 30.48,48.57 v3(30.89,48.97)
  BOTTOM w0.127: PR46.2 39.75,55.5 40.01,55.24 40.59,55.24 v3(40.87,54.96)
SYS_PEX_RST_MON#: length 31.2
  IN1 w0.133: v3(161.09,153.15) 158.62,155.62 v3(158.62,165.12)
  BOTTOM w0.127: v3(158.62,165.12) 158.5,165.25 157.68,165.25 157.56,165.37 155.58,165.37 155.37,165.58 155.37,166.85 155.17,167.05 154,167.05 153.7,166.74 153.7,166.39 153.54,166.23 151.2,166.23 U19.E9 ; v3(161.09,153.15) 161.09,151.86 v2(162.13,150.82) 162.52,150.43 R437.1 163.48,150.34 R439.1 165.18,150.56 166,151.38 U21.2
SYS_PWROK: length 211.8
  TOP w0.089: v3(161.42,97.26) 161.8,96.88 161.8,96.03 161.9,95.93 161.9,94.88 161,93.97
  TOP w0.127: v3(161.98,81.07) 161.57,81.48 161.57,85.18 161.19,85.57 161.19,86.27 160.86,86.6 160.86,87.49 160.06,88.29 159.82,88.29 159.17,88.93 159.04,88.93 158.8,89.17 158.8,89.94 159.12,90.26 R201.1 159.85,90.26 160.68,91.1 160.68,93.66 160.92,93.9 161,93.97 ; v3(159.8,76.88) 160.51,76.88 162.31,78.67 168.14,78.67 170.51,81.04 176.18,81.04 176.49,80.73 178.85,80.73 179.48,81.36 179.48,82.09 TP61.1 181.02,82.51 R235.1 181.67,82.21 181.94,81.93 182.41,81.93 U8.4 ; U12.1 76.39,68.36 76.59,68.16 77.97,68.16 78.17,67.95 R277.2 78.17,40.69 77.5,40.02 76.84,40.02 75.73,38.92 75.73,33.25 75.06,32.58 v3(75.06,28.85)
  IN1 w0.133: v3(75.06,28.85) 76.35,28.85 79.44,31.94 82.61,31.94 83.36,31.19 113.16,31.19 113.98,32.01 115.05,32.01 115.77,31.29 132.42,31.29 139.12,37.98 139.12,39.51 144.72,45.11 144.72,45.19 158.93,59.41 158.93,60.43 159.19,60.68 159.19,76.26 v3(159.8,76.88) 161.98,79.06 v3(161.98,81.07)
  BOTTOM w0.102: v3(161.42,97.26) 161.44,97.26 161.85,97.67 U24.AD7
SYS_RESET#: length 12.8
  BOTTOM w0.089: 158.6,88.57 159.6,89.57 159.6,91.88 158.45,93.02 158.45,95.04 U24.AM1
  BOTTOM w0.102: 156.75,85.7 156.75,85.83 157.34,86.42 157.34,87.92 157.49,88.07 158.09,88.07 158.6,88.57
  BOTTOM w0.127: R617.2 R618.1 156.75,85.7
SYS_SHDN#: length 255.1
  TOP w0.127: v3(103.94,139.13) 103.94,133.83 77.53,107.41 72.04,107.41 70.38,105.75 64.21,105.75 63.8,105.34 63.8,105.34 62.53,104.07 61.18,104.07 60.71,103.6 58.93,103.6 58.22,104.31 PQ34.3 57.28,105.18 57.28,103.85 56.47,103.04 v2(48.52,103.04) v3(47.76,103.04) ; v3(171.28,141.8) 170.29,140.81 167.54,140.81 165.05,138.32 161.01,138.32 159.82,139.52 159.01,139.52 158.3,138.8 158.3,135.81 156.87,134.38 155.09,134.38 v3(154.49,134.99) ; v3(36.02,64.28) 36.62,63.68 PR45.2 ; Q60.3 v3(175.75,173.12) ; PU3.6 40.73,57.58 v3(40.21,57.07) 39.33,57.07 PR44.2
  IN1 w0.133: v3(36.02,64.28) 36.21,64.47 36.21,71.27 37.03,72.09 37.03,80.48 37.95,81.4 37.95,84.8 35.79,86.96 35.79,94.25 37.41,95.86 37.41,99.66 38.42,100.67 39.41,100.67 41.77,103.04 v3(47.76,103.04) ; v3(175.75,173.12) 175.75,172.1 172.67,169.03 172.67,157.9 171.66,156.9 171.66,145.29 171,144.62 171,142.08 v3(171.28,141.8)
  IN2 w0.133: v3(154.49,134.99) 153.77,135.71 139.19,135.71 138.86,136.03 137.27,137.62 116.99,137.62 114.99,139.62 104.32,139.62 103.94,139.24 v3(103.94,139.13)
  BOTTOM w0.127: v3(36.02,64.28) 35.92,64.18 35.92,58.08 36.94,57.07 v3(40.21,57.07)
SYSTEM_AGND: length 1
  TOP w0.254: v3(36.89,59.23) 37.01,59.35 PR55.2
  vias: v2(36.73,59.94)
TD_IREF: length 8.8
  BOTTOM w0.102: 154.93,114.06 154.93,113.65 155.29,113.29 U24.AY43
  BOTTOM w0.254: 154.93,114.06 154.19,114.8 153.01,114.8 150.63,117.17 150.14,117.17 149.91,117.41 149.91,117.76 R469.1
TEMP_MBAT: length 174.5
  TOP w0.127: v3(189.61,188.58) 189.26,188.94 189.26,189.6 189.14,189.72 PU2.3 187.82,189.72 186.38,188.28 183.93,188.28 v2(183.72,188.49) 183.11,189.1 183.11,189.58 182.71,189.98 182.71,190.75 182.49,190.96 PR35.1 181.98,190.96 181.2,190.18 PR30.2 ; v3(180.73,50.97) 181.51,50.97 182.47,51.93 U13.73
  IN1 w0.133: v3(189.61,188.58) 189.93,188.58 190.15,188.36 190.15,183.46 192.56,181.06 192.56,174.29 193.79,173.05 193.79,172.43 195.25,170.98 195.25,168.97 195.23,168.94 195.23,164.7 195.68,164.25 195.68,141.01 194.68,140.01 194.68,128.73 193.78,127.83 193.78,126.63 193.78,126.63 193.78,124.98 190.83,122.03 190.54,122.03 190.24,121.73 190.09,121.58 189.47,121.58 189.08,121.2 189.08,120.57 188.84,120.33 188.84,119.26 190.01,118.09 190.01,114.86 194.32,110.55 194.32,100.99 193.41,100.07 193.41,98.92 194.05,98.28 194.05,96.15 192.88,94.98 192.88,90.79 191.67,89.58 187.9,85.81 186.15,85.81 185.07,84.73 185.07,84.73 182.51,82.17 182.28,82.17 181.74,82.17 179.95,80.38 179.95,74.02 176.65,70.72 176.65,69.8 176.36,69.51 176.36,68.26 176.66,67.96 177.9,67.96 179.35,66.52 179.35,66.5 179.88,65.96 179.88,56.93 178.33,55.38 178.33,54.16 180.73,51.76 v3(180.73,50.97)
TESTLO: length 16
  TOP w0.203: R46.2 117.6,127.49 v2(117.15,127.04) 116.08,125.98 116.08,123.82 112.5,120.24 112.5,115.69 v3(111.92,115.12)
  BOTTOM w0.127: U27.W34 111.4,115.69 111.92,115.17 v3(111.92,115.12)
TESTMODE: length 8.4
  TOP w0.127: v3(153.5,144.65) 153.19,144.34 R44.2
  IN1 w0.133: v3(150.43,150.45) 151.91,148.97 151.91,146.24 v3(153.5,144.65)
  BOTTOM w0.127: U19.AD9 150.81,150.07 v3(150.43,150.45)
TH_FAN_POWER: length 12.7
  BOTTOM w0.762: 59.44,101.62 58.3,102.76 58.3,103.88 57.36,104.82 57.13,104.82 56.16,105.78 56.16,106.8 57.66,108.3 CN3.1 ; 63.1,101.36 v2(63.35,101.62) 63.71,101.97 C448.2 63.72,102.62 C438.2
THERM+: length 3.2
  TOP w0.127: v3(148.73,164.6) 148.35,164.22 148.35,163.73 148.64,163.44 149.68,163.44 TP8.1
  BOTTOM w0.127: U19.F12 148.73,164.6 v3(148.73,164.6)
THERM-: length 5.8
  TOP w0.102: 147.35,167.03 147.35,166.62 147.5,166.46 147.5,165.88 v3(147.94,165.45)
  TOP w0.127: 147.35,167.03 147.35,167.15 146.29,168.21 146.29,169.83 TP5.1
  BOTTOM w0.127: U19.E12 147.94,165.45 v3(147.94,165.45)
TP_INT: length 2.7
  TOP w0.127: v3(109.35,188.18) 109.28,188.11 TP3.1
  BOTTOM w0.127: v3(109.35,188.18) 109.75,188.58 CN2.5
TP_PWR: length 5
  TOP w0.508: v3(117.1,176.75) 117.73,176.12 R5.1
  BOTTOM w0.508: 113.16,176.42 v2(115.78,176.42) 116.29,176.42 116.62,176.75 v3(117.1,176.75)
TP_RST#: length 3.3
  TOP w0.127: v3(109.26,188.83) 108.68,188.83 TP2.1
  BOTTOM w0.127: CN2.4 109.52,189.08 v3(109.26,188.83)
TP_VSS_NCTF2: length 11
  BOTTOM w0.102: 152.46,96.14 152.46,96.41 U24.BE5
  BOTTOM w0.127: 152.46,96.14 152.46,96 152.15,95.7 152.15,93.28 150.59,91.72 150.59,89.57 149.86,88.84 v3(149.61,88.84) 148.75,87.98 R592.2
TP_VSS_NCTF8: length 8.8
  BOTTOM w0.127: v3(178.19,114.95) 177.54,115.6 R483.1
  BOTTOM w0.254: U24.A44 171.52,113.59 173.51,115.59 R484.1 175.33,115.83 175.59,116.09 176.54,116.09 176.84,115.79 R483.1
TP_VSS_NCTF12: length 8.6
  BOTTOM w0.127: v3(176.86,117.75) R479.1
  BOTTOM w0.254: U24.B45 170.99,113.78 173.31,116.1 173.31,117.26 R478.1 173.78,116.99 174.91,116.99 175.11,117.19 175.52,117.19 175.88,117.55 R479.1
TP_VSS_NCTF15: length 11.6
  BOTTOM w0.254: U24.BD1 153.42,95.13 153.25,94.96 153.25,93.96 150.88,91.59 150.88,89.41 149.28,87.81 149.28,86.04 R616.1
TPCLK: length 64
  TOP w0.127: v3(184.73,57.71) 185.01,57.99 185.01,58.1 184.7,58.4 184.28,58.4 184.21,58.33 U13.89
  IN1 w0.133: v3(184.73,57.71) 184.98,57.46 184.98,55.28 183.85,54.15 183.85,48.99 188.17,44.67 188.17,42.43 186.54,40.81 186.54,28.8 186.12,28.37 186.12,22.03 184.99,20.9 184.99,17.73 182.89,15.63 177.99,15.63 174.93,12.58 174.93,11.41 174.88,11.35 174.57,11.35 v3(174.3,11.63)
  BOTTOM w0.127: R712.1 171.83,11.42 172.19,11.42 172.76,11.99 R713.2 173.36,11.4 174.07,11.4 v3(174.3,11.63)
TPCLK_R: length 16.6
  BOTTOM w0.127: CN18.3 160.3,17.71 159.97,17.38 159.97,17.15 160.18,16.95 165.35,16.95 166.38,15.92 166.38,13.86 168.69,11.55 168.99,11.55 169.09,11.65 C554.2 169.75,11.45 170.34,11.45 170.48,11.59 R712.2
TPD_EN: length 2.9
  TOP w0.127: TP70.1 184.8,57.11 184.64,57.27 184.48,57.27 184.21,57.53 U13.87
TPDATA: length 64.8
  TOP w0.127: v3(185.48,57.73) 185.26,57.95 185.26,58.21 184.81,58.66 184.28,58.66 184.21,58.73 U13.90
  IN1 w0.133: v3(185.48,57.73) 185.48,57.71 185.24,57.46 185.24,55.17 184.11,54.04 184.11,49.09 188.43,44.77 188.43,42.33 186.8,40.7 186.8,28.69 186.38,28.27 186.38,21.92 185.25,20.79 185.25,17.63 183,15.37 178.1,15.37 175.19,12.47 175.19,11.3 174.98,11.09 174.5,11.09 v3(174.3,10.89)
  BOTTOM w0.127: v3(174.3,10.89) 174.05,11.14 173.32,11.14 R716.2 172.19,11.16 171.83,11.16 R715.1
TPDATA_R: length 17.4
  BOTTOM w0.127: R715.2 170.48,11.03 170.31,11.19 169.81,11.19 C560.2 169.09,11.2 168.99,11.3 168.58,11.3 166.13,13.75 166.13,15.82 165.25,16.7 160.07,16.7 159.72,17.05 159.72,17.31 159.3,17.73 CN18.4
TS_EN: length 224.8
  TOP w0.127: R1.1 109.22,187.04 107.74,187.04 105.61,184.91 v3(105.61,184.5) ; v3(148.22,45.06) 148.98,45.82 165.43,45.82 165.64,45.61 166.3,45.61 166.63,45.94 166.63,47.31 167.25,47.93 168.66,47.93 168.79,48.06 169.89,48.06 170.03,47.92 U13.35
  IN1 w0.133: v3(146.26,56.71) 147.54,56.71 149.33,58.5 149.33,59.13 152.53,62.33 152.53,67.99 151.41,69.11 151.41,69.94 151.81,70.33 152.06,70.33 153.69,71.97 153.69,73.11 153.04,73.76 153.04,74.6 149.6,78.04 149.6,82.58 150.4,83.37 150.4,84.23 151.81,85.64 151.81,86.54 150.32,88.04 150.32,88.8 150.79,89.28 152.66,89.28 154.59,91.21 154.59,92.71 154.03,93.26 152.43,93.26 152.16,92.99 151.09,92.99 150.6,93.47 150.6,93.96 149.96,94.6 147.8,94.6 146.59,93.39 143.47,93.39 140.33,96.52 140.33,100.11 137.2,103.24 137.2,109.28 139.82,111.9 139.82,120.59 129.81,130.6 116.11,130.6 104.08,142.62 104.08,160.29 106.33,162.54 106.33,165.49 104.91,166.91 104.91,174.8 101.78,177.92 101.78,180.75 105.53,184.5 v3(105.61,184.5)
  BOTTOM w0.127: v3(148.22,45.06) 148.1,45.19 147.96,45.33 147.96,52.68 147.13,53.5 147.13,55.84 v3(146.26,56.71)
USB3_RXN0: length 220.9
  TOP w0.127: v4(22.18,41.19) 22.42,40.95 22.66,40.95 23.21,41.5 24.97,41.5 25.61,40.86 25.61,39.02 22.84,36.25 22.84,34.56 21.88,33.6 20.58,33.6 20.28,33.3 19.93,33.3 19.84,33.22 R349.1
  IN2 w0.089: v3(156.96,106.22) 157.13,106.22 157.22,106.31 157.22,106.55 157.07,106.7 153.7,106.7 153.42,106.98 153.36,106.98 153.35,107
  IN2 w0.133: 153.35,107 148.06,112.29 145.47,112.29 144.92,112.83 142.54,112.83 135.7,119.68 135.7,120.48 133.37,122.8 116.82,122.8 116.09,122.07 105.31,122.07 104.54,122.83 98.33,122.83 97.32,121.81 96.32,121.81 87.2,112.69 85.27,112.69 71.93,99.35 53.58,99.35 52.26,100.67 48.03,100.67 47.99,100.63 41,100.63 36.96,96.59 36.12,96.59 35.46,95.92 35.46,91.91 33,89.46 33,73.78 26.22,67 26.22,61.97 20.4,56.15 20.4,45.34 20.82,44.92 20.82,41.96 21.88,40.9 22.08,40.9 22.18,40.99 v4(22.18,41.19)
  BOTTOM w0.102: v3(156.96,106.22) 157.04,106.22 157.3,105.96 157.3,105.82 157.21,105.73
USB3_RXN0_R: length 10.2
  TOP w0.127: CN12.5 12.22,32.89 12.35,33.01 12.78,33.01 13.35,33.59 14.84,33.59 v3(15,33.42) 15.2,33.62 15.37,33.62 v3(15.9,33.09) 16.44,33.62 17.59,33.62 17.92,33.3 18.6,33.3 R349.2
  BOTTOM w0.127: RV6.1 16.22,33.67 15.26,33.67 v3(15,33.42)
USB3_RXP0: length 220.9
  TOP w0.127: R347.1 19.84,34.23 19.93,34.15 20.27,34.15 20.58,33.84 21.78,33.84 22.6,34.66 22.6,36.35 25.37,39.12 25.37,40.76 24.87,41.26 23.31,41.26 22.76,40.71 22.46,40.71 v3(22.19,40.44)
  IN2 w0.089: v3(157.61,106.22) 157.4,106.43 157.4,106.62 157.15,106.88 153.77,106.88 153.54,107.11 153.54,107.16 153.5,107.21
  IN2 w0.133: v3(22.19,40.44) 21.99,40.64 21.78,40.64 20.57,41.86 20.57,44.81 20.15,45.23 20.15,56.25 25.96,62.07 25.96,67.1 32.75,73.89 32.75,89.56 35.2,92.02 35.2,96.03 36.02,96.84 36.86,96.84 40.9,100.88 47.89,100.88 47.92,100.92 52.37,100.92 53.68,99.61 71.83,99.61 85.17,112.95 87.09,112.95 96.21,122.07 97.21,122.07 98.23,123.08 104.65,123.08 105.41,122.32 115.98,122.32 116.72,123.06 133.48,123.06 135.95,120.58 135.95,119.78 142.64,113.09 145.03,113.09 145.57,112.54 148.16,112.54 153.5,107.21
  BOTTOM w0.102: 157.81,105.73 157.61,105.93 v3(157.61,106.22)
USB3_RXP0_R: length 10.2
  TOP w0.127: CN12.6 12.22,33.37 12.33,33.25 12.68,33.25 13.25,33.83 14.71,33.83 v3(14.96,34.08) 15.18,33.86 15.41,33.86 v3(15.9,34.36) 16.4,33.86 17.57,33.86 17.85,34.15 18.6,34.15 R347.2
  BOTTOM w0.127: v3(14.96,34.08) 15.09,33.95 16.22,33.95 RV5.1
USB3_TXN0: length 208.7
  TOP w0.127: C300.1 23.58,38.48 23.66,38.48 23.91,38.73 23.91,39.74 24.16,40 24.39,40 v3(24.62,39.77)
  IN2 w0.133: v3(143.58,112.08) 143.39,111.9 138.57,111.9 134.6,115.87 134.6,120.66 133.12,122.14 117.09,122.14 116.36,121.4 105.06,121.4 104.47,121.99 99.19,121.99 98.07,120.87 98.07,120.34 97.15,119.41 94.82,119.41 87.44,112.03 85.53,112.03 72.2,98.71 53.31,98.71 52,100.02 48.83,100.02 47.31,98.51 39.8,98.51 36.1,94.81 36.1,91.65 33.64,89.19 33.64,73.52 26.86,66.73 26.86,61.7 21.06,55.9 21.06,46.55 21.62,45.99 21.62,43.52 23.22,41.92 23.22,40.45 23.7,39.97 24.42,39.97 v3(24.62,39.77)
  BOTTOM w0.089: U24.BE24 152.77,104.74 152.54,104.74 152.46,104.82 152.46,104.98 152.49,105.01 152.49,105.03
  BOTTOM w0.127: v3(143.58,112.08) 143.84,111.82 145.58,111.82 146.64,110.76 146.64,107.56 147.65,106.55 151.25,106.55 152.49,105.3 152.49,105.03
