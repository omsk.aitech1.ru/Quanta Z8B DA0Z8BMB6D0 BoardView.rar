# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3V_RTC_0: length 165.6
  TOP w0.508: BT1.1 64.9,36.11 67.75,38.96 v3(68.43,38.96) ; v3(141.85,38.38) 142.19,38.73 142.19,47.56 142.27,47.64 142.27,47.64 v2(146.38,51.76) 147.7,53.07 147.7,72.32 151.56,76.18 160.8,76.18 162.6,77.97 169.09,77.97 171.16,80.04 173.22,80.04 173.38,79.88 Q30.1 174.83,79.32 175.17,79.32 v3(175.22,79.27)
  IN2 w0.508: v3(141.85,38.38) 138.43,34.97 134.48,34.97 133.84,35.6 123.26,35.6 117.63,29.96 78.63,29.96 73.04,35.55 71.84,35.55 v3(68.43,38.96)
  BOTTOM w0.508: v3(175.22,79.27) 175.28,79.27 177.79,81.78 177.79,83.05 R589.1
+3V_RTC_1: length 2.6
  BOTTOM w0.508: D22.1 181.75,88.41 181.56,88.22 R589.2 182.16,87.61 TP181.1
+3V_RTC_2: length 2.2
  BOTTOM w0.508: D22.2 184.33,90.34 R562.1
+3V_S5: length 664.9
  TOP w0.254: RP1.10 166.35,84.87 166.19,84.7 v3(166.19,83.95) ; U12.5 75.86,71.26 75.69,71.09 R265.1 ; C216.2 183.49,80.56 184.05,81.12 U8.5
  TOP w0.305: RP1.5 168.78,87.66 169.15,88.04 v3(169.15,88.27) ; 169.14,91.92 169.14,93.55 R172.1
  TOP w0.381: R223.2 159.48,87.72 v3(158.91,88.29) 158.88,88.29 R220.1 ; v3(163.74,91.23) 163.67,91.3 R184.2 ; R169.2 180.9,95.75 179,95.75 178.65,95.4 178.65,94.21 178.26,93.82 R180.1 178.2,92.83 177.05,92.83 v3(176.9,92.68) ; v3(165.22,91.18) 165.26,91.23 R185.2 ; 85.81,45.18 85.81,49.19 85.12,49.88 85.12,59.25 80.19,64.18 80.19,64.18 79.82,64.55 R288.2 ; R522.1 162.51,91.94 v3(161.95,92.5) ; v3(77.27,72.59) 76.1,72.59 75.25,71.74 R265.1 ; R331.2 v3(174.48,68.79) ; v3(171.82,93.12) 172.13,93.43 R174.2 ; R214.1 166.66,90.25 166.25,90.66 v3(166.25,91.16) 166.25,91.82 R186.1 ; R250.1 183.92,78.53 183.32,79.14 ; v3(189.78,89.12) 189.78,87.31 189.17,86.69 D3.2 ; v3(161.7,88.8) 161.38,88.47 R219.1 ; R330.2 v3(173.34,68.78)
  TOP w0.508: C221.2 80.64,74.47 79.64,75.47 77.7,75.47 v3(77.19,74.97) 74.27,74.97 70.29,70.98 70.29,55.52 65.87,51.1 65.87,42.49 71.61,36.75 71.61,27.7 v3(73.03,26.28) 73.92,26.28 75.95,28.3 75.95,31.57 84.13,39.74 84.13,41.83 85.19,42.89 85.19,44.56 85.81,45.18 ; v3(31.02,105.25) 31.27,105.25 Q18.2 32.94,103.58 R133.1 ; 183.21,109.26 183.21,104.03 R127.1 183.29,103.7 182.65,103.06 v3(182.62,103.06) ; v3(179.88,98.47) 179.88,98.49 179.55,98.83 R149.1 ; v3(175.15,118.5) 176.36,117.29 180.37,117.29 180.93,116.73 182.38,116.73 183.57,115.54 Q14.3 183.47,114.72 v3(183.47,113.76) ; 176.42,90.5 176.42,91.98 176.9,92.46 v3(176.9,92.68) ; 176.42,90.5 176.8,90.5 177.28,90.02 R196.1 ; 176.42,90.5 174.44,88.53 v3(174.44,88.46) 174.44,88.32 173.85,87.72 R224.1 ; v3(52.1,97.61) 44.09,97.61 40.75,94.26 v3(40.75,93.92) 40.92,93.74 PR136.1 ; Q17.2 25.21,109.23 C127.2 25.96,108.07 23.7,105.81 23.7,104.44 v3(23.93,104.21) 23.42,103.7 R125.2 ; v3(166.09,74.49) 175.93,74.49 177.34,75.91 177.34,78.12 178.36,79.14 183.32,79.14 183.49,79.31 C216.2
  TOP w0.762: v3(150.13,71.41) 149.86,71.14 149.86,66.95 150.24,66.57 150.24,64.53 150.13,64.42 150.13,57.4 ; 149.91,57.18 149.88,57.15
  IN1 w0.508: v3(189.78,89.12) 191.54,90.88 191.54,95.12 191.16,95.5 v3(191.16,102.23) ; v3(182.62,103.06) 182.61,103.05 182.61,100.48 180.6,98.47 v3(179.88,98.47) ; v3(145.67,32.56) 145.67,31.02 149.08,27.61 156.79,27.61 163.01,21.39 173.22,21.39 175.59,19.02 175.59,17.77 174.55,16.73 v3(173.31,16.73)
  IN1 w0.762: v3(40.75,93.92) 40.64,94.02 38.92,94.02 37.85,92.96 37.85,87.75 39.22,86.38 39.22,80.92 38.27,79.97 38.27,71.58 37.44,70.76 37.44,63.01 35.94,61.5 35.94,58.19 36.79,57.33 37.15,57.33 37.7,56.79 37.7,55.06 37.34,54.7 37.34,49.17 35.31,47.14 v3(35.31,43.1) 35.31,42.64 v3(35.64,42.31)
  IN2 w0.508: v3(175.15,118.5) 175.14,118.5 175.14,121 174.74,121.4 174.74,130.99 176.45,132.7 178.96,132.7 182.12,135.86 188.85,135.86 190.07,134.64 v3(193.02,134.64)
  IN2 w0.762: 150.6,55.42 150.6,45.74 144.68,39.82 144.68,37.76 145.67,36.77 v3(145.67,32.56) 144.36,32.56 138.08,26.28 113.77,26.28 112.66,27.39 78.53,27.39 77.42,26.28 v3(73.03,26.28) 70.23,26.28 67.23,23.28 51.84,23.28 45.31,29.81 45.31,30.07 40.03,35.34 40.03,37.02 35.64,41.42 v3(35.64,42.31)
  BOTTOM w0.254: R575.1 v3(163.99,88.8) 163.98,88.8 R590.1 ; v3(167.37,88.83) 167.37,89.38 R578.1 ; R585.2 169.15,88.89 v3(169.15,88.27) ; v3(174.44,88.46) 174.4,88.5 R584.2 ; R576.1 v3(165.13,88.8) ; R573.1 v3(161.7,88.8) ; R580.2 v3(172.12,88.42)
  BOTTOM w0.381: v3(166.09,74.49) 166.09,74.09 165.87,73.87 165.87,66.74 166.34,66.26 171.38,66.26 173.34,68.22 v3(173.34,68.78) 174.47,68.78 v3(174.48,68.79) ; R636.2 166.19,82.97 v3(166.19,83.95) 166.19,84.72 R614.1 ; v3(164.61,79.67) 165.14,79.67 R642.1 ; R633.1 v3(160.56,81.58)
  BOTTOM w0.508: PR173.1 192.06,134.67 C387.2 v3(193.02,134.64) ; Q47.1 182.43,112.79 181.74,112.11 R489.2 182.49,111.52 v3(183.56,110.45) 184.23,111.12 185.58,111.12 186.6,110.1 187.76,110.1 188.52,110.86 188.52,112.08 189.54,113.1 191.27,113.1 ; Q47.1 182.48,113.76 v3(183.47,113.76) ; Q47.1 181.41,114.72 181.41,115.39 181.19,115.61 179.56,115.61 179.05,115.11 179.05,114.6 178.17,113.71 R488.1 ; R481.1 190.02,115.89 191.27,114.65 191.27,113.1 ; R652.2 150.73,73.38 150.13,72.79 v3(150.13,71.41) ; v3(52.1,97.61) 52.1,96.31 PR88.2 ; 191.27,113.1 191.62,112.74 191.62,107.61 190.96,106.95 190.96,102.43 v3(191.16,102.23) ; R493.2 181.17,109.58 v3(182.17,109.58) ; v3(23.93,104.21) 23.93,105.82 24.79,106.68 25.95,106.68 26.65,105.99 29.9,105.99 30.63,105.25 v3(31.02,105.25) 31.68,105.25 32.9,104.03 32.9,102.23 34.85,100.27 R537.1 34.41,99.75 34.41,96.45 36.94,93.92 v3(40.75,93.92) ; L29.2 169.2,15.33 172.67,15.33 173.31,15.97 v3(173.31,16.73) 173.82,16.73 174.19,16.35 v2(174.19,15.79) 174.19,14.02 174.91,13.3 175.8,13.3 177.14,11.96 177.14,9.7 174.75,7.31 173.69,7.31 PR62.1 173.23,7.82 173.54,8.13 R720.2 174.57,9.39 R717.1 ; v3(77.19,74.97) 77.24,74.92 77.24,72.62 v3(77.27,72.59)
  vias: v3(150.12,56.43) v3(150.14,55.77) v3(160.45,80.92) v3(165.13,81.82) v3(165.23,74.39) v3(168.56,91.19)
+3V_SUS: length 150.4
  TOP w0.381: R259.1 v3(188.9,73.5)
  IN1 w0.381: v3(188.9,73.5) 188.9,68.73 190.01,67.62 190.01,63.63 192.43,61.21 192.43,53.1 190.63,51.3 190.63,18.26 186.11,13.74 185.5,13.74 184.32,12.55 180.17,12.55 175.73,8.11 v3(174.46,8.11) 174.46,8.12 173.44,8.12 171.29,10.26 171.29,12.32 170.08,13.53 168.96,13.53 165.86,16.63 158.92,16.63 153.36,22.19 151.41,22.19 150.97,21.75 148.97,21.75 147.46,20.24 137.6,20.24 133.61,16.25 v3(132.92,16.25)
  BOTTOM w0.381: PR217.1 136.58,10.7 135.08,12.2 v2(135.08,13.28) 135.08,14.09 v3(132.92,16.25) ; v3(174.46,8.11) 174.75,8.11 176.48,9.85 176.48,11.47 175.87,12.08 R714.1 175.8,12.48 175.57,12.72 174.68,12.72 174.2,13.2 171.58,13.2 PQ42.1 169.15,14.32 L30.1
+3V_TPM_VDD: length 27.6
  TOP w0.381: U11.10 180.79,74.97 179.88,75.88 C220.1 ; U11.19 v3(180.79,69.2)
  TOP w0.508: v3(181.15,78.37) 181.15,78.37 181.72,78.37 182.04,78.05 R238.2 ; R262.1 188.9,70.33 R270.2 188.89,70.01 188.53,69.65 186.15,69.65 185.25,70.55 v3(184.79,70.55) ; v3(180.53,76.01) 179.94,76.01 C220.1
  IN1 w0.508: v3(181.15,78.37) 180.91,78.37 180.53,77.99 v3(180.53,76.01)
  BOTTOM w0.508: v3(184.79,70.55) v3(184.79,69.18) 185.07,68.9 C507.1 C506.2 183.78,68.42 R656.2 181.23,68.42 180.79,68.86 v3(180.79,69.2) 180.79,72.28 181.84,73.33 181.84,75.2
  vias: v2(181.61,76.27)
+3VPCU: length 790.8
  TOP w0.127: PR52.1 38.35,57.52 39.6,57.52 v3(39.86,57.78)
  TOP w0.254: RP2.10 178.84,18.33 v3(179,18.18) ; PR26.2 158.17,180.41 158.14,180.38 v3(158.14,180.37) ; v3(178.97,24.05) 178.21,23.29 RP2.2
  TOP w0.381: v3(167.02,69.04) 166.89,68.91 166.89,68.35 R276.2 ; v3(182.35,189.38) 182.09,189.63 PR35.2 ; v3(21.77,31.37) 21.77,31.51 25.02,34.77 v3(25.02,35.93) ; v3(192.63,97.43) 190.98,99.07 190.98,100.78 190.58,101.18 C746.2 190.58,108.12 v3(189.77,108.93) ; v3(172.92,70.18) 173.91,70.18 175.4,68.69 175.55,68.69 176.44,67.8 176.44,66.99 v3(176.57,66.86) R340.2 ; v3(109.61,160.34) 109.73,160.47 R30.2 ; R332.2 v3(177.97,66.84) ; PR47.1 39.68,55.75 38.89,54.96 36.25,54.96 35.95,55.26 35.95,57.85 35.72,58.08 28.38,58.08 26.98,56.69 v3(26.52,56.69) ; v3(197.99,95.47) 197.66,95.14 197.26,95.14 196.9,94.79 196.9,92.62 R182.1 ; v3(108.39,155.11) 110.31,155.11 110.57,154.86 110.57,154.84 R38.1
  TOP w0.508: v3(197.08,125.47) 197.08,125.14 191.75,119.8 191.75,118.74 188.93,115.92 185.63,115.92 v3(185.63,115.92) ; C745.2 134.79,30.9 v3(135.05,30.65) ; LED2.1 69.95,8.18 69.22,8.91 v1(69.22,10.28) 69.22,10.52 71.84,13.14 v3(72.85,13.14) ; R217.2 187.81,88.82 R216.1 188.35,89.86 v3(188.53,90.04) ; PU2.5 192.17,190.67 192.49,190.36 v3(192.49,190.11) 192.49,189.27 192.57,189.19 PR25.2 192.57,187.26 PR12.2 PR15.2
  TOP w0.762: v3(90.3,32.02) 89.77,32.02 85.12,27.37 81.92,27.37 65.93,11.38 v1(61.51,11.38)
  IN1 w0.133: v3(58.6,58.84) 60.82,61.06 60.82,66.85 61.42,67.46 61.42,74.8 60.68,75.53 41.2,75.53 39.93,74.26 39.93,69.28 39.27,68.62 39.27,62.12 38.74,61.59 38.74,58.41 39.37,57.78 v3(39.86,57.78)
  IN1 w0.381: v3(158.14,180.37) 158.15,180.35 159.05,180.35 159.2,180.21 167.14,180.21 168.05,179.3 179.24,179.3 v3(179.97,180.02) ; v3(160.68,144.42) 158.66,144.42 158.12,143.87 158.12,142.96 152.85,137.69 139.54,137.69 138.57,136.72 131.2,136.72 128.68,134.21 116.34,134.21 108.08,142.46 108.08,154.81 v3(108.39,155.11) 108.41,155.11 108.51,155.21 108.51,159.17 109.61,160.27 v3(109.61,160.34)
  IN1 w0.508: v1(61.51,11.38) 68.11,11.38 v1(69.22,10.28) ; v3(192.49,190.11) 191.24,191.36 183.89,191.36 182.35,189.82 v3(182.35,189.38) ; v3(72.85,13.14) 75.31,13.14 83.09,20.93 120.36,20.93 122.53,23.1 141.72,23.1 143.75,25.13 146.73,25.13 148.56,26.96 156.44,26.96 158.56,24.84 158.56,21.67 159.78,20.46 167.09,20.46 169.04,18.5 169.04,17.6 170.11,16.53 v3(172.56,16.53) 173.07,16.02 177.08,16.02 177.58,16.53 178.36,16.53 179,17.16 v3(179,18.18)
  IN1 w0.762: 33.08,102.08 31.21,102.08 30.28,101.15 30.28,97.58 29.08,96.38 29.08,93.5 33.06,89.52 33.06,85.77 33.54,85.29 33.54,73.54 32.71,72.72 32.71,67.68 31.02,65.98 28,65.98 26.52,64.51 v3(26.52,56.69) 26.52,46.91 27.26,46.17 27.26,45.23 26.61,44.58 26.61,37.52 v3(25.02,35.93) 25.02,35.22 25.62,34.63 27.43,34.63 27.81,34.25 28.75,34.25 29.6,33.4 29.6,32.68 30.15,32.12 31.5,32.12 34.38,29.24 34.38,28.83 34.84,28.38 38.62,28.38 40.57,26.43 40.57,23.01 42.07,21.51 42.07,19.78 49.57,12.27 60.62,12.27 v1(61.51,11.38)
  IN1 w1.016: 189.34,110.38 189.06,110.38 187.51,111.93 187.06,111.93 187,111.98 186.97,111.98 186.37,112.58 186.37,115.18 v3(185.63,115.92) 184.61,116.94 184.61,118.57 183.08,120.1 183.05,120.1 182.38,120.77 178.37,120.77 176.6,122.55 176.6,125.74 175.02,127.32 175.02,132.22 177.8,135 177.8,137.38 176.59,138.59 171.49,138.59 169.23,140.85 169.23,142.5 ; 161.47,49.95 161.47,52.49 162.5,53.52 162.5,55.83 165.38,58.72 165.38,62.68 164.57,63.49 164.57,64.41 165.48,65.31 165.48,67.67 166.27,68.47 ; 187.38,89.7 185.57,87.89 184.34,87.89 176.15,79.71 176.15,76.32 173.15,73.31 173.15,71.36
  IN2 w0.381: v3(177.97,66.84) 176.59,66.84 v3(176.57,66.86)
  IN2 w0.508: v3(197.08,125.47) 197.72,126.1 197.72,137.15 v3(197.41,137.46) 197.18,137.69 197.18,167.94 196.22,168.9 196.22,172.54 197.43,173.75 197.43,174.55 194.49,177.49 194.49,178.89 192.31,181.07 192.31,189.93 v3(192.49,190.11)
  BOTTOM w0.254: v3(158.14,180.37) 158.13,180.37 157.77,180.72 150.98,180.72 150.67,181.03 PR28.2 150.67,182.36 PC13.1 150.61,183.58 PR14.2
  BOTTOM w0.381: R695.2 21.77,31.37 v3(21.77,31.37) ; v3(179.97,180.02) 181.16,180.02 183.29,182.15 183.29,188.44 v3(182.35,189.38) ; v3(192.63,97.43) 196.04,97.43 v3(197.99,95.47)
  BOTTOM w0.508: PQ42.3 172.38,16.35 v3(172.56,16.53) ; v3(185.5,89.93) 185.81,90.24 R562.2 ; C420.2 186.24,116.53 v3(185.63,115.92) 185,116.55 R480.1 ; v3(178.97,24.05) 179.71,23.31 179.71,19.47 179,18.76 v3(179,18.18) ; v3(197.41,137.46) 196.93,136.98 PR189.1 ; v1(61.51,11.38) 62.2,11.38 63.91,9.67 63.91,9.24 ; 63.91,9.24 R721.2 ; 63.91,9.24 64.14,9.24 64.88,9.98 R718.2
  BOTTOM w1.016: 190,107.84 190,91.53 189.79,91.33
  vias: v1(160.13,142.61) v1(160.3,141.8) v1(160.3,140.99) v2(61.85,53.59) v3(33.99,102.2) v3(34.42,102.71) v3(61.42,10.58) v3(61.83,47.64) v3(61.8,46.93) v3(62.49,47.62) v3(62.49,46.93) v3(63.17,46.98) v3(63.2,46.32) v3(63.2,45.66) v3(91.01,32.05) v3(152.73,78.44) v3(152.72,77.78) v3(152.89,49.98) v3(153.42,50.51) v3(159.69,49.65) v3(160.23,50.03) v3(167.57,68.45) v3(168.61,143.86) v3(168.61,143.2) v3(172.04,69.93) v3(188.93,90.6) v3(189.36,109.44)
+3VPCU_EC: length 61.7
  TOP w0.203: U13.50 176.03,48.06 176.28,48.31 v3(176.67,48.31) ; 166.08,51.13 U13.26 ; 171.83,63.98 172.03,63.78 U13.121 ; U13.114 174.83,63.84
  TOP w0.508: v3(166.78,65.13) 166.87,65.22 L9.2 ; v3(175.82,65.37) 175.81,65.36 C229.1 174.83,65.01 174.83,63.84
  IN1 w0.762: 164.88,51.79 167,53.91 167,58.23 167.53,58.76 167.53,63.21 166.78,63.95 v3(166.78,65.13) ; v3(164.28,47.25) 164.68,47.25 164.68,47.25 165.32,47.25 166.85,48.79 170.18,48.79 171.53,47.44 175.8,47.44 v3(176.67,48.31)
  BOTTOM w0.762: 177.62,47.77 179.59,47.77 181.84,50.02 181.84,51.45 181.24,52.05 181.24,52.85 181.77,53.38 184.07,53.38 186.82,56.12 ; v3(166.78,65.13) 166.96,65.31 171.46,65.31 v3(171.64,65.13) 171.66,65.14 173.14,65.14 173.37,65.37 v3(175.82,65.37)
  vias: v2(165.28,50.39) v3(164.32,50.06) v3(164.36,50.71) v3(186.94,57.61) v3(186.94,56.96)
+3VPCU_ECPLL: length 4.3
  TOP w0.203: U13.127 169.63,63.6 169.24,63.99 168.8,64.43
  TOP w0.508: 168.8,64.43 168.18,65.05 L9.1 C227.1
+5V: length 182.8
  TOP w0.178: C313.1 35,32.28 34.14,31.42 34.14,30.95 33.62,30.43 U15.46
  TOP w0.203: C318.1 36.55,28.72 36.26,28.42 35.47,28.42 35.47,28.43 U15.41
  TOP w0.508: C318.1 36.55,29.2 36.7,29.35 36.7,30.67 36.7,30.67 ; v3(171.1,124.05) 171.03,124.12 169.94,124.12 169.28,124.12 169.28,124.12 168.75,124.12 168.38,124.12 167.72,124.78 166.96,124.78 166.07,123.89 151.74,123.89 150.02,122.17 Q13.2 ; D7.2 24.46,53.53 v3(23.96,53.03) ; v3(30.94,63.8) 29.36,62.21 PR147.1 ; Q15.2 180.7,110.22 v3(181.81,110.22) ; 36.7,30.67 36.7,30.68 36.7,31.22 35.87,32.06 C313.1 ; 36.7,30.67 v3(36.7,30.5) ; C753.2 v3(134.16,28.11)
  TOP w1.524: 31.35,47.07 32.05,47.77 37.66,47.77 40.68,50.79 42.39,50.79 45.39,53.79 47.49,53.79 51.61,57.9 52.48,57.9
  IN1 w0.508: v3(20.65,62.55) 23.96,59.25 v3(23.96,53.03) ; v3(181.81,110.22) 181.03,111 181.03,112.57 178.54,115.05 178.54,115.38 177.5,116.43 v3(177.19,116.43) 176.97,116.43 176.41,115.87 174.6,115.87 173.21,117.26 173.21,120.06 172.79,120.48 172.79,121.97 171.46,123.31 171.46,123.69 v3(171.1,124.05) ; 19.23,106.16 23.63,106.16 24.57,105.23 25.48,105.23 26.12,105.86 26.12,107.03 27.11,108.02 60.35,108.02 v3(62.82,105.56)
  IN1 w0.762: 31.98,34.82 34.7,32.1 35.89,32.1 36.7,31.29 36.7,30.68 v3(36.7,30.5)
  BOTTOM w0.305: C429.2 15.26,108.03 15.03,108.26 U22.5 ; U25.5 15.96,104.3 16.39,104.73 C437.2
  BOTTOM w0.508: U26.2 62.41,102.51 62.84,102.94 62.84,104.44 C434.2 63.35,105.56 v3(62.82,105.56) ; C748.2 185.83,117.98 v3(185.73,117.87) C738.2 183.14,117.87 182.78,117.52 179.54,117.52 178.96,116.93 178.96,116 178.74,115.79 R483.2 178.32,116.04 177.93,116.43 v3(177.19,116.43) ; v3(156.49,59.76) 156.39,59.66 C516.2 154.69,60.67 154.41,60.67 Q52.1 153.84,61.88 154.22,62.26 155.53,62.26 155.78,62.51 155.78,64.08 155.24,64.62 R664.1 ; C429.2 16.28,108.4 v3(17.05,109.16) ; v3(16.18,105.38) 16.26,105.38 16.66,104.97 C437.2
  vias: v2(55.98,57.78) v3(17.81,109.16) v3(19.97,64.64) v3(19.97,63.9) v3(19.99,63.24) v3(19.99,62.53) v3(20.65,64.61) v3(20.65,63.95) v3(20.68,63.24) v3(29.11,48.2) v3(29.51,47.62) v3(30.1,47.36) v3(31.04,65.12) v3(30.99,64.46) v3(41.65,23.72) v3(42.3,23.71) v3(53.5,60.09) v3(53.47,59.38) v3(53.57,58.72) v3(53.93,58.16) v3(54.18,60.09) v3(54.16,59.4) v3(54.26,58.74) v3(54.61,58.16) v3(54.84,60.04) v3(54.82,59.38) v3(54.97,58.74) v3(187.53,39.79) v3(187.53,39.06) v3(187.53,38.4) v3(187.53,37.71) v3(192.74,104.27) v3(192.77,105.67) v3(192.78,104.96) v3(192.79,103.58) v3(193.43,105.65) v3(193.44,104.96) v3(193.43,104.27) v3(193.45,103.61)
+5V_HDD:
  vias: v2(192.76,34.23) v3(192.74,42.21) v3(192.74,41.52) v3(192.74,40.86) v3(192.74,40.2)
+5V_KB:
  vias: v2(151.06,65.86)
+5V_KB_R:
  vias: v2(152.3,68.01)
+5V_ODD:
  vias: v2(194.82,104.06) v3(197.6,104.59) v3(197.6,103.93) v3(197.61,103.27) v3(198.15,102.69)
+5V_S5: length 403.7
  TOP w0.508: v3(38.94,87.83) 39.44,88.33 39.44,93.85 44.61,99.02 v3(44.61,99.28) ; v3(148.34,58.44) 148.34,72.06 151.82,75.54 161.07,75.54 162.8,77.27 R242.1 167.38,76.82 167.63,76.56 174.23,76.56 174.76,77.1 R241.1
  TOP w0.635: v1(179.99,143.58) 178.34,143.58 174.39,139.63 168.7,139.63 168.25,139.18 167.77,139.18 165.84,137.25 v3(165.83,135.12)
  IN1 w0.508: v3(44.61,99.28) 44.86,99.03 56.11,99.03 60.3,94.83 60.3,93.36 v3(59.97,93.03) 59,92.06 59,86.06 v3(57.87,84.93) ; v3(174.14,118.66) 174.13,118.67 174.13,120.51 173.71,120.92 173.71,124.55 171.66,126.6 171.66,127.88 170.14,129.39 168.9,129.39 167.48,130.81 166.22,132.07 166.2,132.07 165.83,132.44 v3(165.83,135.12)
  IN1 w0.635: v1(127.08,188.51) 128.69,190.12 132.76,190.12 133.58,190.94 138.93,190.94 140.04,189.83 140.04,187.04 141.99,185.09 143.56,185.09 145.04,183.61 145.66,183.61 147.66,181.61 147.66,181.37 149.02,180.01 149.84,180.01 150.29,180.46 155.37,180.46 156.56,179.26 156.56,178.16 157.75,176.97 157.75,175.59 159,174.34 165.33,174.34 167.26,172.4 167.26,167.84 167.62,167.48 167.62,162.78 167.14,162.3 167.14,159.81 163.55,156.23 163.55,154.12 166.6,151.07 166.6,150.26 165.84,149.5 165.84,144.65 165.12,143.93 165.12,143.93 164.7,143.51 164.7,143.51 164.68,143.49 164.68,142.15 165.66,141.17 165.66,135.35 165.83,135.18 v3(165.83,135.12)
  BOTTOM w0.191: PU12.2 59.05,93.45
  BOTTOM w0.203: 59.05,93.45 59.68,93.45 59.91,93.68 PC155.1
  BOTTOM w0.508: PR94.2 44.61,99.08 v3(44.61,99.28) ; PR158.2 180.24,143.83 v1(179.99,143.58) ; v1(47.43,64.25) 45.01,64.25 44.51,64.76 44.51,65.78 39.55,70.73 39.55,81.12 40.92,82.49 40.92,84.68 38.94,86.66 v3(38.94,87.83) ; v3(59.97,93.03) 60.2,93.26 PC155.1 ; R479.2 174.99,117.75 174.14,118.6 v3(174.14,118.66)
  BOTTOM w0.762: v3(165.83,135.12) 165.76,135.05 165.76,129.25 165.29,128.77 160.07,128.77 159.64,128.34 159.64,126.39 158.9,125.65 148.24,125.65 147.96,125.37 147.53,125.37 147.1,124.93 147.1,122.22 146,121.12 146,119.78 144.42,118.2 144.42,116.13 138.73,110.44 138.73,109.8 135.87,106.94 135.87,70.9 v3(148.34,58.44) 149.1,57.67 149.1,55.21 150.31,54.01 150.31,42.93 147.97,40.59 147.97,29.46 142.91,24.4 v3(142.91,18.02)
  vias: v1(47.48,63.44) v1(47.45,62.6) v1(48.26,64.28) v1(48.26,63.44) v1(48.26,62.6) v1(49.03,64.25) v1(49.03,63.44) v1(49.03,62.6) v2(29.41,43.27) v3(37.6,44.14) v3(37.67,43.48) v3(37.72,42.79) v3(142.12,18.05) v3(179.4,16.58) v3(179.86,17.06) v3(180.39,18.18) v3(180.39,17.52) v3(180.47,16.81) v3(180.96,18.51) v3(180.99,17.86) v3(180.98,17.21)
+5VA: length 25.4
  TOP w0.203: 27.66,25.07 27.92,25.07 28.2,25.34 U15.26
  TOP w0.508: 27.66,25.07 26.68,24.08 C327.1 25.73,23.36 C331.1 25.14,23.11 v3(24.54,22.5)
  BOTTOM w0.508: v3(24.54,22.5) v2(25.66,22.5) 34.37,22.5 35.44,23.57 36.62,23.57 C534.1 R697.1 38.13,23.49 37.85,23.21 C537.2 39.44,22.42 L28.2 39.65,24.21 U31.4
+5VPCU: length 412
  TOP w0.203: PC40.2 45.57,61.56 44.27,60.26 PU3.14
  TOP w0.254: PR50.2 37.37,60.94 37.37,61.79 37.9,62.32 39.48,62.32 v3(39.81,61.99)
  TOP w0.508: 45.5,65.73 45.85,65.37 PC40.2 ; 45.5,65.73 51.87,65.73 52.37,66.23 56.54,66.23 ; 45.5,65.73 45.27,65.96 44.76,65.96 43.59,67.13 PD5.2 ; v3(145.43,126.32) 147.92,128.81 165.42,128.81 165.76,129.15 166.08,129.47 170.41,129.47 170.41,129.47 171.34,129.47 171.35,129.47 174.85,129.47 176.77,131.39 179.68,131.39 180.11,130.96 180.11,125.67 180.57,125.21 180.9,125.21 181.59,124.53 181.59,123.92 182.35,123.16 185.12,123.16 185.5,123.54 185.5,125.14 v3(185.34,125.3) ; LED2.2 70.85,7.54 v3(70.89,7.59) 70.89,10.02 84.89,24.02 136.92,24.02 v3(143.98,31.08)
  TOP w0.762: 52.56,62.12 52.56,60.65 46.96,55.06 44.86,55.06 41.86,52.06 v3(39.65,52.06) ; v3(53.5,34.44) 49.99,34.44 47.03,31.47 47.03,26.2 60.23,13 v3(60.23,10.15) v3(60.23,9.31)
  IN1 w0.254: v1(57.51,67.51) 59.19,67.51 60.96,69.28 60.96,74.49 60.33,75.13 41.61,75.13 40.44,73.96 40.44,69.16 39.81,68.52 v3(39.81,61.99)
  IN1 w0.762: v3(53.5,34.44) 48.54,34.44 46.99,35.98 44.64,35.98 43.7,36.92 43.7,37.74 42.07,39.37 42.07,40.38 39.77,42.68 39.77,50.83 v3(39.3,51.3) 39.3,51.71 v3(39.65,52.06)
  IN2 w0.508: v3(70.89,7.59) 68.07,7.59 66.44,9.22 v3(65.88,9.22) 65.87,9.21 63.2,9.21 v3(63.1,9.31)
  BOTTOM w0.254: PC52.2 186.59,125.98 187.28,126.66 188.5,126.66 189.14,126.02 PU4.7
  BOTTOM w0.508: PC52.2 186.57,125.3 v3(185.34,125.3) ; R719.2 68.5,9.98 v3(70.89,7.59) ; v3(143.98,31.08) 144.78,31.88 144.78,40.28 147,42.5 147,52.28 145.39,53.89 145.39,57.58 133.63,69.34 133.63,108.66 136.57,111.6 136.83,111.6 142.07,116.83 142.07,120.27 144.94,123.14 144.94,125.83 v3(145.43,126.32) ; R722.2 v3(65.88,9.22)
  vias: v1(56.72,68.7) v1(57.48,74.16) v1(57.94,68.8) v1(58.6,68.37) v1(58.93,74.16) v1(59.49,69.28) v1(59.84,70.86) v1(59.89,72.64) v2(56.9,64.84) v3(53.6,35.25)
+15V: length 417.3
  TOP w0.381: R159.2 193.26,96.69 192.71,96.69 v3(192.66,96.74) ; PR205.1 154.35,137.35 v3(149.48,132.48) ; v3(130.48,132.2) 129.98,131.69 PR199.1 ; v3(132.52,13.14) 137.53,18.15 v2(139.42,18.15) v3(141.46,18.15) ; v3(188.04,117.82) 187.96,117.82 186.41,119.38 183.69,119.38 182.51,120.57 178.59,120.57 178.11,121.05 176.13,121.05 175.34,121.84 175.34,126.21 175.34,127.32 173.77,128.9 171.4,128.9 171.39,128.9 170.36,128.9 170.35,128.9 166.32,128.9 165.66,128.24 148.47,128.24 v3(148.16,127.93)
  TOP w0.508: PR60.1 36.5,71.32 36.5,70.35 v3(32.34,66.19) ; PR149.1 31.53,50.1 31.75,49.87 31.75,49.5 v3(31.78,49.47) ; v3(120.84,12.26) 121.15,12.57 129.49,12.57 131.94,12.57 v3(132.52,13.14)
  IN1 w0.381: v3(130.48,132.2) 132.03,130.65 145.45,130.65 v3(148.16,127.93) ; v3(188.04,117.82) 188.04,117.39 189.07,116.36 189.07,115.3 189.07,114.47 192.09,111.44 192.09,107.16 191.24,106.3 191.24,103.45 191.84,102.84 191.84,97.39 192.49,96.74 v3(192.66,96.74)
  IN1 w0.508: v3(130.59,17.05) 129.1,18.53 82,18.53 75.69,12.22 71.76,12.22 69.46,14.52 50.56,14.52 44.28,20.81 44.28,22.9 44.73,23.35 44.73,27.11 44.02,27.83 44.02,28.38 37.67,34.73 37.67,35.3 31.68,41.29 31.68,49.37 v3(31.78,49.47) 31.78,49.75 30.46,51.07 30.46,54.27 31.14,54.96 31.14,63.01 32.34,64.2 v3(32.34,66.19)
  IN2 w0.508: v3(132.52,13.14) 130.59,15.07 v3(130.59,17.05)
  BOTTOM w0.381: v3(149.48,132.48) 148.16,131.16 v3(148.16,127.93) 146.89,126.66 146.89,125.71 146.4,125.22 146.4,122.51 143.54,119.65 143.54,116.24 138.03,110.73 138.03,110.09 135.17,107.23 135.17,70.31 148.4,57.08 148.4,54.92 149.61,53.72 149.61,43.22 147.27,40.88 147.27,29.75 141.46,23.93 v3(141.46,18.15)
  BOTTOM w0.508: PR216.1 131.99,11.91 132.52,12.44 v3(132.52,13.14) ; PR64.1 120.02,11.44 v3(120.84,12.26)
+15V_ALWP: length 4.7
  TOP w0.127: PR60.2 41.46,73.3 v2(41.48,73.32)
  TOP w0.508: PR60.2 39.93,72.96 PC48.2 40.21,71.21 PD6.1
+A3VPCU: length 1.8
  TOP w0.203: U13.74 184.56,52.33 184.61,52.38 C247.1
  vias: v2(187.1,51.68) v3(186.97,61.31) v3(187.74,52.58)
+V1.05M_VCCASW: length 1.1
  BOTTOM w0.508: v3(174.89,103.88) 174.89,104.61 C435.2
  vias: v2(174.76,104.64) v3(163.68,104.31) v3(163.68,102.69) v3(164.35,103.51) v3(164.34,102.69)
+V1.05M_VCCDUSBSUS: length 1.3
  TOP w0.254: v3(163.98,109.67) 163.65,109.99 C125.1
  BOTTOM w0.254: v3(163.98,109.67) 163.83,109.52 163.56,109.52 U24.Y35
+V1.05M_VCCSUS: length 4.8
  TOP w0.254: C198.1 164.47,96.1 164.47,99.48 164.11,99.85 v3(163.98,99.85)
  BOTTOM w0.254: v3(163.98,99.85) 163.77,100.06 U24.Y12
+V1.05S_PCH_VCC: length 1.7
  TOP w0.254: v3(161.7,105.13) 162.25,105.13 163.03,105.91 v3(163.03,105.95)
  vias: v2(142.57,95.9) v3(144.1,98.62) v3(144.1,97.96) v3(144.1,97.3) v3(144.1,96.64) v3(144.07,95.98) v3(161.04,104.31) v3(161.04,102.69) v3(161.7,104.3) v3(161.7,102.7)
+V1.05S_VCC_AXCK_DCB: length 12.1
  BOTTOM w0.254: C412.1 155.81,115.39 156.34,115.39 157.73,113.99 U24.AP45
  BOTTOM w0.508: C412.1 153.44,118.26 153.8,118.62 v3(153.8,119.53) 153.8,119.81 C408.1 152.82,120.55 L22.2
+V1.05S_VCC_EXP: length 3.1
  TOP w0.508: v3(157.5,110.34) 157.4,110.44 C123.1
  BOTTOM w0.254: 157.51,109.42 157.51,109.17 157.89,108.79 U24.AN34 ; 157.51,109.42 157.51,110.33 v3(157.5,110.34) ; 157.51,109.42 157.54,109.44 U24.AN35
  vias: v1(143.51,105.89) v1(143.51,104.62) v1(144.25,104.46) v1(145.04,104.46) v1(145.88,104.26) v1(146.33,103.65) v2(155.07,104.46) v3(156.94,103.65) v3(157.59,103.65) v3(158.24,103.65) v3(158.3,102.67) v3(159.06,102.69) v3(159.72,104.31)
+V1.05S_VCC_SSCFF: length 15.7
  TOP w0.381: R53.2 163.3,120.67 v2(162.79,120.16) 162.17,119.54 v3(162.16,119.54)
  IN1 w0.381: v3(162.16,119.54) 162.3,119.54 163.02,118.81 163.02,115.94 163.58,115.39 163.58,113.89 163.22,113.53 163.22,112.57 162.38,111.73 162.38,109.21 163.02,108.58 v3(163.02,108.4) v3(163.02,107.57)
+V1.05S_VCCAPLL_EXP: length 13.9
  BOTTOM w0.254: 151.87,104.38 152.08,104.17 152.77,104.17 U24.BE22
  BOTTOM w0.508: R512.2 140.9,105.25 141.12,105.25 142.4,106.52 L23.2 142.65,106.67 143.77,106.67 144.92,105.53 C431.1 146.43,105.43 v2(146.44,105.43) 146.44,105.43 150.81,105.43 151.87,104.38
+V1.05S_VCCAPLL_FDI: length 7.2
  TOP w0.508: v3(148.47,113.51) 148.75,113.23 L6.2 149.58,113.05 R75.2 151.25,113.07 C118.1 154.07,113.07 154.21,113.2 v3(154.81,113.2)
  BOTTOM w0.279: v3(154.81,113.2) 154.74,113.13 U24.BB44
+V1.05S_VCCAPLL_SATA3: length 18.4
  TOP w0.254: v3(157.45,99.32) 156.43,99.32 156.16,99.59 156.16,99.98 155.91,100.23 152.85,100.23 R142.2
  TOP w0.508: R142.2 152.28,100.5 152.28,100.09 151.77,99.59 149.31,99.59 149.03,99.86 C176.1 147.89,99.51 145.6,99.51 L8.2 146.38,101.08 146.38,101.75 v3(146.64,102)
  BOTTOM w0.254: v3(157.45,99.32) 157.59,99.46 U24.AN11
+V1.5S_VCCATS: length 2.8
  TOP w0.254: v3(156.24,112.03) 156.24,112.59 R78.2 155.49,112.55 v3(154.85,112.55)
  BOTTOM w0.254: U24.AW40 155.14,112.26 v3(154.85,112.55)
+V1.05S_VCCAUSB: length 9.2
  TOP w0.279: C136.2 164.41,108.5 v3(164.95,109.04) 164.78,109.04 164.47,109.35 164.47,109.68 164.47,113.13 v3(164.65,113.3) 165.17,113.82 166.38,113.82 R67.1
  BOTTOM w0.203: v3(164.95,109.04) 164.55,109.44 U24.U35
+V1.05S_VCCAUX: length 7.1
  TOP w0.254: v3(164.98,109.69) 165.09,109.69 165.48,110.08 165.48,110.61 165.45,110.65 165.45,111.84 165.74,112.13 166.37,112.13 v3(166.45,112.06) 166.52,111.99 167.37,111.99 167.87,112.5 167.87,113.03 R73.2
  BOTTOM w0.254: v3(164.98,109.69) 164.84,109.69 164.49,110.04 U24.U36
+V1.05S_VCCCLKF100: length 10.1
  TOP w0.279: R64.2 164.5,115.47 163.91,115.47 163.43,114.99 163.43,114.58 161.63,112.78 161.63,111.41 161.24,111.02 C122.1 161.07,110.69 160.98,110.61 160.98,110.06 161.35,109.69 v3(161.46,109.69)
  BOTTOM w0.254: U24.AD36 161.73,109.87 161.63,109.87 v3(161.46,109.69) 161.71,109.44 U24.AD35
+V1.05S_VCCPCPU: length 14
  TOP w0.254: R129.2 148.59,103.27 148.59,102.51 148.91,102.19 152.42,102.19 v3(152.43,102.2) 152.44,102.19 156.23,102.19 C169.1 156.86,101.55 156.86,100.57 C182.2 157.48,99.95 158.5,99.95 158.79,99.66 C181.2 159.24,99.66 v3(159.46,99.88)
+V1.05S_VCCSSCF100:
  vias: v3(160.4,107.56) v3(161.05,107.56) v3(162.13,114.72) v3(162.8,114.76)
+V1.05S_VCCUSBCORE:
  vias: v2(169.42,120.54) v3(163.68,107.56) v3(164.34,107.56) v3(168.78,120.21) v3(168.79,119.56)
+V3.3A_VCCPSUS: length 3.7
  TOP w0.381: C153.2 165,104.33 v3(165.01,104.32)
  BOTTOM w0.279: U24.AJ32 159.77,107.7 159.77,107.43 U24.AJ30 ; U24.R20 U24.R22 165.27,103.9 165.01,104.17 v3(165.01,104.32)
  BOTTOM w0.305: U24.AJ30 160.06,107.16 160.38,106.84 v3(160.38,106.73)
  vias: v1(179.05,112.49)
+V3.3A_VCCPUSB: length 3.9
  TOP w0.381: v3(165.01,105.92) 164.8,105.92 164.35,105.46 v3(164.35,105.11) 164.3,105.06 C152.2
  BOTTOM w0.508: v3(177.24,112.36) 177.12,112.24 v2(176.53,112.24) 176.38,112.39 R488.2
+V3.3M_VCCPSPI: length 3.6
  TOP w0.254: R181.2 161.35,93.31 162.11,94.07 v3(162.26,94.07) 162.51,93.82 R522.2 ; v3(161.41,99.86) 161.65,99.86 161.94,99.56 C183.1
  BOTTOM w0.203: U24.AD12 161.71,99.86 161.41,99.86 v3(161.41,99.86)
+V3.3S_ADACBG: length 20.5
  TOP w0.254: v3(166.8,107.19) 166.93,107.32 166.93,109.09 167.13,109.29 167.13,109.7 167.52,110.09 167.52,110.48 168.48,111.44 168.97,111.44 169.1,111.56 169.84,111.56 170.09,111.31 171.21,111.31 171.81,111.91 174.18,111.91 174.66,111.42 175.4,111.42 175.72,111.75 175.72,113.86 R76.2 175.77,114.28 176.7,115.21 178.72,115.21 v2(178.77,115.16) 178.85,115.08 R72.2
  BOTTOM w0.254: U24.M31 166.6,107.39 v3(166.8,107.19)
+V3.3S_VCC_ASEPCI: length 9.7
  TOP w0.279: v3(165,107.56) 165,108.35 165.53,108.89 165.53,109.33 C126.1 165.86,109.96 166.81,110.91 167.16,110.91 v3(168.03,111.78) 168.16,111.92 168.8,111.92 169.22,112.34 169.22,113.11 R74.1
  BOTTOM w0.305: U24.V32 164.12,108.08 164.56,108.08 U24.U32 164.69,107.97 165,107.66 v3(165,107.56)
+V3.3S_VCC_FLEX0: length 8.9
  TOP w0.305: C130.1 169.76,108.64 168.34,108.64 v3(167.42,107.71) 167.38,107.68 167.38,107.04 166.76,106.42 v3(166.76,106.23)
  TOP w0.381: R98.1 171.76,109.4 171.18,108.81 171.18,108.22 170.93,107.97 170.35,107.97 169.86,108.45 C130.1
  BOTTOM w0.254: U24.M29 166.6,106.39 v3(166.76,106.23)
+V3.3S_VCC_FLEX1: length 9.6
  TOP w0.254: v3(167.41,106.24) 167.41,106.39 167.74,106.72 168.49,106.72 C140.1 168.95,106.72 170.51,106.72 171.53,107.74 174.1,107.74 v2(174.3,107.94) 174.47,108.12 R99.1
  BOTTOM w0.254: v3(167.41,106.24) 167.41,106.5 U24.L29
+V3.3S_VCC_FLEX23: length 7.1
  TOP w0.254: v3(166.8,105.25) 166.26,105.79 C143.1
  TOP w0.279: R114.1 v3(171,106.16) 170.9,106.16 170.43,105.7 169.02,105.7 168.99,105.72 167.26,105.72 166.8,105.27 v3(166.8,105.25)
+V3.3S_VCC_GIO: length 17.4
  TOP w0.279: C137.2 165.77,107.56 v3(165.66,107.56)
  TOP w0.381: v3(169.32,123.28) 169.57,123.54 170.18,123.54 170.69,123.03 v2(170.69,122.8) 170.69,122.42 171.3,121.81 R55.2
  IN2 w0.381: v3(169.32,123.28) 169.32,123.21 169.06,122.95 169.06,121.42 167.79,120.15 167.79,111.4
+V3.3S_VCCAUBG: length 11.9
  TOP w0.254: C154.2 168.07,104.34 169.41,104.34 169.8,103.95 170.27,103.95 171.76,105.44 174.23,105.44 174.98,106.19 175.77,106.19 v3(176.03,106.44) 176.43,106.44 176.69,106.7 R108.1
  TOP w0.279: v3(167.46,105.23) 167.46,105.07 167.81,104.73 C154.2
  BOTTOM w0.254: v3(167.46,105.23) 167.46,105.02 U24.L24
+V3.3S_VCCPCORE: length 2.7
  TOP w0.381: v3(161.03,101.06) 160.93,100.96 C179.2 160.93,100.29 160.49,99.86 v3(160.45,99.86)
  TOP w0.508: v3(160.24,93.16) 159.96,92.88 R190.1
+V3.3S_VCCPFUSE: length 15.1
  TOP w0.279: v3(165.66,102.69) 166.03,102.31 C166.1 166.25,102.01 166.44,102.2 167.8,102.2 167.8,102.21 169.64,102.21 170.13,101.72 170.47,101.72 170.97,101.21 174.55,101.21 R139.2 174.98,101.11 175.58,101.71 176.78,101.71 v2(177.09,101.39) 177.8,100.68 R143.2
  BOTTOM w0.254: U24.P18 165.99,102.29 165.67,102.61 165.67,102.67 v3(165.66,102.69) 165.67,102.7 165.67,102.7 165.99,103.02 U24.P20
+V3.3S_VCCPTS: length 1.1
  BOTTOM w0.279: U24.AK30 159.06,107.48 v3(159.06,107.55) 159.06,107.65 159.38,107.97 U24.AK32
  vias: v2(158.55,108.17)
+VCC_AXCK_DCB: length 2.8
  BOTTOM w0.508: L22.1 149.66,120.21 148.22,118.77 R477.2
+VCC_HDA_IO: length 10.5
  BOTTOM w0.254: R493.1 179.06,109.33 179.06,108.78 C427.2 178.69,108.58 178.41,108.86 177.09,108.86 176.73,108.49 R501.2 176.73,108.11 176.15,107.54 175.36,107.54 173.49,105.67 U24.A26
+VCCA_DAC_1_2: length 10
  TOP w0.381: v3(166.3,118.18) 166.65,118.18 166.83,118 C114.2 167.47,118 168.24,118.77 L4.1 168.68,118.12 168.56,118 C115.1
  BOTTOM w0.254: U24.P45 165.86,116.39 166.91,117.44 C416.2
  BOTTOM w0.381: v3(166.3,118.18) 166.86,118.18 C416.2
+VCCA_USBSUS: length 10.1
  TOP w0.508: C139.1 153.24,107.16 153.69,106.71 155.53,106.71 155.59,106.66 C145.1 155.77,106.84 157.86,106.84 158.58,106.12 159.32,106.12 159.72,106.53 v3(159.72,106.73)
  BOTTOM w0.254: U24.AJ26 U24.AJ28 160.01,106.34 159.72,106.63 v3(159.72,106.73)
+VCCAPLL_USB3: length 17.3
  TOP w0.508: R101.2 146.35,108.9 L7.2 148.24,110.79 v2(149.41,110.79) 150.9,110.79 151.93,109.76 C128.1 152.05,109.34 154.04,107.35 155.16,107.35 155.27,107.46 158.21,107.46 158.93,106.73 v3(159.06,106.73)
  BOTTOM w0.254: U24.AK26 U24.AK28 159.28,106.34 159.06,106.56 v3(159.06,106.73)
+VCCAXCK_VRM: length 4.7
  TOP w0.508: v3(161.88,115.37) 161.81,115.37 160.94,114.51 C117.1 159.67,113.18
  BOTTOM w0.254: v3(159.65,108.42) 160.3,108.42 160.4,108.53 160.71,108.53 160.92,108.74 U24.AF34
  vias: v2(155.55,117.82) v3(162.03,118.88)
+VCCCLKF135: length 7.4
  TOP w0.279: R70.1 164.14,113.62 163.12,112.6 v3(163.12,112.26) 163.12,111.95 C121.1 162.26,109.68 161.62,109.04 v3(161.41,109.04)
  BOTTOM w0.254: v3(161.41,109.04) 161.61,108.84 U24.AD34
+VCCIN: length 36.1
  IN1 w0.381: v3(38.51,99.2) 39.41,99.2 42.01,101.8 55.35,101.8 57.26,99.89 65.21,99.89
  BOTTOM w0.279: v3(105.93,107.15) U27.AD25 ; 113.4,107.67 U27.U26 113.4,107.69
  BOTTOM w0.381: v3(38.51,99.2) 38.41,99.3 37.39,99.3 36.98,98.89 PR130.2
  BOTTOM w0.508: v3(99.29,117.32) 99.29,119.53 98.58,120.24 R460.2
  vias: v1(70.92,94.61) v1(70.9,93.85) v1(70.9,93.08) v1(70.95,92.3) v1(71.68,94.58) v1(71.68,93.82) v1(71.66,93.03) v1(71.78,92.27) v1(71.78,91.46) v1(72.5,94.61) v1(72.52,93.82) v1(72.52,93.03) v1(72.57,92.22) v1(72.6,91.46) v1(73.31,94.53) v1(73.33,93.74) v1(73.38,92.98) v1(73.38,92.17) v1(73.36,91.38) v1(74.12,94.56) v1(74.17,93.8) v1(74.2,93.01) v1(74.2,92.25) v1(74.96,94.63) v1(74.96,93.85) v1(75.01,93.06) v1(75.72,94.63) v1(75.75,93.85) v1(76.64,95.7) v1(76.64,94.91) v1(77.09,96.51) v1(77.37,95.5) v1(77.73,97.02) v1(77.93,96.06) v1(78.34,97.55) v1(78.54,96.67) v1(78.85,98.11) v1(79.18,97.25) v1(79.4,98.62) v1(79.89,97.88) v1(80.34,98.72) v1(81.03,99.28) v2(76.58,89.53) v3(92.14,107.72) v3(100.93,114.15) v3(100.93,113.15) v3(100.93,112.15) v3(100.93,111.15) v3(100.93,110.15) v3(100.93,109.15) v3(100.93,108.15) v3(100.93,107.15) v3(100.93,106.15) v3(101.93,116.15) v3(101.93,115.15) v3(101.93,114.15) v3(101.93,113.15) v3(101.93,112.15) v3(101.93,111.15) v3(101.93,110.15) v3(101.93,109.15) v3(101.93,108.15) v3(101.93,107.15) v3(101.93,106.15) v3(102.11,117.22) v3(102.48,104.47) v3(102.48,103.71) v3(102.48,102.18) v3(102.48,101.42) v3(102.48,99.9) v3(102.48,99.13) v3(102.93,116.15) v3(102.93,114.15) v3(102.93,112.15) v3(102.93,110.15) v3(102.93,108.15) v3(102.93,106.15) v3(103.93,117.15) v3(103.93,116.15) v3(103.93,115.15) v3(103.93,114.15) v3(103.93,113.15) v3(103.93,112.15) v3(103.93,111.15) v3(103.93,110.15) v3(103.93,109.15) v3(103.93,108.15) v3(103.93,107.15) v3(103.93,106.15) v3(104.93,116.15) v3(104.93,114.15) v3(104.93,112.15) v3(104.93,110.15) v3(104.93,108.15) v3(104.93,106.15) v3(105.93,117.15) v3(105.93,116.15) v3(105.93,115.15) v3(105.93,114.15) v3(105.93,113.15) v3(105.93,112.15) v3(105.93,111.15) v3(105.93,110.15) v3(105.93,109.15) v3(105.93,108.15) v3(105.93,106.15) v3(106.93,116.15) v3(106.93,114.15) v3(106.93,112.15) v3(106.93,110.15) v3(106.93,108.15) v3(106.93,106.15) v3(107.81,104.47) v3(107.81,103.71) v3(107.81,99.9) v3(107.83,99.24) v3(107.93,117.15) v3(107.93,116.15) v3(107.93,115.15) v3(107.93,114.15) v3(107.93,113.15) v3(107.93,112.15) v3(107.93,111.15) v3(107.93,110.15) v3(107.93,109.15) v3(107.93,108.15) v3(107.93,107.15) v3(107.93,106.15) v3(108.44,102.14) v3(108.44,101.48) v3(108.48,100.72) v3(108.93,116.15) v3(108.93,114.15) v3(108.93,112.15) v3(108.93,110.15) v3(108.93,108.15) v3(108.93,106.15) v3(109.59,104.47) v3(109.59,103.71) v3(109.59,99.9) v3(109.59,99.25) v3(109.93,117.15) v3(109.93,116.15) v3(109.93,115.15) v3(109.93,114.15) v3(109.93,113.15) v3(109.93,112.15) v3(109.93,111.15) v3(109.93,110.15) v3(109.93,109.15) v3(109.93,108.15) v3(109.93,107.15) v3(109.93,106.15) v3(110.27,102.21) v3(110.3,101.45) v3(110.32,100.68) v3(110.93,109.15) v3(110.93,108.15) v3(110.93,106.15) v3(111.37,104.47) v3(111.37,103.71) v3(111.38,99.9) v3(111.37,99.23) v3(111.93,108.15) v3(111.93,107.15) v3(111.93,106.15) v3(112.1,102.18) v3(112.11,101.38) v3(112.93,108.16) v3(112.93,107.15) v3(112.93,106.15) v3(113.93,107.15) v3(113.93,106.15) v3(114.93,107.15) v3(114.93,106.15) v3(115.93,107.15) v3(115.93,106.16) v3(116.7,104.47) v3(116.7,103.71) v3(116.7,99.9) v3(116.7,99.25) v3(116.93,107.15) v3(116.93,106.15) v3(117.46,102.18) v3(117.47,101.4) v3(117.93,107.15) v3(117.93,106.15) v3(118.48,104.47) v3(118.48,103.71) v3(118.48,99.9) v3(118.48,99.25) v3(118.93,107.15) v3(118.93,106.15) v3(119.26,102.17) v3(119.28,101.33) v3(119.93,108.15) v3(119.93,107.15) v3(119.93,106.15) v3(120.93,107.15) v3(120.93,106.15) v3(121.93,107.15) v3(121.93,106.15) v3(122.93,107.15) v3(122.93,106.15) v3(123.93,107.15)
+VCCIO_OUT: length 83
  TOP w0.635: R68.2 135.12,114.89 135.89,115.66 135.89,116.4 v2(137.19,117.7) 137.19,117.7 v3(137.19,119.2)
  IN1 w0.635: v3(137.19,119.2) 137.19,121.11 133.77,124.53 117.96,124.53 v3(117.78,124.71) 115.78,124.71 113.47,122.4 102.42,122.4 100.46,124.35 97.37,124.35 v3(96.37,125.36) ; v3(87.08,102.13) 84.23,102.13 v3(83.22,103.14)
  BOTTOM w0.635: R457.2 118.13,124.36 v3(117.78,124.71) ; v3(96.37,125.36) 94.56,125.36 91.11,121.91 C406.2 ; v3(96.37,125.36) 96.16,125.15 96.16,124.26 R458.2 ; v3(96.37,125.36) 97.82,126.81 R453.2 ; R533.1 86.85,101.9 v3(87.08,102.13) 86.97,102.23 R520.1 ; v3(83.22,103.14) 83.14,103.22 83.14,113.66 85.3,115.82 R482.1
+VCCIO_OUT_R: length 9.3
  BOTTOM w0.508: R482.2 89.64,116.55 v3(90.5,116.55) 92.99,116.55 93.71,117.27 96.81,117.27 U27.AN35
+VCCIO_PCH: length 12.7
  TOP w0.508: R116.1 140.67,106.47 v2(140.21,106.01) 139.79,105.59 R117.1 ; R116.1 141.96,106.47 142.27,106.77 144.45,106.77 147.45,103.78 R129.1 ; R116.1 141.33,106.5 C138.2
+VCCIO_PCH_R: length 5.9
  TOP w0.254: v3(129.93,104.15) 132.79,104.15 v2(132.8,104.16) 133.01,104.16 R117.2
  BOTTOM w0.381: v3(129.93,104.15) U27.A23
+VCCIOA_OUT:
  vias: v2(137.72,109.64)
+VCCIOA_OUT_R: length 13.3
  TOP w0.508: v3(123.93,103.15) 124.97,103.15 126.55,104.74 128.42,104.74 128.85,105.17 131.6,105.17 v2(132.16,105.73) 134.44,108.01 R105.2
  BOTTOM w0.254: v3(123.93,103.15) 123.93,103.22 U27.F22
+VCCPDSW: length 16
  TOP w0.102: R136.2 178.23,102.02
  TOP w0.254: 178.23,102.02 178.79,102.58 180.19,102.58 180.55,102.23 v2(180.93,102.23) 181.18,102.23 181.81,102.86 R127.2 ; C168.2 175.14,101.79 175.43,102.08 175.93,102.08 v3(176.19,102.34) 176.88,102.34 177.24,101.97 R136.2
  BOTTOM w0.254: U24.A16 171.82,101.61 171.9,101.52 174.85,101.52 174.95,101.62 175.61,101.62 176.19,102.21 v3(176.19,102.34)
+VCCPRTCSUS_3P3: length 12.3
  TOP w0.229: v3(167.88,98.54) 167.88,98.62 168.51,99.25 169.49,99.25 170.04,98.71 C190.1
  TOP w0.254: R149.2 176.2,99.21 175.43,98.44 R151.2 174.66,98.44 v2(174.35,98.75) 174.3,98.8 173.35,98.8 173.22,98.67 172.38,98.67 171.86,99.19 170.69,99.19 C190.1
  BOTTOM w0.254: v3(167.88,98.54) 167.78,98.54 167.51,98.27 U24.K8
+VCCRTCEXT: length 1.8
  TOP w0.305: C177.2 165.38,100.73 165.67,101.02 v3(165.67,101.07)
  BOTTOM w0.254: U24.P16 165.99,101.39 v3(165.67,101.07) 165.99,100.75 U24.P14
+VCCSST: length 1.7
  TOP w0.305: C178.2 162.85,100.46 162.36,100.95 v3(162.36,101.06)
  BOTTOM w0.305: v3(162.36,101.06) 162.36,100.95 162.66,100.65 U24.AA14
+VCCST: length 15.3
  TOP w0.381: v3(99.93,113.15) 100.13,113.36 100.13,115.54 100.8,116.22 100.8,120.43 100.96,120.58 v3(100.96,120.95)
  BOTTOM w0.305: U27.AK31 v3(99.93,113.15)
  BOTTOM w0.381: C388.1 101.76,126.43 101.76,124.92 C390.1 R462.2 101.22,122.24 100.96,121.99 v3(100.96,120.95)
+VIN_VCCIN: length 12.5
  BOTTOM w0.381: 50.25,83.13 48.16,85.21 41.2,85.21 39.68,86.73 PR95.1
  vias: v1(50.63,79.47) v1(51.44,83.61) v1(51.41,78.76) v1(51.41,78) v1(51.46,82.85) v1(51.49,82.03) v1(51.46,79.55) v1(51.72,81.27) v1(52.73,91.2) v1(52.73,90.44) v1(52.76,89.6) v1(53.52,92.45) v1(53.47,91.69) v1(53.5,90.9) v1(53.5,90.14) v1(53.5,89.38) v1(54.33,92.47) v1(54.26,91.71) v1(54.26,90.95) v1(54.31,90.19) v1(54.28,89.43)
AGND_CPU: length 13.5
  TOP w0.381: PC88.2 46.33,99.23 v3(45.88,99.69)
  IN2 w0.381: v3(41.53,99.38) 41.66,99.51 43.34,99.51 43.69,99.87 45.7,99.87 v3(45.88,99.69)
  BOTTOM w0.381: v3(42.32,87.19) 42.32,87.21 PR103.1 ; PC156.2 PC158.2 38.81,91.66 PC89.2 PC86.2 v3(38.81,88.62) ; PR193.2 v3(51.39,92.58) ; PC154.2 50.86,94.9 v3(51.46,94.3) ; PC77.2 41.84,99 41.53,99.31 v3(41.53,99.38)
  vias: v2(42.9,91.33)
AGND_DDR:
  vias: v2(51.46,29.28)
AVDD: length 6.9
  BOTTOM w0.508: v3(40.06,10.56) 39.4,11.22 L32.1 39.05,11.13 C558.1 C557.1 36.89,11.22 C559.2 34.8,11.22 33.89,12.13
DVDD: length 3.5
  BOTTOM w0.508: R707.2 28.5,17.7 28.1,17.3 28.1,15.99 28.18,15.91 C548.2 ; L32.2 v3(39.14,8.91)
  vias: v3(28.81,15.46) v3(31.13,17.05) v3(37.19,17.19) v3(38,16.73)
DVDD_IO: length 7.6
  TOP w0.178: C306.1 28.49,34.22 29.32,33.39 29.32,32.99 29,32.67 U15.9
  TOP w0.381: C306.1 28.1,34.22 v3(28.1,33.47)
  BOTTOM w0.508: v2(27.16,34.31) 27.18,34.28 28.03,34.28 C306.1 ; C306.1 28.09,33.47 v3(28.1,33.47) ; C306.1 R692.1 R693.1
GND: length 1445
  TOP w0.127: v3(117.83,14.06) 115.56,14.06 115.39,13.9 U16.13 ; U16.5 111.21,11.9 110.55,12.57 109.45,12.57 v3(109.3,12.41) 109.28,12.39 109.28,11.7 109.38,11.6 109.38,10.16 C338.2 ; v3(112.42,15.08) 112.68,14.82 U16.16 ; U16.12 v3(117.78,13.4) ; U16.10 v3(117.9,12.4) ; v3(113.11,15.08) 113.18,15 U16.15
  TOP w0.203: v3(171.9,60.83) 171.97,60.9 171.97,61.54 171.63,61.87 U13.122 ; U13.27 168.48,50.73 168.96,50.25 v3(168.96,49.6) ; v3(166.48,61.54) 166.89,61.13 U13.1 ; U13.91 182.23,59.13 v3(181.61,58.51) ; v3(175.43,48.24) 175.63,48.04 U13.49 ; U13.113 175.23,61.99 175.18,61.93 175.18,60.68 v3(175.2,60.65) ; VRAM2.G1 124.39,146.85 v3(124.78,146.46)
  TOP w0.254: U8.3 182.27,83.32 v3(181.86,83.72) ; v3(155.27,101.7) 155.27,101.71 C169.2 ; v3(84.9,103.09) 85.06,102.93 U5.3 ; v3(138.18,172.59) 138.18,172.03 138.61,171.6 138.61,171.11 138.03,170.53 R14.1 ; Q8.4 v3(107.91,159.22) ; VRAM1.E2 v3(118.35,171.54) ; VRAM2.J8 118.75,148.45 v3(119.17,148.86) ; PR36.1 156.8,181.2 153.12,181.2 v3(152.12,182.19) ; VRAM2.D8 118.71,144.45 v3(118.34,144.83) 118.75,145.24 VRAM2.E8 ; v3(194.72,93.44) 194.92,93.65 194.92,93.97 194.79,94.11 Q21.1 ; R165.1 167.42,94.37 v3(167.52,94.26) ; v3(164.82,53.83) 164.82,54.12 165.18,54.48 165.18,55.06 165.4,55.28 C245.2 ; Q21.4 191.25,95.41 190.89,95.06 v3(190.89,94.85) ; VRAM2.G8 v3(119.15,147.25) ; v3(123.96,148.03) VRAM2.J2 ; v3(184.41,187.24) 184.41,187.2 PR6.2 ; U12.3 77.69,69.4 77.94,69.64 v3(79.09,69.64) ; C183.2 162.06,100.41 161.7,100.77 v3(161.7,101.06) ; v3(118.35,169.14) VRAM1.G1
  TOP w0.279: U3.3 v3(182.13,171.27) ; C136.1 163.63,108.67 v3(163.98,109.02) ; v3(170.16,98.07) 170.38,98.07 170.98,98.68 C190.2
  TOP w0.305: VRAM1.E8 v3(123.15,171.54) 123.37,171.77 VRAM1.D8 ; v3(117.49,173.98) 117.93,173.54 VRAM1.B1 ; R192.1 110.94,91.09 v3(110.88,91.16) ; VRAM2.G9 117.41,146.85 v3(117.34,146.78) 117.38,146.74 117.38,146.62 VRAM2.F9 ; v3(135.37,56.94) 135.42,56.94 135.42,56.93 135.87,56.93 R297.2 ; C164.2 159.68,102.65 v3(159.72,102.69) 159.71,102.7 159.71,103.31 C160.2 ; v3(113.88,91.19) 113.99,91.31 R191.1 ; v3(124.93,173.6) 124.87,173.54 VRAM1.B9 ; C177.1 166.16,100.04 v3(165.98,99.85) ; R155.2 161.96,97.53 161.58,97.91 v3(161.41,97.91) ; C213.2 160.56,89.41 v3(160.08,88.93) 159.53,89.48 R201.2 ; VRAM1.P1 117.4,163.94 117.38,163.92 v3(117.36,163.92) ; C115.2 v3(171.23,117) ; v3(159.04,101.05) 159.06,101.04 159.06,100.65 C181.1 ; C165.2 162.97,102.08 v3(162.36,102.69) 162.36,102.83 162.66,103.12 C162.2 ; R323.2 R325.2 136.33,48.57 v3(136.01,48.89) ; VRAM1.G8 123.55,169.54 v3(123.95,169.14) VRAM1.G9 ; VRAM1.E1 117.86,171.14 v3(117.42,171.59) 117.53,171.7 117.61,171.7 117.85,171.94 VRAM1.D1 ; VRAM1.T9 124.76,162.34 124.94,162.53 v3(124.94,162.63) ; C114.1 167.04,119.33 v3(166.78,119.59) ; VRAM1.P9 124.37,163.92 124.92,163.92 124.95,163.9 v3(124.95,163.87) ; v3(119.15,167.54) 118.75,167.94 VRAM1.J2 ; VRAM2.P1 v3(124.88,152.45) ; C75.2 147.01,152 v3(146.27,151.26) ; VRAM2.M9 117.55,150.85 117.32,150.62 v3(117.24,150.62) ; VRAM2.E2 v3(123.15,144.85) ; VRAM2.M1 125.01,150.85 v3(125.09,150.77) ; VRAM1.M9 124.53,165.54 v3(124.87,165.2) ; v3(134.98,45.19) 134.98,45.8 134.05,46.73 C270.2 ; v3(122.66,141.26) 122.66,141.28 122.32,141.62 122.32,142.42 VRAM2.B3 ; v3(135.11,118.33) 135.02,118.25 R65.2 ; C166.2 165,101.76 v3(165,101.07) ; VRAM1.J8 v3(123.15,167.54) ; VRAM1.M1 117.36,165.54 v3(117.29,165.61) ; U1.5 163.73,178.72 163.53,178.92 163.53,179.4 v3(163.76,179.62) ; VRAM2.D1 124.37,144.45 v3(124.77,144.85) 124.37,145.25 VRAM2.E1 ; v3(124.94,154.16) 124.83,154.05 VRAM2.T1 ; VRAM1.B3 119.92,173.54 v3(120.23,173.86) ; R52.2 146.15,121.45 145.24,120.53 v3(145.24,120.53) ; VRAM1.F9 124.48,170.48 124.48,170.65 125.2,171.37 v3(125.2,171.49) ; VRAM1.A9 124.28,174.41 v3(124.28,174.87) ; v3(117.34,162.34) VRAM1.T1 ; v3(116.99,152.56) 117.02,152.58 117.81,152.58 VRAM2.P9 ; VRAM2.B1 124.35,142.85 124.9,142.29 124.9,142.24 v3(124.86,142.2) ; C178.1 163.68,100.76 v3(163.68,101.06) ; v3(117.35,154.05) VRAM2.T9
  TOP w0.381: R23.1 169.46,164.72 v3(169.88,164.31) ; v3(11.1,100.15) 11.1,100.55 10.72,100.93 U6.3 ; v3(98.17,72.12) 99.09,72.12 C223.2 C224.2 ; C149.1 176.1,105.59 v3(176.54,105.15) ; v3(151.86,121.32) 151.71,121.47 R49.1 ; C182.1 156.63,100.1 156.37,100.37 v3(156.37,100.73) ; C179.1 160.15,100.61 159.77,100.99 159.77,101.02 159.75,101.03 159.75,101.03 159.74,101.05 v3(159.72,101.05) ; Q28.1 v3(188.2,87.57) ; v3(28.75,83.2) 28.75,82.45 29.17,82.03 U9.2 ; C143.2 165.66,106.5 v3(165.66,105.94) ; v3(83.09,63.87) 83.59,64.38 C230.2 ; v3(87.66,101.29) 87.66,101.43 88.46,102.23 R135.2 88.58,101.11 R140.2 ; v3(155.72,109.21) 155.89,109.04 C129.1 ; v3(97.07,52.84) 98.07,52.84 C253.1 99.21,51.7 C257.2 ; R81.1 166.41,113.2 v3(167.08,112.53) ; v3(181.28,77.7) 181.53,77.46 181.53,76.8 ; v3(119.7,128.54) 118.33,128.54 R46.1 ; v3(113.01,43.52) 113.01,43.52 111.74,44.79 111.74,45.84 C279.1 111.9,46 C280.1 ; R32.1 v3(105.28,158.57) ; C121.2 162.26,112.48 v3(162.2,112.53) ; v3(154.31,105.85) 153.71,105.85 153.36,106.2 152.61,106.2 152.2,105.79 C150.2 ; C152.1 162.97,104.36 v3(163.02,104.31) ; 185.88,63.62 185.33,63.62 R291.2 ; 185.88,63.62 185.79,63.53 R341.2 ; 185.88,63.62 v3(185.9,63.65) ; C268.1 101.19,46.73 C267.2 100.01,46.1 99.49,45.58 v3(98.92,45.58) ; R93.1 172.71,110.54 v3(173.08,110.18) ; v3(33.56,23.2) C326.2 32.87,23.31 32.09,24.09 C325.2 ; C196.1 v3(23.41,96.21) ; R164.1 22.89,95.57 v3(22.68,95.37) ; C255.1 103.56,53.61 v3(103.26,53.91) ; R9.2 148.28,172.81 149.51,172.81 v3(149.61,172.92) ; v3(112.83,166.9) 112.09,166.9 111.3,167.69 C22.1 ; v3(159.72,190.34) 159.72,190.57 159.24,191.05 158.37,191.05 158.32,191 PC21.1 PC24.1 ; C313.2 36.65,33.4 R348.1 36.64,34.1 37,34.47 v3(37,34.68) ; v3(176.71,100.02) 175.95,100.02 R146.2 ; R22.1 128.66,166.16 128.44,165.94 v3(128.44,165.94) ; R350.2 24.62,33.51 25,33.89 v3(25,33.89) ; PC145.1 131.11,137.48 130.3,136.67 v3(130.3,136.65) ; v3(112.6,162.96) 112.65,163.01 C29.1 ; C217.2 97,76.47 v3(97,75.99) ; R221.2 165.12,87.03 R222.2 165.13,86.26 v3(165.13,86.25) ; v3(160.21,53.5) 160.83,53.5 161.12,53.78 R329.1 ; v3(194.72,93.44) 194.16,92.88 R177.2 ; C278.2 105.85,46.35 C277.2 104.75,45.25 104.75,44.32 v3(104.77,44.3) ; v3(159.06,105.12) 158.77,105.12 158.27,104.62 C155.2 ; v3(165.66,104.31) 165.66,104.94 C153.1 166.1,105.06 166.55,104.6 C154.1 ; R175.2 v3(151.36,93.76) ; R122.2 170.35,104.76 v3(170.04,104.45) ; C275.1 108.49,46.22 C276.1 108.39,45.45 v3(108.59,45.25) ; v3(161.7,107.55) 161.78,107.62 161.78,108.05 C135.2 ; v3(90.07,104.08) 88.88,104.08 88.54,103.75 R131.2 ; C141.2 161.42,106.31 v3(161.04,105.94) ; v3(163.98,111.64) 163.65,111.32 C125.2 ; v3(160.58,112.53) 161.07,112.04 C122.2 ; v3(40.11,27.99) 39.96,27.84 C321.1 ; C111.1 135.56,133.07 135.56,133.06 v3(136.35,133.06) ; v3(87.25,99.92) 87.48,99.69 R147.2 ; C240.2 187.4,59.41 188.08,58.73 v3(188.08,57.73) ; C130.2 170.64,108.62 v3(170.14,109.12) 170.57,109.12 171.06,109.61 R96.1 ; v3(157.77,83.98) 157.32,83.98 156.75,84.55 R226.2 ; R21.1 113.56,166.5 113.26,166.21 v3(112.78,166.21) ; v3(112.25,150.06) 112.25,150.06 R42.2 ; C256.2 106.1,52.33 106.1,53.74 v3(106.02,53.82) ; C237.2 165.03,60.08 164.11,61 v3(164.11,61.32) ; v3(110.37,12.11) 110.64,11.83 C341.2 ; C7.2 170.97,174.41 v3(170.96,174.41) ; C163.2 160.93,101.93 161.7,101.17 v3(161.7,101.06) ; C302.2 C303.2 34.1,35.5 33.95,35.65 v3(33.94,35.65) ; C211.2 172.2,92.22 v3(172.57,91.85) ; C189.1 23.41,98.25 v3(23.45,98.21) ; PC113.1 178.78,134.51 179.19,134.92 v3(179.2,134.92) ; R90.1 131.68,112.21 v3(131.35,111.87) ; C307.2 v3(30.25,35.68) ; C220.2 179.1,75.87 180.14,74.82 U11.11 ; v3(184.33,134.31) 184.33,133.49 183.87,133.03 PR182.2 182.66,133.03 182.04,133.65 PR159.2 ; C25.2 v3(112.65,164.28) ; R112.2 84.71,106.64 C144.1 84.31,106.66 v3(83.91,107.06) ; C180.2 23.41,99.57 v3(23.45,99.54) ; C308.1 31.4,35.5 31.27,35.63 v3(31.27,35.63) ; v3(134.89,50.26) 134.3,50.26 C261.2 ; VRAM2.B9 117.93,142.85 v3(117.43,142.35) 117.72,142.05 VRAM2.A9 ; C140.2 169.3,107.27 v3(169.34,107.23) ; v3(156.57,110.34) 156.62,110.38 C123.2 ; U11.18 180.14,69.92 v3(180.11,69.95) ; v3(170.11,102.73) 170.34,102.49 171.47,102.49 172.17,101.79 C168.1 ; C260.2 162.37,49.97 v3(162.37,49.58) 162.62,49.33 C263.2 ; v3(119.77,186.02) 119.77,186.17 120.98,187.39 PR87.2 ; C304.2 26.01,34.22 v3(26.38,33.85) ; C116.1 172.99,117.49 v3(174.35,117.49) ; R356.2 40.3,27 v3(40.7,27.4) ; v3(171.43,94.77) 171.42,94.76 R168.2 ; C306.2 v3(28.09,35.71) ; U11.4 184.69,75.08 v3(184.47,75.3) ; PR157.2 57.35,110.6 v3(57.35,110.05) ; R361.1 40.3,21.94 v3(39.86,21.5) ; R378.1 v3(114.07,7.69) ; R115.2 89.43,105.85 v3(90.1,106.52) ; v3(101.58,53.95) 101.53,53.9 C254.1 ; C23.1 v3(112.75,165.55) ; 181.53,76.8 R249.1 ; 181.53,76.8 R247.1 ; v3(156.31,105.24) 156.31,105.4 155.84,105.87 C145.2 ; C318.2 37.77,29.2 v3(38,29.43) ; U11.25 v3(184.69,66.79) ; R41.1 v3(112.83,151.33) ; C244.1 159.45,54.81 v3(159.83,54.43) ; C117.2 160.94,116.01 159.55,114.61 v3(159.55,114.33) ; C204.2 174.91,93.69 v3(175.11,93.49) ; PC140.1 126.82,187.05 v3(126.14,186.38) ; v3(164.54,94.6) 164.57,94.64 C198.2 ; v3(34.12,23.57) 34.44,23.89 R359.2 ; v3(154.27,98.05) 154.27,98.02 153.61,97.36 R157.2 ; v3(158.95,96.37) 158.95,96.23 158.41,95.68 R167.1 ; C161.2 160.38,103.89 v3(160.38,104.31) 160.38,105.26 C151.2 ; Y1.4 20.16,95.79 v3(20.58,95.37) ; C335.1 v3(110.83,15.15) ; C342.2 v3(115.47,7.69) ; v3(182.03,80.15) 182.16,80.02 C216.1 ; v3(46.92,58.67) 46.71,58.87 PC33.1 ; R58.2 99.69,120.96 v3(99.82,121.1) ; v3(103.79,179.22) 103.88,179.12 C1.2 ; v3(186.73,54.8) 186.14,54.8 R304.2 ; PQ29.1 45.21,111.55 v3(44.68,111.02) ; C249.2 111.45,52.28 C252.1 111.53,53.12 v3(111.48,53.17) ; v3(112.7,161.69) 112.75,161.74 R25.2 ; R287.1 71.67,65.36 v3(71.35,65.04) ; C126.2 166.64,109.51 v3(166.12,109) 166.12,108.83 165.66,108.36 C137.1 ; v3(107.49,154.68) Q9.1 ; v3(103.29,44.92) 103.56,45.19 C269.1 ; v3(110.24,54.66) 108.61,53.03 C251.2 ; C142.2 164.23,106.48 v3(163.68,105.94)
  TOP w0.457: C24.2 151.63,165.79 v3(151.26,165.42) ; v3(151.22,88.35) 151.22,89.11 R204.2 ; v3(135.8,169.07) 135.68,168.95 135.68,168.45 136.19,167.94 R19.1
  TOP w0.508: v3(160.64,55.95) 160.91,56.22 C243.2 161.7,56.61 162.45,57.36 C242.2 ; v3(41.13,71.01) 41.76,70.38 PC47.1 ; v3(150.62,102.72) 150.62,103.09 C158.2 ; 41.43,110.56 v3(42.47,110.56) ; Y1.2 21.86,99.42 v3(21.26,100.02) ; C339.2 119.35,9.21 v3(119.71,9.57) ; PC34.2 v3(36.91,56.46) ; PC43.2 51,53.08 v3(50.5,53.59) ; C98.1 164.44,141.11 v3(164.32,140.99) ; v3(176.51,139.77) 176.07,139.33 PR177.2 ; PQ32.1 v3(30.15,57.09) ; v3(15.85,8.49) 15.99,8.63 R375.2 ; HOLE1.1 HOLE1.2 ; HOLE1.1 HOLE1.3 ; HOLE1.1 HOLE1.9 ; C229.2 v3(175.18,67.11) ; C340.2 12.91,8.45 v3(12.98,8.38) ; C77.2 138.45,150.92 138.76,151.22 v3(138.76,151.32) ; v3(159.56,164.94) 159.59,164.97 Q12.1 ; C737.1 v3(54.28,56.04) ; C724.1 160.17,163.24 159.59,162.65 v3(159.49,162.65) ; Q25.1 181.55,87.83 v3(180.66,86.94) 180.66,85.5 180.3,85.14 C215.2 ; v3(152.81,113.95) 152.81,114 C118.2 ; v3(193.28,106.38) C747.1 191.36,106.92 C746.1 ; C175.2 23.04,101.54 v3(22.79,101.8) ; HOLE25.6 HOLE25.1 ; HOLE25.1 HOLE25.4 ; HOLE25.1 HOLE25.3 ; HOLE25.1 HOLE25.5 ; HOLE25.1 HOLE25.8 ; D16.2 v3(15.88,30.83) ; v3(143.59,108.35) 142.85,107.61 C138.1 ; PC62.1 51.49,41.21 v3(51.49,40.33) ; HOLE2.2 HOLE2.1 HOLE2.4 ; v3(165.78,156.83) 165.64,156.97 C53.2 ; C124.1 v3(27.08,114.25) ; R363.2 22.53,20.73 v3(22.53,20.33) ; R83.1 168.32,173.63 v3(168.23,173.63) ; C730.2 179.66,176.7 v3(179.56,176.6) ; PQ50.1 v3(157,141.01) ; v3(130.38,132.86) 129.95,133.29 PQ44.1 ; U33.2 v3(23.27,43.76) ; R281.2 166.02,66.58 v3(166.58,67.14) ; PR202.2 PC146.1 118.54,132.24 v3(119.04,132.24) ; D24.2 18.91,30.56 v3(19.28,30.93) ; v3(199.14,100.84) 198.76,101.22 C167.2 ; v3(21.82,94.2) 22.41,93.62 C205.1 ; SW1.6 162.15,66.38 v3(162.71,66.94) ; v3(26.01,20.31) 25.87,20.17 CN1.6 ; PQ33.1 31.27,53.87 v3(31.14,53.99) ; C271.2 C272.2 191.04,47.62 191.84,48.42 v3(192.07,48.42) 192.07,47.68 C273.2 ; v3(167.21,151.76) 167.71,152.26 C718.1 ; v3(139.12,144.06) C84.2 ; v3(47.91,95.34) 48.72,96.16 PC170.1 ; v3(47.91,95.34) 46.66,96.6 PR218.2 ; v3(47.91,95.34) 47.91,94.79 49.26,93.43 PR124.2 ; v3(180.37,189.27) 180.37,189.27 179.86,189.78 PR37.2 ; v3(114.05,37) 113.48,37.57 C297.2 ; v3(154.03,141.93) 153.19,142.77 R44.1 ; PC67.2 v1(57.81,37.53) ; v3(167.5,67.2) 167.4,67.1 C227.2 ; C316.2 v3(17.05,31.18) ; C231.2 187.92,64.85 188.85,65.78 v3(189.15,65.78) ; v3(137.19,170.88) 136.86,170.88 136.85,170.87 136.85,170.87 136.48,170.5 136.48,170.5 136.46,170.49 C18.2 ; Q33.1 111.17,72.83 111.28,72.94 111.87,72.94 v3(112.05,72.76) ; C212.2 194.37,91.61 v3(194.37,91.62) ; v3(186.03,174.36) 186.29,174.11 PC3.1 ; v3(163.76,179.62) 163.34,180.04 C723.1 ; C296.2 v3(114.79,37.28) ; L12.1 186.82,52.38 v3(186.94,52.5) ; C127.1 v3(25.96,110.64) ; C17.2 163.33,170.18 162.77,169.61 v3(162.54,169.61) 163.17,168.98 C51.2 ; v3(21.19,104.21) 20.82,104.58 C739.1 ; v3(125.63,132.19) PQ46.1 ; PC147.1 156.51,137.35 156.77,137.61 v3(156.77,137.86) ; v3(35.21,55.77) 35.21,55.77 35.21,56.97 PQ28.1 ; C753.1 v3(135.57,27.48) ; C734.2 v3(183.59,181.19) ; D5.2 14.77,61.55 v3(14.76,61.54) ; PC40.1 v3(48.14,61.56) ; v3(178.12,76.3) 178.47,75.95 C220.2 ; v3(158.08,165.77) 158.07,165.78 C64.2 ; Q5.1 169.8,169.77 v3(170.29,170.25) ; v3(162.82,185.31) 162.41,185.72 PQ8.1 ; v3(142.04,186.05) 141.06,187.03 C736.2 ; v3(31,49.61) 31,49.61 30.51,50.1 PC105.1 ; C334.1 v3(115.77,15.17) ; R272.2 v3(17.78,68.62) ; C159.1 173.86,103.53 v3(174.2,103.87) ; R27.1 v3(107.72,160.97) ; C214.1 31.7,85.31 31.17,85.84 v3(30.55,85.84) ; PQ4.1 178.52,176.85 178.77,176.6 v3(178.79,176.6) ; PQ31.1 35.08,52.9 35.23,53.05 v3(35.23,54.04) ; PQ3.4 195.55,170.21 v3(194.79,169.45) ; C228.2 169.87,66.17 R282.2 169.87,66.95 v3(169.83,66.99) ; C725.1 57.91,109.49 v3(57.35,110.05) ; Q42.1 16.83,58.2 R296.1 v3(14.51,58.2) ; C749.1 v3(42.54,83.91) ; v3(184.74,189.5) 184.38,189.86 PC27.2 PC26.2 ; PU2.2 v3(189.84,190.67) ; U10.2 32.26,74.45 v3(32.03,74.23) ; PQ30.1 v3(27.48,53.74) ; R364.2 35.46,20.72 v3(35.01,20.27) ; v3(118.48,102.94) 118.11,102.94 117.62,103.43 R126.1 ; C284.2 192.48,44.08 v3(192.48,43.52) ; v3(188.39,46.12) 188.39,45.28 C282.2 ; C743.1 v3(91.03,26.36) ; C731.1 182.2,171.2 v3(182.13,171.27) ; PC48.1 v3(38.46,70.6) ; C716.1 v3(175.09,169.97) ; R244.2 v3(171.79,78) ; v3(139.19,142.36) 139.2,142.36 C100.2 ; 168.05,171.52 v3(168.99,171.52) ; C745.1 v3(135.57,31.03) ; PQ45.1 v3(121.82,132.18) ; v3(161.24,149.32) 161.85,149.32 162.14,149.03 PR207.2 ; PC44.2 52.28,68.88 v3(52.28,67.86) ; PR150.2 28.09,49.49 v3(27.46,48.86) 27.06,48.86 26.7,49.22 PR152.2 ; C176.2 147.37,100.78 v3(147.37,102.39) ; Q7.1 v3(167.24,158.23) ; C719.1 146.11,184.02 v3(144.88,182.78) ; HOLE8.4 HOLE8.1 ; PQ49.1 156.27,144.09 v3(156.06,144.29) ; PC32.1 v3(48.14,60.22) ; Q20.1 v3(197.97,92.83) ; v3(139.12,143.07) 138.77,143.07 C95.1 ; v1(180.93,122.75) 180.72,122.95 PC54.1 ; PR201.2 v3(118.96,134.81)
  BOTTOM w0.102: v3(135.06,150.61) 135.34,150.89 136.79,150.89 U19.AC26
  BOTTOM w0.127: R42.2 112.88,150.06
  BOTTOM w0.203: U24.P43 165.78,112.86 v3(165.45,112.53) ; v3(148.76,167.04) 148.76,167.6 149.17,168.01 U19.B11 ; v3(151.26,147.34) 151.66,147.73 151.66,148.43 U19.AF8 ; v3(166.77,101.71) 166.6,101.88 U24.M17 ; v3(130.38,114.88) 130.18,114.67 129.41,114.67 U27.A33 ; U24.R2 165.45,96.16 166.12,96.83 166.13,96.83 166.13,96.84 166.34,96.84 166.42,96.91 ; v3(151.2,167.04) 151.2,167.05 151.2,167.63 151.65,168.08 U19.B8 ; U24.N12 166.23,100.11 v3(165.98,99.85) 165.77,100.06 U24.R12 ; U24.AF38 160.83,110.54 160.04,110.54 U24.AJ38 ; v3(52.78,27.02) 52.78,27.53 v3(53.46,28.2) 53.86,28.6 PU5.4 ; U24.AV7 U24.AV6
  BOTTOM w0.229: U24.AY15 154.8,101.19 154.21,101.19 U24.BC16
  BOTTOM w0.254: v3(154.2,109.33) U24.BD35 ; CN17.23 v3(184.68,10.34) ; v3(112.65,183.58) CN2.15 110.36,183.58 110.1,183.32 110.1,182.37 110.39,182.08 CN2.18 ; CN2.28 v3(112.12,177.08) 112.12,177.36 111.89,177.59 111.89,178.83 111.64,179.08 CN2.24 ; U24.K20 167.79,102.9 v3(167.59,102.7) 167.89,102.7 168.39,102.2 U24.H17 ; U24.U28 164.56,106.34 164.16,105.94 v3(163.68,105.94) ; U24.AD40 161.9,112.23 v3(162.2,112.53) U24.AC44 ; U24.P26 165.99,105.61 v3(165.66,105.94) 165.66,106.01 U24.P28 U24.P30 ; 163.35,104.72 163.05,104.42 163.05,104.34 v3(163.02,104.31) 162.69,103.98 U24.AA22 ; v3(156.19,151.32) 156.59,150.92 U19.AC2 ; U24.Y8 163.49,98.32 163.25,98.56 v3(163,98.56) 162.9,98.56 162.61,98.27 U24.AB8 ; v3(169.88,164.31) 169.89,164.29 U18.3 ; U24.AL38 158.92,110.64 158.62,110.34 v3(158.41,110.34) 158.29,110.34 U24.AN36 ; v3(161.04,105.94) 160.71,105.61 U24.AG26 ; v3(161.04,105.94) 160.71,106.27 U24.AG28 ; v3(161.04,105.94) 161.37,106.27 U24.AE28 ; v3(187.3,23.67) 186.86,24.11 CN13.4 ; v3(170.14,99.75) 170.31,99.57 U24.B11 ; VRAM2.E8 118.75,145.24 v3(118.34,144.83) ; v3(110.01,186.25) 110.34,186.58 CN2.9 ; U24.AV24 156.02,104.79 156.31,105.09 v3(156.31,105.24) 156.31,105.38 156.62,105.68 156.62,105.8 156.31,106.1 v3(156.31,106.23) ; U24.U42 164.64,112.45 ; 164.64,112.45 U24.V43 164.16,112.86 v3(163.83,112.53) U24.W44 ; 164.64,112.45 164.64,112.67 164.83,112.86 U24.T43 165.13,112.86 v3(165.45,112.53) U24.R44 ; VRAM3.G8 v3(118.35,169.14) VRAM1.G1 ; U24.H13 168.39,100.27 168.09,100.57 v3(168.09,100.7) 168.09,100.91 U24.K15 ; U24.BD15 153.39,101.2 U24.BC16 ; v3(119.17,148.86) 119.17,148.87 VRAM2.J8 ; U24.AJ24 160.05,104.71 160.38,104.38 v3(160.38,104.31) 160.38,104.24 160.05,103.91 U24.AJ22 ; v3(158.48,97.5) 158.48,97.72 157.99,98.21 U24.AN8 ; CN13.1 185.36,25.31 184.94,25.72 v3(184.41,25.72) ; v3(113.2,179.56) 112.17,180.58 CN2.21 ; v3(94.93,116.15) 94.87,116.15 U27.AT34 ; CN17.19 184.94,12.34 185.07,12.46 185.76,12.46 v3(185.94,12.29) ; U24.N39 166.69,111.5 v3(166.91,111.5) 167.18,111.23 U24.K39 ; v3(163.68,105.94) 164.01,105.61 U24.V26 ; v3(163.68,105.94) 163.68,106.01 163.21,106.48 162.83,106.48 U24.AA28 162.68,106.34 162.36,106.02 v3(162.36,105.94) ; v3(136.07,158.38) 136.11,158.34 U19.P26 ; v3(168.48,110.72) 168.89,110.72 U24.G38 ; v3(185.94,10.85) 185.93,10.84 CN17.22 ; U27.AG11 103.4,92.52 v3(103.9,92.02) ; v3(145.18,18.6) CN16.3 ; v3(161.48,110.34) 161.18,110.64 U24.AF38 ; VRAM1.E2 v3(118.35,171.54) VRAM3.D8 ; v3(156.31,102.66) 156.31,102.66 156.31,102.8 156.62,103.1 U24.AT20 ; U19.U26 136.76,155.89 v3(136.2,155.89) ; U24.AD8 161.9,98.25 161.53,97.88 161.41,97.88 161.38,97.91 ; v3(163.76,96.5) 163.96,96.5 164.46,97 U24.U6 ; v3(163.76,96.5) 163.04,96.5 U24.AA4 ; v3(163.76,96.5) 163.83,96.43 U24.W2 ; U24.B35 170.34,109.33 v3(170.14,109.12) 170.09,109.12 169.64,108.67 U24.F33 169.58,108.6 169.82,108.37 169.82,108.29 170.4,107.7 U24.B31 ; v3(156.37,100.73) 156.37,100.94 156.62,101.19 U24.AT15 156.65,101.24 156.65,102.16 U24.AT17 ; v3(185.14,9.84) 185.1,9.8 184.54,9.8 184.49,9.84 CN17.24 ; U24.H7 168.4,97.69 168.4,98.08 v3(168.48,98.17) 168.6,98.28 U24.G8 ; v3(143.72,18.51) 143.68,18.48 CN16.6 ; v3(156.29,103.68) 156.29,103.9 156.04,104.15 U24.AV22 ; U24.D4 170.1,96.44 169.69,96.44 v3(169.61,96.36) ; 161.38,97.91 v3(161.41,97.91) ; 161.38,97.91 161.24,97.91 160.92,98.23 U24.AF8 ; v3(168.51,96.53) 168.51,96.52 168.7,96.32 168.7,96.21 168.71,96.21 168.71,96.01 168.76,95.95 U24.G2 ; CN2.12 112.18,185.08 v3(112.19,185.08) ; CN2.3 109.33,189.58 v3(109.25,189.5) ; U24.AY20 154.47,103.17 154.28,102.98 v3(154.28,102.68) 154.25,102.68 154.1,102.82 U24.BD19 ; U24.AY10 154.48,99.26 154.24,99.49 v3(154.24,99.68) 154.13,99.57 U24.BD11 ; U19.B23 139.09,168.39 139.09,168.62 139.09,169.41 v3(138.97,169.54) ; v3(94.89,103.18) U27.AT21 ; U24.AD6 161.9,96.67 v3(162.2,96.37) U24.AC2 ; U24.AY7 154.27,97.67 v3(154.27,98.05) 154.16,97.95 U24.BD7 ; U19.U23 139.19,155.9 v3(138.82,156.27) ; U27.AT27 94.14,108.69 v3(93.8,109.03) ; CN17.13 184.96,15.34 v3(185.24,15.05) ; v3(110.93,107.15) U27.W25 ; v3(158.08,165.77) 158,165.69 156.69,165.69 U19.E2 ; v3(168.63,112.45) 168.6,112.45 168.56,112.4 168.56,112.01 U24.H40 ; 170.86,113.16 170.4,113.62 U24.C45 ; v3(157.33,96.37) U24.AR2 ; U24.AV6 156.02,97.06 156.02,96.62 155.97,96.57 v3(155.97,96.53) 155.7,96.27 U24.AW2 ; R574.2 162.85,88.93 162.97,88.8 v3(162.97,88.8) ; U28.3 193.84,98.86 v3(194.06,99.08) ; v3(158.66,112.27) 158.77,112.27 U24.AK43 U24.AK45 159.36,114.14 v3(159.55,114.33) ; U24.AY15 155.27,101.66 v3(155.27,101.7) ; v3(162.97,110.91) 162.79,110.91 U24.AB38 ; U24.U10 164.49,98.86 164.79,98.57 v3(165,98.57) 165.19,98.57 165.44,98.32 U24.R8 ; U24.AJ6 159.94,97 v3(160.58,96.37) U24.AG2 ; U24.AJ20 160.05,103.02 v3(159.72,102.69) 160.05,102.35 U24.AJ18 ; v3(181.92,17.32) 182.4,16.84 CN17.10 ; CN17.16 184,13.84 184.41,14.24 v3(184.41,14.37) ; U27.AF11 104.4,93.12 v3(104.23,93.28) ; v3(170.29,111.82) 170.19,111.92 U24.D42 ; U24.AT43 156.92,112.76 v3(157.39,112.3) 157.39,112.51 U24.AP43 157.84,112.75 158.14,112.45 U24.AN42 157.99,112.28 157.99,111.84 U24.AN40 ; v3(154.56,183.51) 154.56,183.1 154.7,182.96 PQ6.1 ; U24.AV31 156.02,107.71 156.31,108.01 v3(156.31,108.18) 156.31,108.35 156.02,108.64 U24.AV33 156.02,108.69 155.66,109.05 155.66,109.15 v3(155.72,109.21) ; U24.B7 170.95,97.89 170.34,97.89 170.16,98.07 v3(170.16,98.07) ; U24.B39 170.33,110.95 v3(170.13,110.75) ; v3(158.95,96.37) U24.AL2 ; v3(167.39,151.1) 167.7,151.1 168.06,151.45 U20.3 ; U24.H10 168.28,99.14 167.68,99.14 U24.K10 167.16,98.62 167.08,98.54 v3(166.89,98.54) 166.77,98.54 166.45,98.86 U24.N10 ; PC13.2 151.9,182.42 v3(152.12,182.19) 152.65,181.66 PQ6.4 ; PC10.1 163.71,184.68 v3(164.39,185.36) ; U24.AA20 162.68,103.09 162.36,102.77 v3(162.36,102.69) 162.36,102.61 U24.AD18 ; v3(124.99,53.13) 124.75,52.9 JDIM1.162 ; U19.P23 v3(139.61,157.92) ; U24.F15 v3(170.27,101.21) 170.28,101.2 U24.B15 ; U24.AJ8 159.59,97.91 v3(159.42,97.91) 159.1,98.27 U24.AL8 ; v3(156.26,98.75) 156.26,98.88 156.62,99.23 U24.AT10 156.62,99.55 156.02,100.15 U24.AV13 ; v3(170.04,104.45) U24.B23 ; VRAM2.B1 124.86,142.34 v3(124.86,142.2) 124.5,142.2 VRAM4.A9 ; 170.91,113.12 171.38,112.65 ; R443.1 v3(127.02,148.64) ; v3(108.93,107.15) U27.AA25 ; v3(167.08,112.53) U24.L44 ; v3(123.96,148.03) VRAM2.J2
  BOTTOM w0.279: v3(102.93,115.15) U27.AG33 ; U27.AF6 v3(103.93,87.16) ; U24.L2 167.08,96.37 v3(166.91,96.55) 166.78,96.55 166.42,96.91 U24.N6 ; U27.AD7 v3(105.93,88.16) ; U27.AK34 100.35,115.69 v3(99.83,116.21) ; U27.L6 v3(119.93,87.16) ; U27.AE9 v3(104.93,91.16) ; v3(99.93,112.15) U27.AK30 ; v3(107.93,88.16) U27.AB6 ; v3(97.91,114.22) 98.4,113.74 U27.AM32 ; U27.AR28 95.4,109.74 v3(94.93,110.21) ; v3(102.93,113.15) U27.AG31 ; v3(104.93,107.15) U27.AE25 ; v3(104.91,92.02) 105.24,91.69 U27.AE10 ; v3(99.93,108.15) U27.AK26 ; v3(104.93,109.15) U27.AE27 ; v3(108.93,113.15) U27.AA31 ; v3(99.93,111.15) U27.AK29 ; v3(102.93,117.15) U27.AG35 ; v3(104.93,111.15) U27.AE29 ; v3(104.93,113.15) U27.AE31 ; v3(94.84,107.07) 95.22,106.69 U27.AR25 ; U27.AC31 v3(106.93,113.15) ; U27.AC29 v3(106.93,111.15) ; U27.AC33 v3(106.93,115.15) ; v3(96.93,103.15) U27.AN21 ; v3(108.93,111.15) U27.AA29 ; U27.AE7 v3(104.93,89.16) ; v3(158.66,112.27) 158.29,112.27 U24.AN42 ; v3(108.93,109.15) U27.AA27 ; U27.AC27 v3(106.93,109.15) ; U27.AE6 v3(104.93,88.16) ; U27.AN27 v3(96.86,109.23) ; v3(104.93,117.15) U27.AE35 ; U27.AR31 95.4,112.62 v3(94.88,112.11) ; v3(93.8,105.69) 93.81,105.69 U27.AT24 ; v3(95.86,103.22) 95.86,103.23 U27.AR22 ; v3(108.93,117.15) U27.AA35 ; v3(99.93,107.15) U27.AK25 ; U27.AN34 v3(96.93,116.15) ; v3(98.93,103.15) U27.AL21 ; U24.AA4 162.31,96.47 v3(162.2,96.37) ; v3(98.93,105.15) U27.AL23 ; U27.K8 v3(120.93,90.16) ; v3(107.93,89.16) U27.AB7 ; v3(101.93,89.16) U27.AH7 ; v3(108.93,115.15) U27.AA33 ; U24.AG44 v3(160.58,112.53) ; v3(102.93,109.15) U27.AG27 ; v3(101.93,90.16) U27.AH8 ; v3(102.93,107.15) U27.AG25 ; v3(102.93,111.15) U27.AG29 ; v3(98.93,102.15) U27.AL20 ; v3(94.93,116.15) U27.AR34 ; U27.M6 v3(118.93,87.16) ; v3(106.93,107.15) U27.AC25 ; v3(104.93,115.15) U27.AE33 ; v3(96.93,106.15) U27.AN24 ; U24.G44 168.71,112.53 v3(168.63,112.45) 168.78,112.45 U24.F43 ; U27.AF8 v3(103.93,89.16) ; v3(99.93,110.15) U27.AK28 ; U27.AC35 v3(106.93,117.15)
  BOTTOM w0.305: v3(94.93,94.16) 95.4,94.62 U27.AR13 ; v3(165.41,121.79) 165.64,121.55 R466.1 ; v3(123.93,84.16) 123.46,83.69 U27.G2 ; U27.K10 120.46,91.69 v3(120.93,92.16) ; U27.D27 126.4,108.74 v3(126.9,109.24) ; C414.1 v3(164.5,119.56) ; U27.G4 123.46,85.69 v3(123.93,86.16) ; v3(116.99,152.56) 117.84,152.56 VRAM2.P9 ; v3(102.93,87.16) 103.4,87.62 U27.AG6 ; v3(125.93,89.16) 125.46,88.69 U27.E7 ; U27.A10 129.46,91.69 v3(129.93,92.16) ; v3(137.19,165.37) 137.59,165.77 U19.E25 ; U27.AK11 100.4,92.62 v3(99.93,92.16) ; VRAM1.M9 124.69,165.2 v3(124.87,165.2) ; U27.C13 127.46,94.69 v3(127.93,95.16) ; v3(97.93,88.16) 98.4,88.62 U27.AM7 ; VRAM1.G9 v3(123.95,169.14) ; v3(129.93,113.15) 129.46,112.69 U27.A31 ; v3(129.93,98.15) 129.46,97.69 U27.A16 ; v3(96.93,91.16) 97.4,91.62 U27.AN10 ; U27.F6 124.46,87.69 v3(124.93,88.16) ; U27.AL6 v3(98.93,88.16) ; v3(123.93,100.15) U27.F18 ; U27.T3 v3(114.93,84.16) ; v3(124.9,114.19) U27.F32 ; v3(110.93,117.15) U27.W35 ; U24.BE41 v3(152.32,112.05) ; U27.D16 126.46,97.69 v3(126.93,98.15) ; VRAM1.P9 124.87,163.94 v3(124.95,163.87) ; C416.1 166.91,119.46 v3(166.78,119.59) ; VRAM4.G8 v3(123.95,146.45) VRAM4.F9 ; U19.U5 154.19,155.87 v3(154.6,156.28) ; v3(125.93,83.16) 125.46,82.69 U27.E1 ; U27.C7 127.46,88.69 v3(127.93,89.16) ; U27.K33 v3(120.9,115.19) ; U27.J26 v3(120.93,108.15) ; v3(124.93,99.15) 124.46,98.69 U27.F17 ; U27.AP4 96.4,85.62 v3(95.93,85.16) ; v3(125.93,92.16) 125.46,91.69 U27.E10 ; C413.1 163.28,118.99 v3(163.28,119.56) ; v3(123.93,93.16) 123.46,92.69 U27.G11 ; U19.B20 141.73,168.86 v3(141.72,168.87) ; VRAM3.B3 v3(122.35,173.94) ; U19.AF17 143.83,148.07 v3(143.81,148.07) ; v3(128.93,98.15) 128.46,97.69 U27.B16 ; U27.AL17 v3(98.93,99.15) ; U27.AL4 99.4,85.62 v3(98.93,85.16) ; U27.D35 126.46,116.69 v3(126.93,117.15) ; v3(98.93,97.16) U27.AL15 ; v3(98.93,84.16) 99.4,84.62 U27.AL3 ; R465.1 164.32,121.25 v3(164.32,121.77) ; v3(148.75,165.42) U19.E11 ; U27.D22 v3(126.93,103.15) ; v3(143.79,166.24) 144.19,165.84 U19.E17 ; U27.A4 129.46,85.69 v3(129.93,86.16) ; v3(93.93,84.16) 94.4,84.62 U27.AT3 ; U27.N4 v3(117.93,85.16) ; v3(117.34,146.78) 117.41,146.85 VRAM2.G9 ; R606.2 174.41,86.89 174.41,86.31 v3(174.35,86.25) ; v3(97.93,94.16) 98.4,94.62 U27.AM13 ; v3(126.87,110.05) 126.39,110.53 126.39,110.69 U27.D29 ; v3(139.62,160.46) 139.25,160.82 U19.L23 ; v3(124.93,94.16) 124.46,93.69 U27.F12 ; VRAM4.B3 120.09,142.31 v3(120.09,142.19) ; v3(141.33,165.46) 141.71,165.84 U19.E20 ; VRAM2.T1 124.88,154.05 124.94,154.11 v3(124.94,154.16) ; C418.2 159.64,118.23 159.64,118.94 v3(159.9,119.2) ; v3(165.13,86.25) 165.13,86.26 R601.2 ; U27.AL1 99.4,82.62 v3(98.93,82.16) ; U27.M26 v3(117.93,108.15) ; v3(137.19,160.4) 137.59,160.8 U19.L25 ; v3(144.21,168.82) U19.B17 ; v3(124.93,91.16) 124.46,90.69 U27.F9 ; v3(97.87,112.21) 97.4,111.74 U27.AN30 ; v3(15.4,101.54) 15.41,101.55 U25.1 15.41,103.03 16.33,103.95 C437.1 ; U27.A25 v3(129.97,107.26) ; v3(163.02,121.62) 163.36,121.29 R464.1 ; v3(102.93,89.16) 102.46,88.69 U27.AH7 ; v3(124.93,102.15) U27.F21 ; U27.AR4 95.4,85.62 v3(94.93,85.16) ; v3(127.9,114.13) 127.45,113.69 U27.C32 ; v3(113.77,117.32) U27.T35 U27.R34 ; U27.N10 v3(117.93,91.16) ; C417.2 v3(154.46,118.93) ; v3(121.07,93.2) 121.07,93.2 121.07,93.01 U27.J11 121.46,92.69 v3(121.93,93.16) ; U27.AM32 98.9,114.19 99.89,114.19 U27.AK32 ; U27.C16 127.46,97.69 v3(127.93,98.15) ; U27.G33 123.4,114.74 v3(123.95,115.29) ; U27.N7 v3(117.93,88.16) ; R592.1 148.68,86.82 v3(148.68,86.22) ; v3(123.86,111.2) 123.4,110.74 U27.G29 ; U27.F24 124.4,105.62 v3(123.93,105.15) ; U27.C30 v3(127.9,112.19) ; U27.AM23 v3(97.93,105.15) ; v3(93.93,97.16) 94.4,97.62 U27.AT16 ; U27.AP1 96.31,82.69 v3(95.77,82.14) ; v3(123.93,85.16) 123.46,84.69 U27.G3 ; v3(111.93,86.16) 111.87,86.16 U27.W4 ; v3(128.93,89.16) 128.46,88.69 U27.B7 ; v3(111.93,85.16) 111.87,85.16 U27.W3 ; v3(127.93,101.15) 127.46,100.69 U27.C19 ; v3(147.1,165.42) 146.69,165.83 U19.E14 146.69,165.84 v3(147.09,166.24) ; VRAM2.P1 v3(124.88,152.45) ; v3(107.93,82.16) 108.4,82.62 U27.AB1 ; U27.AT32 94.4,113.84 v3(94.86,114.3) 94.47,114.69 U27.AT33 ; U27.N6 v3(117.93,87.16) ; v3(93.93,91.16) 94.4,91.62 U27.AT10 ; U27.N33 117.4,114.79 v3(117.03,115.15) ; VRAM3.A9 117.85,174.34 v3(117.49,173.98) 117.93,173.54 VRAM1.B1 ; U27.F23 123.93,104.22 v3(123.93,104.15) ; U27.K31 v3(120.9,113.19) ; v3(117.35,154.05) VRAM2.T9 ; v3(137.19,153.8) 136.79,153.4 U19.Y26 ; U27.AN16 97.4,97.62 v3(96.93,97.16) ; v3(124.93,96.16) 124.46,95.69 U27.F14 ; v3(97.93,85.16) 98.4,85.62 U27.AM4 ; v3(129.93,95.16) 129.46,94.69 U27.A13 ; U19.AD13 147.54,150.04 v3(147.93,149.65) 148.32,150.04 U19.AD12 ; v3(146.27,151.26) U19.AB14 ; U27.C4 127.46,85.69 v3(127.93,86.16) ; v3(117.36,163.92) 117.93,163.92 VRAM1.P1 ; v3(125.93,98.15) 125.46,97.69 U27.E16 ; U27.F30 v3(124.9,112.19) ; U27.T6 v3(114.93,87.16) ; C409.1 171.12,121.17 v3(170.54,121.75) ; U27.F4 124.46,85.69 v3(124.93,86.16) ; VRAM4.E1 117.41,145.25 v3(116.99,144.82) 117.36,144.45 VRAM4.D1 ; U27.E19 125.41,100.69 v3(125.88,101.15) ; v3(124.93,108.15) 124.46,107.69 U27.F26 ; v3(95.93,94.16) 96.4,94.62 U27.AP13 ; U27.L11 119.4,92.51 v3(118.92,92.04) 118.4,92.56 U27.M11 ; U22.1 15.03,107.12 15.24,107.34 16.2,107.34 C429.1 ; v3(123.93,117.15) 123.46,116.69 U27.G35 ; v3(165.64,119.54) 165.51,119.41 C415.1 ; v3(128.93,86.16) 128.46,85.69 U27.B4 ; v3(96.93,85.16) 97.4,85.62 U27.AN4 ; U19.E22 139.67,166.26 v3(139.63,166.26) ; v3(99.82,121.1) 99.82,121.83 R461.1 ; v3(164.16,152.29) 164.16,151.66 164.42,151.4 165.13,151.4 165.35,151.62 U21.3 ; U27.M30 v3(118.9,112.19) ; v3(126.93,104.08) 127.32,103.69 U27.C22 ; U27.M32 v3(118.9,114.19) ; U27.AP27 96.31,108.69 v3(95.8,109.2) ; v3(120.89,117.3) 120.89,117.17 U27.K35 ; U27.P26 116.4,107.69 v3(115.93,108.16) ; VRAM1.M1 117.36,165.54 v3(117.29,165.61) ; v3(95.93,97.16) 96.4,97.62 U27.AP16 ; v3(117.93,84.16) U27.N3 ; U25.3 14.11,101.51 v3(14.15,101.47) ; U27.E4 125.46,85.69 v3(125.93,86.16) ; v3(162.07,82.12) 162.07,82.33 R634.2 ; VRAM4.D8 v3(123.15,144.85) VRAM2.E2 ; U27.B22 128.32,103.69 v3(127.93,104.08) ; U27.J30 v3(121.9,112.19) ; U27.B2 128.46,83.69 v3(128.93,84.16) ; U27.AM24 v3(97.93,106.15) ; v3(97.83,83.27) 97.42,83.69 U27.AN2 ; U27.J32 v3(121.9,114.19) ; v3(115.9,112.18) 115.4,111.69 U27.R30 ; v3(104.93,86.16) U27.AE4 ; VRAM2.M1 125.01,150.85 v3(125.09,150.77) ; U27.N5 v3(117.93,86.16) ; v3(113.85,115.14) 114.3,114.69 U27.T33 ; U27.F10 124.46,91.69 v3(124.93,92.16) ; v3(93.93,94.16) 94.4,94.62 U27.AT13 ; U19.P5 154.19,158.36 v3(154.59,158.76) ; U27.C1 127.46,82.69 v3(127.93,83.16) ; v3(94.88,112.11) 94.46,111.69 U27.AT30 ; v3(128.93,95.16) 128.46,94.69 U27.B13 ; v3(98.93,94.16) U27.AL12 ; v3(100.93,92.16) 101.4,92.62 U27.AJ11 ; v3(97.93,97.16) 98.4,97.62 U27.AM16 ; U27.C2 127.46,83.69 v3(127.93,84.16) ; U27.AL24 v3(98.93,106.15) ; v3(127.93,92.16) 127.46,91.69 U27.C10 ; v3(149.61,149.67) 149.17,149.24 U19.AE11 149.28,149.14 149.28,148.55 U19.AF11 ; v3(98.93,93.16) U27.AL11 ; U27.AT7 94.4,88.62 v3(93.93,88.16) ; U27.F28 v3(124.9,110.19) ; v3(98.93,83.16) 99.4,83.62 U27.AL2 ; U27.C34 v3(127.9,116.19) ; U27.AL10 v3(98.93,92.16) ; U27.F20 v3(123.93,102.15) ; U27.K29 v3(120.9,111.19) ; v3(95.93,91.16) 96.4,91.62 U27.AP10 ; v3(128.91,117.11) 128.91,116.37 128.4,115.86 U27.B34 ; v3(124.93,97.16) 124.46,96.69 U27.F15 ; U27.J6 121.4,87.62 v3(120.93,87.16) ; U27.AH6 v3(101.93,88.16) ; v3(115.94,86.13) 115.4,86.67 U27.R5 ; U27.K4 v3(120.93,85.16) ; v3(97.93,100.15) 98.4,100.62 U27.AM19 ; U27.H6 v3(121.93,88.16) ; U22.3 13.73,105.77 v3(13.51,105.56) ; U27.AL7 v3(98.93,89.16) ; U27.AH9 v3(101.93,91.16) ; U27.F34 v3(124.9,116.19) ; U27.D4 126.46,85.69 v3(126.93,86.16) ; U27.E22 v3(124.93,104.15) ; U27.K9 120.46,90.69 v3(120.93,91.16) ; v3(111.93,116.15) U27.V34 ; U27.AT19 94.4,100.62 v3(93.93,100.15) ; v3(95.93,100.15) 96.4,100.62 U27.AP19 ; VRAM1.E8 v3(123.15,171.54) ; U27.W1 111.87,83.16 v3(111.93,83.16) ; U27.AR10 95.4,91.62 v3(94.93,91.16) ; v3(122.93,87.16) U27.G5 ; v3(114.86,111.14) 114.41,110.69 U27.T29 ; v3(104.93,85.16) U27.AE3 ; v3(119.15,167.54) 118.75,167.94 VRAM1.J2 ; U27.D10 126.46,91.69 v3(126.93,92.16) ; U27.AL18 v3(98.93,100.15) 99.4,100.62 U27.AL19 ; v3(146.76,169.03) 146.69,168.96 U19.B14 ; U27.T4 v3(114.93,85.16) ; U27.T1 v3(114.93,82.16) ; v3(101.93,84.16) U27.AH2 ; v3(143.79,151.26) U19.AB17 ; v3(126.9,113.14) 126.45,112.69 U27.D31 ; U27.N9 v3(117.93,90.16) ; U27.P5 v3(116.93,86.16) ; U27.J28 v3(121.9,109.19) ; v3(111.93,114.15) U27.V32 ; U27.AM22 v3(97.93,104.15) ; U27.AH4 v3(101.93,86.16) ; v3(128.93,101.15) 128.46,100.69 U27.B19 ; U27.K5 v3(120.93,86.16) ; U27.D33 v3(126.9,115.19) ; U19.AE14 146.66,149.24 v3(146.28,148.86) 146.69,148.45 U19.AF14 ; U27.AJ5 101.4,86.62 v3(100.93,86.16) ; U27.F11 124.46,92.69 v3(124.93,93.16) ; U27.G31 v3(123.92,113.21) ; v3(96.93,100.15) 97.4,100.62 U27.AN19 ; U27.AR7 95.4,88.62 v3(94.93,88.16) ; VRAM3.F9 117.93,170.33 117.44,170.33 117.37,170.25 v3(117.34,170.25) ; v3(151.86,121.32) 152.94,122.41 C408.2 ; v3(117.24,150.62) 117.32,150.62 117.55,150.85 VRAM2.M9 ; U27.AM10 98.4,91.62 v3(97.93,91.16) ; U27.F7 124.46,88.69 v3(124.93,89.16) ; v3(118.93,116.15) 118.46,115.69 U27.M34 ; U27.C28 v3(127.9,110.19) ; U27.N29 v3(116.93,111.15) ; U27.D19 125.9,100.18 v3(125.9,100.18) ; v3(120.93,89.16) 120.46,88.69 U27.K7 ; U27.A22 129.35,103.69 v3(128.93,104.1) ; v3(156.19,158.76) 156.59,158.36 U19.P2 ; U27.AN7 97.4,88.62 v3(96.93,88.16) ; v3(139.64,153) 139.57,153 U19.Y23 ; U27.AT4 94.4,85.62 v3(93.93,85.16) ; v3(96.93,116.15) U27.AP35 ; U27.E13 125.46,94.69 v3(125.93,95.16) ; v3(120.93,84.16) U27.K3 ; v3(122.93,92.16) 122.46,91.69 U27.H10 ; v3(95.9,107) 95.4,107.5 U27.AR26 ; U27.D7 126.46,88.69 v3(126.93,89.16) ; v3(156.95,147.01) 156.59,147.37 U19.AG2 U19.AF1 ; U27.AH10 v3(101.93,92.16) ; VRAM1.T9 124.63,162.63 v3(124.94,162.63) ; U27.H7 122.46,88.69 v3(122.93,89.16) ; v3(117.34,162.34) VRAM1.T1 ; U27.AH3 v3(101.93,85.16) ; U27.AL9 v3(98.93,91.16) ; U27.AL5 v3(98.93,87.16) ; v3(94.93,97.16) 95.4,97.62 U27.AR16 ; U27.N31 v3(116.93,113.15) ; v3(104.93,83.16) U27.AE1 ; VRAM2.G1 124.39,146.85 v3(124.78,146.46) ; U27.AR19 95.4,100.62 v3(94.93,100.15) ; U27.T7 v3(114.93,88.16) ; U27.R32 115.88,113.21 v3(115.88,113.2) ; U27.H26 v3(121.93,108.15) ; U19.U2 156.59,155.89 v3(156.19,156.29) ; U27.AN13 97.4,94.62 v3(96.93,94.16) ; v3(113.88,91.19) 113.88,91.19 114.37,91.69 U27.T10 ; v3(95.93,88.16) 96.4,88.62 U27.AP7 ; U27.N2 v3(117.93,83.16) ; v3(124.93,173.6) 124.87,173.54 VRAM1.B9 ; U27.B10 128.46,91.69 v3(128.93,92.16) ; v3(124.93,90.16) 124.46,89.69 U27.F8 ; U27.A7 129.46,88.69 v3(129.93,89.16) ; U27.AL22 v3(98.93,104.15) ; U27.K1 v3(120.93,82.16) ; v3(142.15,151.26) U19.AB20 ; U27.AK5 100.4,86.62 v3(99.93,86.16) ; U27.A19 129.46,100.69 v3(129.93,101.15) ; VRAM1.J8 v3(123.15,167.54) ; U27.AM21 v3(97.93,103.15) ; U27.K2 v3(120.93,83.16) ; U27.N1 v3(117.93,82.16) ; U27.AH5 v3(101.93,87.16) ; v3(97.93,102.15) U27.AM20 ; U27.V30 v3(112.9,111.19) ; VRAM3.D1 124.7,171.59 125.11,171.59 v3(125.2,171.49) ; C412.2 v3(152.94,119.73) ; v3(97.93,107.15) U27.AM25 ; U27.R28 v3(114.9,109.19) ; U27.AL8 v3(98.93,90.16) ; U27.R26 115.4,107.69 v3(114.93,108.16) ; v3(98.93,96.16) U27.AL14 ; U27.G1 v3(123.93,82.16) ; U27.L26 v3(118.93,108.15) ; U27.J34 v3(121.9,116.19) ; v3(126.93,95.16) 126.46,94.69 U27.D13 ; v3(112.93,109.15) U27.U27 ; v3(101.93,83.16) U27.AH1 ; U27.T9 v3(114.93,90.16) ; U27.G27 v3(123.9,109.19) ; U27.AR2 95.4,83.66 v3(94.89,83.16) ; U27.M28 v3(118.9,110.19) ; U27.V28 v3(111.9,109.18) ; v3(113.93,113.15) U27.T31
  BOTTOM w0.33: VRAM3.E1 124.85,171.14 v3(125.2,171.49)
  BOTTOM w0.356: v3(134.9,41.19) 134.95,41.14 JDIM2.196 ; v3(84.01,57.84) 84.85,58.68 JDIM1.37 ; v3(89.44,53.47) 89.95,52.96 JDIM1.54 ; JDIM1.185 131.65,58.69 v3(131.39,58.43) 131.62,58.19 132.06,58.19 132.25,58.39 JDIM1.187 ; v3(129.79,40.3) 129.79,40.14 129.55,39.91 JDIM2.178 ; JDIM2.8 76.15,40.04 75.95,40.23 v3(75.95,41.02) ; v3(108.9,91.99) 108.59,91.69 U27.AB10 ; JDIM2.60 91.75,40.65 v3(91.65,40.76) ; JDIM1.127 114.25,56.89 114.62,56.53 v3(114.95,56.53) ; v3(125.64,58.33) 125.64,58.33 125.86,58.33 126.25,58.72 JDIM1.167 126.25,61.01 126.01,61.25 124.7,61.25 124.45,61 JDIM1.161 ; JDIM1.14 77.95,53.12 77.33,53.75 v3(77.15,53.75) ; JDIM2.139 117.85,45.49 v3(117.8,45.44) ; JDIM1.151 121.45,56.96 121.96,56.46 v3(122.56,56.46) ; JDIM2.162 124.75,39.83 v3(125.13,40.21) ; v3(80.93,58.12) 80.93,58.4 81.25,58.72 JDIM1.25 ; v3(73.97,53.14) 74.35,52.76 JDIM1.2 ; JDIM2.37 84.85,45.58 84.5,45.22 v3(84.5,44.29) ; JDIM1.32 83.35,52.73 82.87,53.21 v3(82.53,53.21) ; JDIM2.155 122.65,45.47 123.39,44.73 v3(123.5,44.73) ; v3(75.88,53.12) 76.15,52.84 JDIM1.8 ; JDIM1.65 93.25,58.09 92.99,57.82 v3(92.52,57.82) ; JDIM2.136 v3(116.95,40.23) 116.57,40.23 116.35,40.02 JDIM2.134 ; v3(110.88,91.16) 111.4,91.68 U27.W10 ; JDIM2.71 95.05,45.47 95.02,45.43 v3(95.02,44.88) ; v3(90.25,40.92) 89.84,40.51 89.84,39.98 89.95,39.87 JDIM2.54 ; JDIM2.153 122.05,49.2 v3(121.97,49.29) 121.45,48.77 JDIM2.151 ; JDIM1.31 83.05,58.59 v3(82.48,58.01) ; JDIM2.25 81.25,44.58 v3(81.3,44.53) ; JDIM1.179 129.85,58.69 v3(129.61,58.45) ; v3(119.77,41.04) 119.54,41.04 119.13,40.64 119.13,40.15 119.35,39.93 JDIM2.144 ; v3(79.16,58.45) 79.45,58.74 JDIM1.19 ; v3(75.87,49.55) 75.87,48.61 76.45,48.03 76.45,47 JDIM2.9 ; v3(92.54,53.82) 92.59,53.82 93.55,52.86 JDIM1.66 ; JDIM1.145 119.65,58.06 v3(119.92,57.8) ; JDIM2.127 114.25,48.71 v3(114.34,48.8) ; JDIM1.196 134.95,52.99 v3(135.34,53.37) ; JDIM1.195 134.65,58.18 134.65,58.18 134.65,57.53 135.24,56.94 v3(135.37,56.94) ; JDIM1.20 79.75,53.07 v3(79.13,53.7) ; JDIM2.150 121.15,40.22 v3(121.17,40.23) ; JDIM1.60 91.75,52.7 90.59,53.86 v3(90.59,54.18) ; JDIM1.72 95.35,52.75 95.78,53.18 v3(96.1,53.18) ; JDIM2.173 128.05,45.74 v3(128.38,45.42) ; JDIM1.71 95.05,58.75 96.1,57.71 v3(96.1,57.68) ; v3(89.77,58.14) 90.25,58.62 JDIM1.55 ; U19.B27 135.65,168.58 135.65,168.92 v3(135.8,169.07) 135.94,169.21 136.62,169.21 U19.A26 ; v3(111.92,92.03) 111.92,92.03 112.4,92.51 U27.V11 ; v3(88.26,40.22) 88.15,40.11 JDIM2.48 ; JDIM1.133 116.05,58.61 116.26,58.4 v3(116.26,57.22) ; JDIM2.19 79.45,45.88 v3(79.17,45.59) ; JDIM1.43 86.65,58.33 86.06,57.73 v3(86.06,57.43) ; JDIM2.145 119.65,45.77 v3(119.16,45.28) ; v3(87.18,44.46) 87.18,44.73 86.65,45.26 JDIM2.43 ; v3(114.84,53.27) 114.55,52.98 JDIM1.128 ; JDIM2.2 74.35,40 74.1,40.25 v3(74.1,40.25) ; JDIM1.139 117.85,58.33 117.62,58.1 117.62,57.68 v3(117.61,57.67) ; v3(128.3,57.81) 128.3,58.47 128.05,58.72 JDIM1.173 ; v3(130.46,45.04) 130.11,45.04 129.85,45.29 JDIM2.179 ; JDIM2.184 131.35,39.99 131.59,40.22 v3(131.59,40.33) ; JDIM1.3 74.65,58.29 74.18,57.81 v3(74,57.81) ; JDIM2.49 88.45,45.5 88.33,45.38 v3(88.33,44.47) ; v3(133.15,53.32) 133.15,53.32 133.15,53.32 133.16,53.32 133.16,53.32 133.16,53.32 133.15,53.31 JDIM1.190 ; v3(125,45.52) 124.87,45.52 124.45,45.93 JDIM2.161 ; JDIM2.63 92.65,45.43 v3(93.23,44.86) 93.23,45.58 93.25,45.61 JDIM2.65 ; v3(81.47,40.26) 81.55,40.17 JDIM2.26 ; JDIM2.61 92.05,44.47 v3(91.49,43.91) ; JDIM1.156 122.95,53.58 123.17,53.8 v3(123.45,53.8) ; JDIM1.170 127.15,50.28 v3(127.52,49.91) ; v3(81.49,40.92) 81.74,40.92 82.15,40.51 JDIM2.28 ; v3(133.19,58.49) 133.18,58.49 133.19,58.49 133.18,58.49 132.85,58.82 JDIM1.189 ; v3(95.18,40.34) 95.35,40.18 JDIM2.72 ; JDIM2.167 126.25,45.99 126.38,45.86 v3(126.38,44.89) ; JDIM2.55 90.25,46.01 89.89,45.65 89.89,44.98 90.2,44.67 v3(90.49,44.67) ; JDIM2.31 83.05,48.4 v3(84.27,49.61) ; v3(79.66,40.21) 79.75,40.12 JDIM2.20 ; JDIM1.138 117.55,53.51 v3(117.61,53.57) ; JDIM1.134 116.35,53.13 v3(116.29,53.19) ; JDIM2.32 83.35,40.19 v3(83.4,40.23) ; v3(115.15,41.18) 114.68,40.72 114.68,39.94 114.55,39.82 JDIM2.128 ; JDIM1.178 129.55,50.24 v3(130.13,49.66) ; JDIM2.172 127.75,40.18 v3(127.79,40.21) ; JDIM2.189 132.85,45.98 v3(132.47,45.59) 132.25,45.8 JDIM2.187 ; JDIM1.61 92.05,58.77 92.34,58.48 v3(92.52,58.48) 92.65,58.62 JDIM1.63 ; JDIM2.138 117.55,40.8 v3(117.51,40.84) ; JDIM2.3 74.65,45.64 73.94,44.93 v3(73.59,44.93) ; v3(133.02,40.59) 133.15,40.46 JDIM2.190 ; JDIM1.155 122.65,57.84 v3(122.56,57.76) 122.05,58.27 JDIM1.153 ; v3(127.34,49.15) 126.55,49.94 JDIM1.168 ; v3(86.9,40.26) 86.95,40.21 JDIM2.44 ; JDIM1.49 88.45,58.65 v3(87.54,57.74) ; JDIM1.136 116.95,53.64 116.7,53.9 v3(116.29,53.9) ; v3(128.32,53.79) 127.96,53.79 127.61,53.44 127.61,52.92 127.75,52.78 JDIM1.172 ; JDIM1.150 121.15,53.16 121.01,53.3 121.01,54.02 v3(120.81,54.23) ; JDIM2.11 77.05,48.38 v3(76.45,48.98) ; v3(127.01,41.32) 126.55,40.87 JDIM2.168 ; JDIM2.14 77.95,40.22 v3(77.38,40.79) ; JDIM2.195 134.65,45.52 v3(134.98,45.19) ; JDIM2.185 131.65,44.99 131.79,44.85 v3(132.42,44.85) ; JDIM2.156 122.95,40.62 123.22,40.89 v3(123.58,40.89) ; JDIM2.13 77.65,45.97 77.22,45.54 v3(76.86,45.54) ; v3(127.15,40.44) JDIM2.170 ; JDIM1.144 119.35,52.77 v3(119.85,53.27) ; JDIM1.184 v3(131.35,53.44) ; v3(84.08,53.67) 84.25,53.67 85.15,52.77 JDIM1.38 ; JDIM2.133 116.05,45.56 v3(115.65,45.16) ; JDIM2.46 v3(87.55,40.26) ; JDIM2.38 v3(85.15,41.12) ; v3(93.55,40.27) JDIM2.66
  BOTTOM w0.381: RV2.2 17.96,37.39 v3(17.96,37.28) 17.96,37.25 RV3.2 ; C425.1 178.41,109.82 v3(178.61,110.03) ; R478.2 173.76,118.14 174.35,117.54 v3(174.35,117.49) ; R392.2 115.53,177.28 v3(116.08,177.28) ; R637.2 154.28,81.48 154.28,80.92 v3(154.28,80.92) ; v3(116.78,93.28) 116.4,92.9 U27.P11 ; U19.AD22 140.19,150.14 140.19,150.75 U19.AC22 ; U19.AD22 140.09,150.04 139.69,149.64 v3(139.67,149.64) ; U19.AD22 U19.AD21 ; U27.A29 129.46,110.69 v3(129.93,111.15) ; R41.1 v3(112.83,151.33) ; v3(154.32,147.76) 154.14,147.94 U19.AF5 ; U27.AC11 U27.AD11 106.4,92.81 v3(106.03,93.18) ; C25.2 v3(112.65,164.28) ; U27.R11 U27.P11 ; U27.P11 116.4,92.52 v3(116.8,92.13) ; R529.2 178.67,101.67 v3(178.92,101.42) ; C562.2 28.39,8.26 v3(28.23,8.11) ; C387.1 191.31,134.78 v3(190.72,135.37) ; R616.2 v3(148.75,84.1) ; U19.E5 154.56,166.21 v3(154.56,166.21) ; U19.AB7 v3(152.1,151.29) U19.AC8 ; C475.1 181.83,98.08 183.26,96.64 v2(183.26,96.54) 183.73,96.07 v3(183.73,95.37) ; U27.W33 111.22,114.69 v3(110.74,115.17) ; v3(142.04,186.05) 142.12,186.12 PC151.1 ; C372.2 v3(112.7,155.14) ; v3(154.28,189.12) 154.36,189.05 PR34.1 154.96,188.81 154.45,188.3 PC25.1 ; v3(151.26,165.42) 151.26,165.45 U19.E8 ; RV6.2 17.44,32.64 v3(17.35,32.56) ; v3(13.11,99.69) 12.88,99.92 R535.2 C458.1 ; v3(124.91,100.15) 124.4,100.66 U27.F19 ; C435.1 175.92,104.86 176.25,104.86 v3(176.54,105.15) ; R395.2 157.05,176.34 v3(157.04,176.36) R389.2 ; R390.2 155.91,176.88 v3(156.37,176.42) 156.37,176.1 R396.2 ; PR188.1 176.55,134.11 177.19,133.47 v3(177.55,133.47) ; v3(164.34,155.53) 164.34,155.25 R435.1 ; v3(142.07,147.95) 141.73,148.29 U19.AF20 ; v3(188.7,117.87) 189.4,117.18 C419.1 ; U19.B1 157.39,168.64 v3(157.16,168.87) 157.16,168.9 157.01,169.04 U19.A2 ; U27.U11 113.4,93.09 v3(113.18,93.3) ; C427.1 179.82,108.76 v3(180.39,108.76) ; v3(129.88,109.28) 129.6,109 129.4,108.8 U27.A27 ; v3(59.26,105.62) 59.08,105.8 C433.1 ; R484.2 176.11,115.11 175.85,114.85 v3(175.54,114.85) ; v3(17.73,39.69) 17.44,39.4 RV1.2 ; v3(149.61,172.92) 150.05,173.35 R400.2 ; C449.1 35.7,101.43 v3(35.79,101.34) ; C374.1 113.36,152.79 v3(112.69,152.79) ; v3(161.8,147.06) 162.19,146.67 R446.2 ; C364.2 112.67,162.89 v3(112.6,162.96) ; R397.2 v3(159.45,176.27) 159.35,176.37 R388.2 ; C432.1 v3(13.06,106.27) ; v3(122.93,93.16) 122.46,92.69 U27.H11 ; R635.2 162.96,82.69 162.88,82.61 162.88,82.06 v3(162.88,82.06) ; U19.AC5 154.17,150.89 v3(154.59,151.32) ; v3(139.67,162.87) 139.43,163.1 139.39,163.1 U19.H23 ; U19.AD16 145.05,150.04 145.22,149.88 145.22,149.88 v3(145.45,149.65) U19.AD15 ; U19.L5 154.57,161.2 154.57,161.21 v3(154.59,161.24) ; C389.1 173.06,124.72 v3(172.65,124.31) ; C472.2 31.75,97.24 v3(31.75,96.87) ; v3(175.46,94.96) C495.1 ; C567.2 v3(102.43,3.45) ; C541.2 169.91,16.84 v3(170.34,17.26) ; v3(154.59,152.96) 154.19,153.36 U19.Y5 ; v3(112.46,148.67) R442.1 C376.2 ; v3(107.98,4.11) 108.18,4.31 C565.2 ; 186.67,113.86 186.67,113.59 187.43,112.83 v3(187.56,112.83) 187.56,116.2 C420.1 ; R538.2 v3(176.71,100.02) ; PC122.2 186.59,134.64 v3(186.03,134.08) ; R519.2 183.54,104.08 v3(184.05,104.59) ; v3(190.89,94.85) 190.96,94.92 R549.2 ; RV5.2 17.44,34.44 v3(17.93,34.94) 17.93,35.13 RV4.2 ; U19.AF23 v3(138.83,148.03) ; v3(154.59,162.88) 154.51,162.96 154.51,162.98 U19.H5 ; U27.W9 111.4,90.57 v3(111,90.17) ; v3(169.88,164.31) 169.88,164.43 169.89,164.44 169.89,164.84 C361.1 ; v3(86.36,109.62) 86.23,109.75 R490.2 ; v3(36.1,95.75) 36.1,95.8 36.33,96.03 PR134.1 PC94.2 ; v3(12.81,107.46) 12.65,107.61 C430.2 ; v3(163.88,79.67) 163.88,80.22 R640.2 ; v3(156.19,160.4) 156.59,160.8 U19.L2 ; v3(110.93,88.16) U27.W6 ; v3(188.08,57.73) 187.92,57.89 187.52,57.89 187.1,58.31 CN10.4 ; U19.B5 154.52,167.87 v3(154.52,167.84) ; PQ53.1 v3(135.58,6.12) ; R476.1 172.14,119.32 v3(172.29,119.47) ; PQ21.1 124.93,6.61 v3(125.29,6.61) ; R410.1 163.97,165.26 R415.2 ; v3(177.75,98.47) 177.6,98.62 R541.1 ; v3(20.4,32.72) 20.24,32.56 C531.1 ; v3(156.19,152.96) 156.59,153.36 U19.Y2 ; v3(150,118.63) 149.62,119.01 R469.2 ; v3(157.67,86.13) 157.76,86.22 R608.1 ; v3(128.93,84.16) 129.4,84.62 U27.A3 ; C353.1 151.3,174.89 151,175.18 v3(151,175.45) ; C350.1 v3(145.85,177.59) ; CN2.43 106.45,184.88 v3(106.25,184.68) ; v3(152.76,60.37) 152.86,60.27 153.62,60.27 C516.1 ; U19.AE20 141.75,149.24 v3(142.15,149.64) 142.55,150.04 U19.AD19 ; C354.1 v3(154.11,173.98) ; C386.1 131.27,136.78 131.14,136.65 130.3,136.65 v3(130.3,136.65) ; v3(157.3,163.06) 156.83,163.06 U19.H2 ; v3(10.92,106.75) 10.9,106.72 U23.3 ; U27.N35 117.4,117.42 v3(117.22,117.59) ; v3(179.38,138.32) 179.09,138.61 PC124.2 ; C556.2 C561.2 25.56,9.95 v3(25.18,10.33) ; C304.2 26.01,34.22 v3(26.38,33.85) ; VRAM2.B9 117.93,142.85 v3(117.43,142.35) ; U27.AA11 109.4,93.05 v3(109.62,93.26) 110.19,92.69 U27.Y11 ; v3(143.81,148.85) 144.19,149.24 U19.AE17 ; C373.1 v3(112.75,153.87) ; C352.1 147.89,175.27 v3(147.09,176.07) ; R391.2 158.45,176.84 158.45,176.31 v3(158.46,176.3) 158.46,175.9 R398.2 ; v3(23.41,96.21) 24.03,96.83 C485.2 ; v3(137.18,162.91) 137.19,162.9 U19.H25 ; C564.2 v3(110.72,5.47) ; v3(36.55,98.04) 36.95,97.64 PC91.2 ; v3(175.43,48.24) 175.57,48.1 C526.2 ; v3(57.35,110.05) 57.35,110.56 57.6,110.8 CN3.3 ; CN10.43 168.3,50.06 168.76,49.6 v3(168.96,49.6) ; U27.T26 v3(113.93,108.15) ; v3(111.93,88.16) U27.W7 ; v3(149.47,152.31) 149.47,151.93 149.22,151.68 U19.AB11 ; R572.2 154.85,89.36 v3(154.19,88.7) ; v3(148.77,89.3) 148.77,89.8 R566.1 148.78,90.02 R565.1 ; R448.2 153.21,141.11 v3(154.03,141.93) ; v3(152.92,152.96) 152.5,152.54 U19.AA7 ; C384.1 v3(132,138.94) ; C566.2 106.79,4.99 C568.2 106.79,3.82 107.17,3.82 v3(107.42,3.57) ; C457.1 192.42,101.54 v3(192.55,101.42) ; C306.2 v3(28.09,35.71) ; C497.1 v3(175.6,93.05) ; C563.2 102.46,7.22 v3(102.04,7.64) ; R385.2 115.68,178.71 116.08,179.11 v3(116.08,179.55) ; R507.2 184.26,106.22 v3(183.95,105.91) ; v3(107.93,91.16) U27.AB9 ; 112.88,150.06 v3(112.25,150.06) ; PQ52.1 v3(131.83,6.12) ; v3(138.76,151.32) 138.77,151.32 138.39,151.71 U19.AB24 ; R424.1 v3(114.45,163.65) ; U19.AD18 143.77,150.44 v3(143.79,150.44) ; C23.1 v3(112.75,165.55) ; C363.1 v3(111.79,161.36)
  BOTTOM w0.457: R420.2 164.43,164.04 v3(164.64,164.25) ; v3(164.64,162.81) 164.61,162.85 R422.2 ; R431.1 168.88,159.69 169.96,158.62 v3(170.16,158.62) ; C369.1 166.44,156.41 166.03,156.83 v3(165.78,156.83) ; R415.2 164.66,165.23 v3(164.67,165.25) ; v3(164.62,161.64) 164.59,161.61 R426.2
  BOTTOM w0.508: PQ18.1 118.19,6.52 v3(117.89,6.22) ; v3(166.48,61.54) 166.18,61.54 165.5,60.86 CN10.50 ; CN10.18 178.3,57.95 v3(178.06,57.71) ; R526.2 C447.1 11.81,103.23 v3(11.81,103.83) ; C515.1 175.81,63.9 v3(175.55,64.16) 174.94,64.16 174.67,63.89 C514.2 ; v3(199.14,100.84) 198.68,101.3 C452.2 196.2,101.08 C450.2 ; v3(121.65,128.77) 120.74,127.86 Q46.1 ; C554.1 169.09,12.87 v3(169.88,12.87) ; C370.1 168.09,155.78 v3(167.51,156.36) 168.05,156.89 C367.1 ; v3(9.95,109.68) C426.1 ; PC168.2 174.29,180.53 v3(174.88,181.12) ; PQ51.1 127.89,7.36 v3(128.59,6.66) ; CN4.5 29.48,106.75 v3(29,107.23) ; Y3.2 159.09,121.28 v3(159.77,120.59) ; v3(88.17,82.67) 85.98,84.85 77.23,84.85 C742.2 ; CN4.6 37,104.6 CN4.4 37,102.87 v3(37.14,102.74) ; v3(19.13,39.9) 18.83,40.19 C529.1 C528.1 ; v3(154.56,183.51) 154.45,183.62 PR11.1 ; R429.1 v3(163.99,159.73) R432.1 ; v3(27.51,104.68) 27.54,104.65 27.54,103.94 C446.1 ; v3(29.32,58.67) 30.18,59.53 C740.1 ; CN8.1 154.42,72.15 154.71,72.44 v3(154.71,72.44) ; v3(150.37,177.74) 150.05,177.42 R393.2 ; PQ9.1 148.27,180.34 v3(147.52,180.34) ; v3(176.71,15.08) 176,14.37 PQ20.1 ; PR66.2 v3(120.29,6.91) ; CN10.34 v3(171.9,60.83) ; C536.2 43.1,22.34 C535.1 44.3,22.32 45.6,22.32 v3(45.62,22.34) ; PC49.1 v3(123.65,11.82) ; v3(165.53,63.99) 165.53,63.31 C511.1 ; PC163.1 133.26,11.36 v3(132.99,11.64) ; PR96.1 119.27,188.19 118.93,188.54 v3(118.93,188.92) ; v3(175.2,60.65) 175.1,60.55 CN10.26 ; v3(150.06,80.76) 150.38,80.45 C501.2 ; J2.2 v3(124.61,27.37) ; v3(184.59,49.6) 184.69,49.52 185.1,49.94 CN10.9 ; v3(12.88,97.53) C470.1 R543.1 ; v3(160.67,62.86) 160.11,63.42 Q51.1 ; v3(124.98,11.93) 124.97,11.92 PR214.2 ; v3(108.23,192.3) 108.9,192.96 CN2.41 108.28,193.48 107.47,192.68 v3(107.47,192.19) ; PC41.1 61.47,49.67 v3(60.56,48.76) ; v3(10.8,103.6) 10.75,103.55 C445.1 ; U30.4 v3(145.32,70.96) ; v3(172.17,167.96) 172.48,167.64 PC116.2 PC131.2 ; v3(17.12,107.21) 17.08,107.25 C429.1 ; CN10.21 177.1,52.65 v3(177.09,52.66) ; C527.1 182.79,45.53 v3(182.79,46.5) ; C728.2 v3(68.89,115.5) ; v3(167.94,63.92) C513.2 C512.1 ; C462.1 v3(11.1,100.15) ; PC12.2 162.69,190.04 v3(162.87,189.86) ; v3(109.5,169.39) 109.5,168.79 CN2.42 ; C542.2 v3(29.85,17.85) ; PQ19.1 v3(169.24,7.04) ; R452.2 v3(119.7,128.54) ; Q53.1 v3(160.56,61.74) ; PC169.2 172.29,179.93 v3(171.96,180.26) ; PC152.2 130.18,188.03 v1(130.74,188.59) ; v3(182.11,52.53) 182.7,51.94 CN10.15 ; C509.1 151.77,62.78 v3(152.05,62.5) ; v3(185.4,66.46) 185.4,67.29 C507.2 ; v3(163.12,177.62) 163.09,177.65 R384.1 ; v3(186.63,111.08) 186.63,111.28 Q50.1 ; v3(10.14,97.05) 10.14,97.77 C474.1 ; CN10.40 v3(169.5,60.64) ; v3(184,66.81) 183.8,67.01 C506.1 ; C560.1 v3(169.09,8.66) ; C436.1 v3(9.37,104.69) ; v3(31.65,73.6) 30.77,73.6 C504.1 ; PC112.2 v3(186.34,143.71) ; v3(188.34,62.89) 188.03,63.2 C510.1 ; C444.1 29.03,105 v3(29.26,105.23) ; v3(157.51,120.41) 156.67,119.58 Y3.4 ; C545.1 v3(38.9,16.74) ; PC101.1 157.5,140.51 v3(157,141.01) ; C548.1 v3(26.65,15.23) ; C544.1 v3(31.91,16.98) ; C538.1 v3(147.38,21.37) ; v3(40.7,27.4) 40.7,25.88 41.1,25.47 U31.2 ; Q57.1 19.38,31.03 v3(19.28,30.93)
  vias: v1(2.59,28.26) v1(4.12,89.35) v1(4.25,90.57) v1(4.17,86.78) v1(4.27,94.33) v1(4.27,92.14) v1(5.06,93.34) v1(5.11,45.56) v1(5.62,64.71) v1(6.13,98.94) v1(6.17,112.45) v1(6.25,113.86) v1(6.76,90.75) v1(6.76,89.35) v1(7.14,64.71) v1(7.44,28.11) v1(7.52,46.55) v1(7.52,45.28) v1(8.16,95.07) v1(8.92,64.71) v1(9.17,44.01) v1(9.48,28.11) v1(9.58,95.6) v1(9.86,64.81) v1(10.06,45.79) v1(11.36,28.11) v1(11.81,65.09) v1(11.97,44.9) v1(12.57,65.07) v1(13.41,2.63) v1(13.49,46.68) v1(15.9,2.61) v1(19.14,116.61) v1(19.79,2.79) v1(21.36,2.61) v1(22.4,116.66) v1(23.42,2.79) v1(24.39,4.18) v1(26.64,116.9) v1(26.95,5.4) v1(28.22,29.13) v1(28.22,27.73) v1(28.35,30.78) v1(29.49,5.4) v1(30,116.68) v1(30.13,30.78) v1(30.13,29.13) v1(30.13,27.73) v1(31.27,114.48) v1(31.65,30.78) v1(31.78,29.13) v1(31.78,27.73) v1(32.03,5.4) v1(34.57,5.4) v1(35.45,113.66) v1(37.11,5.4) v1(38.93,4.36) v1(39.1,114.16) v1(39.56,3.49) v1(39.96,2.63) v1(41.06,3.49) v1(41.41,53.51) v1(41.43,2.61) v1(42.29,115.19) v1(42.42,3.45) v1(43.21,2.61) v1(43.75,3.4) v1(44.58,67.4) v1(44.66,38.6) v1(44.71,37.25) v1(44.95,4.64) v1(45.01,66.74) v1(45.06,68.06) v1(45.55,115.26) v1(46.08,76.42) v1(46.15,78.35) v1(47.53,5.28) v1(48.39,39.11) v1(48.44,36.85) v1(49.05,78.15) v1(49.05,76.29) v1(49.1,115.32) v1(49.3,38.12) v1(49.43,61.69) v1(49.41,60.83) v1(49.43,60.01) v1(49.41,59.12) v1(49.59,66.64) v1(50.09,38.14) v1(50.07,5.28) v1(50.22,36.87) v1(50.45,66.64) v1(50.88,76.24) v1(51.31,54.96) v1(51.36,66.64) v1(51.36,55.9) v1(52.18,55.9) v1(52.2,54.98) v1(52.61,5.28) v1(52.78,115.29) v1(52.94,76.19) v1(53.01,55.92) v1(53.01,55.03) v1(53.29,85.97) v1(53.33,84.96) v1(53.27,83.39) v1(53.27,82.55) v1(53.27,81.76) v1(53.35,84.14) v1(53.55,76.98) v1(54.03,81.76) v1(54.13,85.95) v1(54.1,84.98) v1(54.1,84.19) v1(54.05,83.41) v1(54.05,82.54) v1(54.83,82.49) v1(54.84,81.7) v1(54.81,76.19) v1(54.94,85.95) v1(54.88,84.98) v1(54.88,84.21) v1(54.87,83.38) v1(55.12,78.4) v1(55.15,5.28) v1(56.03,91.69) v1(56.01,90.75) v1(56.06,93.97) v1(56.06,93.21) v1(56.06,92.45) v1(56.16,94.73) v1(56.67,76.19) v1(56.82,93.95) v1(56.82,93.19) v1(56.82,92.4) v1(56.8,91.64) v1(56.77,90.75) v1(56.98,94.73) v1(57.1,114.76) v1(57.64,93.95) v1(57.58,93.19) v1(57.58,92.37) v1(57.56,91.59) v1(57.56,90.72) v1(57.69,5.28) v1(57.79,94.73) v1(58.45,76.14) v1(59.23,113.05) v1(59.47,94.68) v1(59.72,4.77) v1(59.97,34.61) v1(59.97,31.69) v1(60.23,35.76) v1(60.86,34.61) v1(60.86,31.31) v1(60.86,2.61) v1(61.62,31.69) v1(61.75,34.61) v1(62.67,112.74) v1(63.4,2.61) v1(65.41,114.79) v1(65.43,2.61) v1(66.36,117.18) v1(69.33,119.39) v1(72.51,120.68) v1(74.46,4.39) v1(76.46,122.58) v1(78.64,2.61) v1(79.27,124.16) v1(81.93,126.02) v1(84.11,127.73) v1(86.38,129.84) v1(88.22,131.87) v1(90.06,134.23) v1(90.16,3.07) v1(94.32,2.94) v1(95.42,143.7) v1(96.71,147.04) v1(97.34,150.54) v1(98.32,154.59) v1(98.42,172.58) v1(98.4,168.72) v1(98.4,163.53) v1(98.53,180.23) v1(98.48,176.27) v1(98.5,159.59) v1(98.57,193.19) v1(98.56,190.68) v1(98.66,187.7) v1(98.66,184.14) v1(100.11,2.49) v1(100.9,193.33) v1(103.28,193.36) v1(105.56,193.62) v1(108.21,1.55) v1(111.89,2.89) v1(115.68,2.89) v1(119.54,189.58) v1(119.86,4.07) v1(121.7,193.57) v1(123.09,193.62) v1(123.41,4.39) v1(125.63,193.62) v1(127.02,4.31) v1(128.17,193.62) v1(129.44,2.83) v1(130.71,193.62) v1(131.07,191.15) v1(131.53,188.61) v1(132.34,191.15) v1(132.34,188.59) v1(132.52,2.83) v1(133.25,193.62) v1(135.79,193.62) v1(136.28,2.7) v1(138.33,193.62) v1(140.06,8.81) v1(140.06,5.31) v1(140.12,2.62) v1(140.26,191.18) v1(140.87,193.62) v1(142.27,11.54) v1(146.14,11.78) v1(150.27,11.78) v1(151.67,133.24) v1(151.69,132.45) v1(151.72,131.67) v1(152.33,134.05) v1(153.44,193.62) v1(154.59,11.7) v1(155.98,193.62) v1(158.52,193.62) v1(159.24,11.78) v1(161.06,193.62) v1(164.06,11.8) v1(166.14,193.62) v1(167.21,5.54) v1(167.42,2.94) v1(168.28,141.39) v1(168.41,138.25) v1(168.68,193.62) v1(169.04,138.7) v1(170.18,2.91) v1(171.22,193.62) v1(173.53,2.83) v1(174.93,148.1) v1(175.77,148.13) v1(176.61,148.1) v1(177.5,148.1) v1(177.55,2.73) v1(177.81,6.04) v1(179.42,8.17) v1(179.89,156.48) v1(179.91,155.52) v1(179.89,154.55) v1(179.94,152.82) v1(179.96,153.64) v1(180.09,160.67) v1(180.83,156.51) v1(180.8,155.59) v1(180.83,154.63) v1(180.78,153.54) v1(180.83,152.42) v1(180.95,160.67) v1(181.79,160.67) v1(181.84,153.49) v1(181.84,152.55) v1(181.79,151.63) v1(181.87,156.46) v1(181.87,155.54) v1(181.87,154.5) v1(182.38,125.24) v1(182.4,124.4) v1(183.21,125.27) v1(183.21,124.43) v1(183.15,8.65) v1(183.34,156.46) v1(183.34,155.47) v1(184,124.48) v1(183.98,120.57) v1(184.05,125.27) v1(184.56,160.72) v1(184.79,156.46) v1(184.79,155.54) v1(184.79,154.5) v1(184.79,153.49) v1(184.79,152.55) v1(184.81,151.61) v1(184.76,124.66) v1(184.79,123.84) v1(184.81,120.57) v1(185.32,160.72) v1(185.42,5.49) v1(185.81,151.68) v1(186.01,156.46) v1(186.01,155.54) v1(186.01,154.5) v1(185.98,153.49) v1(185.98,152.55) v1(186.16,160.7) v1(186.24,123.74) v1(187.2,149.19) v1(187.23,148.33) v1(187.15,123.72) v1(187.99,149.17) v1(187.99,148.33) v1(189.05,3.47) v1(189.89,195.14) v1(192.18,195.14) v1(192.38,147.54) v1(194.41,22.51) v1(194.39,12.8) v1(194.36,9.52) v1(194.49,19.64) v1(194.46,16.41) v1(194.81,74.31) v1(194.81,72.18) v1(194.81,70.1) v1(194.81,68.25) v1(194.97,63.77) v1(197.88,47.26) v1(197.92,44.7) v1(197.92,38.96) v1(197.87,35.48) v1(197.99,57.73) v1(197.96,54.45) v1(197.96,50.53) v1(197.95,41.96) v1(199.78,113.23) v1(200.18,185.72) v1(200.18,184.35) v1(200.18,181.81) v1(200.18,179.27) v1(200.18,176.73) v1(200.18,174.19) v1(200.18,171.65) v1(200.18,169.11) v1(200.18,166.57) v1(200.18,164.03) v1(200.18,161.49) v1(200.18,158.95) v1(200.18,156.41) v1(200.18,153.87) v1(200.18,151.33) v1(200.18,148.79) v1(200.18,146.25) v1(200.18,143.71) v1(200.18,141.17) v1(200.18,138.63) v1(200.18,136.09) v1(200.18,133.55) v1(200.18,131.01) v1(200.18,128.47) v1(200.18,125.93) v1(200.18,123.39) v1(201.7,111.7) v1(201.7,109.16) v1(201.7,106.62) v1(201.7,104.08) v1(201.7,101.54) v1(201.7,99) v1(201.7,96.46) v1(201.7,93.92) v1(201.7,91.38) v1(201.7,88.84) v1(201.7,86.3) v2(7.14,93.29) v2(7.22,92.45) v2(14.36,45.46) v2(19.41,5.5) v2(19.71,91.13) v2(21.13,97.76) v2(29.19,30.09) v2(29.44,89.93) v2(33.45,19.75) v2(43.61,67.84) v2(52,34.99) v2(53.62,102.3) v2(53.73,26.03) v2(56.37,103.75) v2(58.98,88.26) v2(66.3,105.17) v2(70.82,83.36) v2(73.92,78.35) v2(91.47,72.1) v2(92.13,9.31) v2(92.08,8.04) v2(111,156.71) v2(111.84,142.82) v2(111.91,158.82) v2(111.92,142.82) v2(112.27,171.21) v2(122.43,102.71) v2(132.16,189.5) v2(134.62,9.21) v2(135.56,138.8) v2(142.98,107.97) v2(151.41,134.1) v2(153.32,177.08) v2(156.04,120.01) v2(156.29,161.38) v2(166.04,191.08) v2(167.67,137.31) v2(168.1,13.02) v2(171.4,190.59) v2(189.39,17.6) v2(191.14,36.47) v2(191.37,74.85) v2(191.72,19.35) v2(196.8,163.98) v3(11.58,109.54) v3(12.17,57.93) v3(12.47,109.54) v3(12.63,55.09) v3(13.49,109.54) v3(13.58,69.95) v3(14.17,66.82) v3(14.25,109.54) v3(14.28,52.29) v3(14.51,54.45) v3(14.61,50.36) v3(14.84,49.7) v3(14.94,34.74) v3(14.99,37.15) v3(14.96,32.63) v3(15.14,46.3) v3(15.17,47.06) v3(15.17,39.21) v3(15.22,37.76) v3(15.44,65.02) v3(15.44,64.33) v3(15.5,47.92) v3(15.52,35.25) v3(15.6,52.75) v3(15.7,65.63) v3(16,47.08) v3(16,46.3) v3(16.16,65.09) v3(16.74,47.06) v3(16.71,46.27) v3(17.93,64.71) v3(17.93,63.95) v3(18.34,92.25) v3(18.99,92.25) v3(19.49,14.9) v3(19.5,14.25) v3(19.64,92.25) v3(20.28,92.25) v3(21.31,36.92) v3(21.85,35.07) v3(22.46,41.9) v3(22.84,47.95) v3(22.92,50.21) v3(22.86,40.05) v3(23.09,54.7) v3(23.17,52.42) v3(23.96,40.81) v3(25.11,14.48) v3(25.12,13.79) v3(25.15,13.1) v3(25.99,93.24) v3(26.9,88.74) v3(26.95,99.26) v3(26.95,98.37) v3(26.95,97.48) v3(27.08,88.08) v3(27.08,87.34) v3(27.39,41.49) v3(27.39,40.84) v3(27.56,94.43) v3(27.74,58.57) v3(27.84,99.26) v3(27.84,98.37) v3(27.84,97.48) v3(27.79,88.77) v3(27.79,88.08) v3(27.79,87.37) v3(28.73,98.37) v3(28.73,97.48) v3(28.83,75.61) v3(28.78,60.06) v3(28.96,80.49) v3(29.16,77.79) v3(29.24,72.64) v3(29.4,85.79) v3(30.03,13.48) v3(30.13,11.96) v3(30.81,93.08) v3(30.81,12.64) v3(31.09,94.86) v3(31.47,11.96) v3(31.6,13.45) v3(32.36,19.27) v3(32.54,91.25) v3(32.54,20.29) v3(32.57,100.45) v3(32.57,99.79) v3(32.69,94.68) v3(33.71,36.65) v3(34.29,18.97) v3(34.93,17.44) v3(35.41,16.22) v3(35.72,8.93) v3(35.79,16.76) v3(36.38,8.91) v3(36.55,17.14) v3(36.94,9.62) v3(37.88,9.67) v3(43.06,14.57) v3(43.08,13.89) v3(43.11,13.2) v3(49.89,111.63) v3(50.53,111.6) v3(51.18,111.6) v3(51.83,111.57) v3(52,17.57) v3(52,16.86) v3(52.25,103.68) v3(52.79,26.33) v3(52.81,25.62) v3(52.91,103.65) v3(53.57,103.7) v3(65.13,104.18) v3(65.82,104.21) v3(66.48,104.21) v3(68.08,48.41) v3(68.79,48.41) v3(70.41,88.38) v3(70.51,89.86) v3(70.46,89.1) v3(71.15,47.8) v3(71.15,44.82) v3(71.18,47.11) v3(71.18,44.16) v3(71.28,89.86) v3(71.28,89.2) v3(71.84,90.54) v3(73.03,34.41) v3(73.03,33.7) v3(73.64,44.06) v3(73.69,33.7) v3(73.79,62.07) v3(73.77,61.38) v3(73.98,55.74) v3(73.98,41.44) v3(75.19,78.96) v3(75.21,78.28) v3(75.21,77.57) v3(75.22,76.92) v3(75.74,55.7) v3(76.02,43.9) v3(76.94,37.36) v3(77.07,58.49) v3(77.07,57.83) v3(77.15,55.81) v3(77.32,42.29) v3(77.68,37.36) v3(78.39,37.31) v3(79.13,56.46) v3(79.12,43) v3(80.37,75.79) v3(80.47,40.86) v3(80.93,55.42) v3(81.39,41.85) v3(81.76,54.25) v3(81.82,53.57) v3(82.2,69.16) v3(82.18,68.51) v3(82.45,55.34) v3(83.5,43.49) v3(83.97,54.99) v3(86.04,55.32) v3(85.96,42.79) v3(86.06,54.66) v3(86.14,41.67) v3(86.27,71.97) v3(86.27,71.31) v3(87.05,42.31) v3(87.61,55.19) v3(87.56,53.11) v3(88.39,42.5) v3(89.47,56.26) v3(89.46,54.84) v3(90.17,73.93) v3(90.17,73.27) v3(90.17,72.1) v3(90.16,70.97) v3(90.48,71.53) v3(90.89,42.37) v3(91.27,35.74) v3(92.01,35.76) v3(92.53,55.85) v3(93.69,41.56) v3(95.52,43.1) v3(96.12,56.97) v3(96.19,55.5) v3(96.3,121.12) v3(96.91,121.35) v3(97.32,41.65) v3(97.53,121.1) v3(97.72,57.15) v3(97.74,55.19) v3(98.83,42.43) v3(98.99,40.25) v3(100.18,56.79) v3(100.18,54.53) v3(100.29,41.03) v3(100.47,43.06) v3(101.07,125.67) v3(101.61,55.27) v3(101.93,12.77) v3(102.37,125.66) v3(102.48,102.94) v3(102.48,100.66) v3(102.52,40.46) v3(102.65,179.41) v3(102.57,127.93) v3(102.65,12.82) v3(103.04,125.62) v3(103.07,42.24) v3(103.24,181.15) v3(103.22,127.94) v3(103.26,57.61) v3(103.51,172.61) v3(103.51,171.65) v3(103.51,170.96) v3(103.69,125.61) v3(103.68,41.07) v3(104.26,104.47) v3(104.26,103.71) v3(104.26,102.94) v3(104.26,99.9) v3(104.26,99.13) v3(104.27,98.46) v3(104.26,96.34) v3(104.65,5.25) v3(104.65,4.56) v3(104.84,102.15) v3(104.84,101.38) v3(104.84,100.7) v3(105.08,182.09) v3(105.19,177.54) v3(105.24,4.18) v3(105.26,179.75) v3(105.26,42.85) v3(105.62,57.68) v3(105.67,40.41) v3(105.97,177.44) v3(106.03,104.47) v3(106.03,103.71) v3(106.03,102.94) v3(106.03,99.9) v3(106.03,99.22) v3(106.04,98.53) v3(106.03,96.34) v3(106.64,102.16) v3(106.63,101.46) v3(106.65,100.69) v3(106.71,42.51) v3(106.9,91.99) v3(107.06,56.67) v3(107.15,54.95) v3(107.47,169.66) v3(107.55,163.57) v3(107.55,162.91) v3(107.81,102.94) v3(107.81,96.34) v3(107.87,98.54) v3(107.93,86.16) v3(107.93,85.16) v3(108.01,40.84) v3(108.86,42.88) v3(109.04,171.67) v3(109.07,174.52) v3(109.59,102.94) v3(109.6,98.57) v3(109.59,96.34) v3(109.73,11.91) v3(109.91,92.01) v3(110.34,44.37) v3(110.51,55.98) v3(110.6,57.55) v3(110.64,41.7) v3(111.15,7.82) v3(111.37,102.94) v3(111.38,98.56) v3(111.37,96.34) v3(111.51,56.13) v3(111.94,7.82) v3(112.07,159.63) v3(112.08,157.92) v3(112.09,157.19) v3(112.12,156.46) v3(112.14,146.35) v3(112.12,145.61) v3(112.12,144.95) v3(112.09,144.26) v3(112.09,143.58) v3(112.15,141.27) v3(112.12,140.38) v3(112.14,100.67) v3(112.12,41.5) v3(112.5,142.31) v3(112.68,152.14) v3(112.93,175.08) v3(112.93,174.41) v3(112.9,173.7) v3(112.9,173.04) v3(112.9,172.36) v3(112.88,171.67) v3(113.15,104.47) v3(113.15,103.71) v3(113.15,102.94) v3(113.15,99.9) v3(113.14,99.23) v3(113.15,98.55) v3(113.15,96.34) v3(113.88,102.18) v3(113.88,101.4) v3(113.91,100.67) v3(114.92,104.47) v3(114.92,103.71) v3(114.92,102.94) v3(114.92,100.58) v3(114.92,99.9) v3(114.91,99.24) v3(114.91,98.56) v3(114.92,96.34) v3(114.96,92.12) v3(115.04,55.24) v3(115.45,42.21) v3(115.7,149.14) v3(115.68,102.15) v3(115.68,101.34) v3(115.73,49.64) v3(115.74,48.97) v3(116.23,42.97) v3(116.28,54.58) v3(116.7,102.94) v3(116.7,100.56) v3(116.71,98.55) v3(116.7,96.34) v3(117.17,41.55) v3(117.48,183.71) v3(117.65,55.52) v3(117.7,185.87) v3(118.11,181.66) v3(118.49,98.55) v3(118.48,96.34) v3(118.93,179.82) v3(119.3,178.82) v3(119.29,178) v3(119.29,100.61) v3(119.61,119.35) v3(119.87,55.45) v3(120.04,43.99) v3(120.25,100.57) v3(120.26,104.47) v3(120.26,103.71) v3(120.26,102.94) v3(120.26,99.9) v3(120.27,99.21) v3(120.29,98.54) v3(120.26,97.86) v3(120.26,97.1) v3(120.26,96.34) v3(120.26,95.58) v3(120.26,94.82) v3(120.36,144.81) v3(120.6,121.2) v3(120.78,119.68) v3(121.79,145.33) v3(122.13,42.14) v3(122.16,171.12) v3(122.53,127.07) v3(123.42,125.65) v3(123.69,43.31) v3(124.82,126.94) v3(124.79,120.13) v3(125.05,44.19) v3(125.05,42.83) v3(125.63,55.08) v3(125.63,42.49) v3(125.91,107.33) v3(126.93,120.62) v3(127.93,108.15) v3(127.89,106.11) v3(128.32,55.12) v3(128.43,43.96) v3(129.21,120.62) v3(129.62,55.82) v3(129.62,54.17) v3(130.53,43.72) v3(131.37,120.82) v3(131.4,56.02) v3(131.78,116.6) v3(132.52,114.88) v3(132.87,112.74) v3(132.92,42.23) v3(132.97,118.18) v3(133.16,54.61) v3(133.25,55.92) v3(133.63,116.54) v3(133.66,156) v3(135.03,42.99) v3(135.68,43.87) v3(136.94,141.98) v3(136.94,141.27) v3(136.94,140.61) v3(136.94,139.95) v3(137.94,146.78) v3(137.88,146.12) v3(137.91,33.67) v3(137.98,145.43) v3(138.66,33.67) v3(138.79,34.38) v3(138.99,139.67) v3(139.02,54.55) v3(139.35,33.65) v3(139.39,49.68) v3(139.4,48.97) v3(139.48,34.38) v3(139.55,57.8) v3(139.78,60.75) v3(139.78,59.74) v3(140.01,57.3) v3(140.03,52.04) v3(140.03,51.33) v3(140.09,50.49) v3(140.21,47.87) v3(140.24,47.14) v3(140.36,38.22) v3(140.72,48.38) v3(140.77,38.78) v3(141.3,79.57) v3(141.33,48.91) v3(141.38,122.85) v3(141.58,140.79) v3(141.56,110.48) v3(141.81,77.72) v3(141.91,125.57) v3(142.01,153.84) v3(142.02,48.91) v3(142.34,156.84) v3(142.45,124.1) v3(142.75,144.14) v3(142.7,15.26) v3(142.93,126.94) v3(143.12,157.77) v3(143.08,142.49) v3(143.25,159.93) v3(143.21,153.98) v3(143.31,155.9) v3(143.44,15.59) v3(143.68,145.83) v3(143.72,110.64) v3(143.92,183.7) v3(144.06,124.12) v3(144.2,162.96) v3(144.25,112.26) v3(144.27,108.35) v3(144.38,183.22) v3(144.76,141.24) v3(144.93,108.35) v3(145.14,155.85) v3(145.16,161.69) v3(145.19,159.84) v3(145.16,157.82) v3(145.42,93.89) v3(145.5,15.49) v3(145.93,42.82) v3(146.11,114.09) v3(146.15,93.87) v3(146.15,156.79) v3(146.33,163.14) v3(147.22,161.97) v3(147.2,15.49) v3(147.71,96.87) v3(147.82,153.71) v3(148.13,158.79) v3(148.06,146.42) v3(148.14,92.6) v3(148.06,16.78) v3(148.22,162.96) v3(148.19,160.84) v3(148.19,156.72) v3(148.24,154.86) v3(148.21,114.19) v3(148.62,16.4) v3(149.07,162.97) v3(149.13,107.77) v3(149.15,107.03) v3(149.31,104.77) v3(149.61,153.74) v3(149.81,24.1) v3(149.84,22.88) v3(150.17,156.74) v3(150.47,24.1) v3(150.5,22.88) v3(150.98,177.36) v3(151.01,176.65) v3(151.34,146.42) v3(151.39,162.25) v3(151.38,161.34) v3(151.38,159.34) v3(151.38,157.26) v3(151.38,155.34) v3(151.45,78.48) v3(151.92,162.81) v3(152.12,160.42) v3(152.73,94.73) v3(152.68,79.87) v3(153.24,145.71) v3(153.22,48.94) v3(153.19,48.23) v3(153.29,20.19) v3(153.82,178.78) v3(154.05,74.19) v3(154.11,65.8) v3(154.18,111.83) v3(154.34,107.99) v3(154.3,104.68) v3(154.29,94.65) v3(154.26,19.25) v3(154.54,178.81) v3(154.52,66.48) v3(154.54,16.05) v3(154.56,67.22) v3(154.71,74.19) v3(154.85,111.79) v3(155,16.99) v3(155.3,121.35) v3(155.3,16.05) v3(155.53,111.78) v3(155.49,77.82) v3(155.68,17.9) v3(155.66,16.93) v3(156.14,17.39) v3(156.19,157.92) v3(157.26,16.99) v3(159.06,179.6) v3(159.06,44.82) v3(159.45,109.04) v3(159.72,179.57) v3(159.82,147.62) v3(160.15,56.38) v3(160.66,117.14) v3(161.32,44.75) v3(162.27,71.47) v3(162.25,70.81) v3(162.28,70.15) v3(162.36,107.56) v3(163.01,101.07) v3(163.63,140.99) v3(163.65,44.69) v3(163.95,16.02) v3(164.09,52.64) v3(164.6,16.02) v3(164.98,110.34) v3(165.25,16.02) v3(165.41,143.22) v3(165.42,142.57) v3(166.76,191.25) v3(167.47,191.25) v3(167.62,109.15) v3(168.1,107.2) v3(168.06,106.22) v3(168.1,103.7) v3(168.23,191.25) v3(168.52,71.02) v3(168.51,70.35) v3(168.61,190.67) v3(168.79,105.23) v3(168.99,191.23) v3(169.75,191.25) v3(169.78,180.21) v3(170.18,157.96) v3(170.34,114.46) v3(170.44,180.21) v3(170.39,18.2) v3(171.03,18.25) v3(171.1,180.21) v3(171.58,173.81) v3(171.61,173.09) v3(171.56,172.43) v3(171.73,49.38) v3(171.68,18.23) v3(171.76,48.73) v3(172.14,112.73) v3(172.24,95.83) v3(172.34,18.18) v3(172.85,190.9) v3(172.99,18.2) v3(173.35,108.26) v3(173.53,114.23) v3(173.49,107.07) v3(173.64,18.2) v3(173.79,188.92) v3(173.84,49.6) v3(174.22,49.07) v3(174.27,188.46) v3(174.28,18.2) v3(175.19,113.18) v3(175.19,111.93) v3(175.34,110.69) v3(175.42,116.57) v3(176.69,173.02) v3(176.69,172.36) v3(176.71,120.47) v3(176.73,96.41) v3(176.91,68.6) v3(177.35,173.02) v3(177.35,172.36) v3(178.26,119.7) v3(178.39,96.47) v3(179.18,181.5) v3(179.84,181.5) v3(180.14,119.75) v3(180.44,26.17) v3(180.85,14.01) v3(181.14,26.17) v3(181.79,26.18) v3(183.37,112.51) v3(184.08,140.28) v3(184.05,139.26) v3(184.41,26.38) v3(184.54,139.77) v3(184.89,22.22) v3(184.99,140.28) v3(184.99,139.24) v3(185.63,124.33) v3(185.98,36.34) v3(186.01,34.23) v3(186.06,32.02) v3(186.29,20.67) v3(187.47,17.34) v3(187.76,28.54) v3(188.06,34.99) v3(188.06,32.25) v3(188.07,10.05) v3(188.09,9.39) v3(188.12,8.58) v3(188.65,66.87) v3(188.8,99.99) v3(188.8,99.33) v3(190.63,137.41) v3(191.49,54.91) v3(191.52,54.22) v3(191.73,60.11) v3(191.72,31.74) v3(191.72,31.03) v3(192.64,138.67) v3(192.74,38.12) v3(192.73,37.41) v3(192.74,36.77) v3(192.73,36.07) v3(193.05,177.8) v3(193.53,177.35) v3(193.45,174.21) v3(193.91,173.73) v3(195.69,167.58) v3(195.71,166.93) v3(195.71,166.29) v3(195.71,165.64) v3(196.96,127.23) v3(196.98,126.56) v3(197.36,175.61) v3(197.56,106.16) v3(197.56,105.5) v3(197.85,175.12) v3(197.99,109.51) v3(197.99,108.83)
