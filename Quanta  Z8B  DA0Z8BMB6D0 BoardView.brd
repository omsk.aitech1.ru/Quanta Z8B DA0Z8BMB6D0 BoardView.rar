# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V on TOP (solid shape): 157.89,89.35 157.89,89.05 158.06,89.05 158.07,89.03 158.08,89.01 158.08,88.77 157.41,88.09 157.38,88.09 157.22,88.03 157.15,87.87 157.15,87.57 157.16,87.49 157.2,87.42 157.2,87.29 157.41,87.08 157.88,87.08 158.01,86.96 158.01,86.94 158.24,86.62 158.63,86.68 158.89,86.41 158.89,86.03 158.85,85.99 158.85,85.96 158.76,85.88 158.13,85.88 158.05,85.92 158.03,86.01 157.67,86.51 157.3,86.01 157.29,85.92 157.21,85.88 156.58,85.88 156.56,85.87 156.43,85.8 156.37,85.65 156.37,85.37 156.39,85.28 156.45,85.2 156.45,85.04 156.39,84.96 156.37,84.87 156.37,84.59 156.39,84.51 156.42,84.45 156.43,84.43 156.43,84.42 157.19,83.66 157.56,83.66 158.14,83.89 157.71,84.35 157.69,84.36 157.67,84.37 157.53,84.51 157.53,84.99 157.58,85.04 158.32,85.04 158.66,84.7 158.66,83.64 158.58,83.34 158.7,83.06 158.7,82.21 158.21,81.72 156.88,81.72 155.43,83.16 155.43,83.98 155.43,83.98 155.43,86.75 156.87,88.2 156.87,88.41 156.88,88.41 156.88,89.62 156.98,89.73 157.51,89.73
+3V on TOP (solid shape): outline of 2681 points within 124.49,34.54 136.84,61.69
+3V on BOTTOM (solid shape): 60.94,47.31 60.94,46.42 60.28,45.76 58.48,45.76 58.2,46.04 58.2,46.81 59.14,47.74 60.51,47.74
+3V on BOTTOM (solid shape): 153.9,55.1 153.9,53.86 153.54,53.5 152.71,53.5 152.39,53.82 152.39,55.59 152.57,55.76 153.25,55.76
+3V on BOTTOM (solid shape): 156.67,44.21 156.67,43.35 156.4,43.08 153.97,43.08 153.22,43.83 153.22,44.09 153.73,44.6 156.29,44.6
+3V on BOTTOM (solid shape): 117.02,28.82 117.02,22.19 117.45,21.76 117.48,21.76 118.75,20.49 118.75,20.03 118.22,19.5 116.77,19.5 114.43,21.84 114.43,28.75 114.61,28.92 116.92,28.92
+3V on BOTTOM (solid shape): 146.86,21.52 146.86,18.26 146.85,18.24 146.85,17.48 146.49,17.11 146.08,17.11 146.03,17.16 146.03,18.69 145.34,19.38 145.34,21.52 145.55,21.73 146.65,21.73
+3V on BOTTOM (solid shape): 166.33,155.88 166.7,155.88 166.8,155.79 166.8,154.82 166.8,154.82 166.8,153.29 166.79,153.29 166.75,153.25 165.87,153.25 165.71,153.41 165.71,154.86 165.32,155.25 165.32,156.29 165.45,156.41 165.8,156.41
+3V on BOTTOM (solid shape): 169.88,157.04 169.88,154.71 169.52,154.35 169.52,153.31 169.49,153.29 169.24,153.29 169.21,153.32 169.21,154.44 168.62,155.02 168.62,156.52 168.63,156.53 168.62,156.54 168.62,157.05 168.78,157.21 169.7,157.21
+3V on BOTTOM (solid shape): 40,15.31 40.51,14.92 41.14,14.83 41.27,14.71 41.27,12.88 41.82,12.33 41.89,12.33 41.91,12.31 42.27,12.31 42.52,12.06 42.52,11.64 42.21,11.33 41.43,11.33 40,12.77 40,13.64 39.72,13.92 39.31,13.92 38.93,14.3 38.93,15.15 39.09,15.31
+3V on BOTTOM (solid shape): 168.64,49.11 168.64,47.78 168.61,47.77 168.34,47.36 168.68,47.02 168.72,47 168.73,46.97 168.73,45.98 168.46,45.71 167.42,45.71 167.15,45.98 167.15,48.47 167.89,49.22 168.54,49.22
+3V on IN1 (solid shape): 127.66,35.58 127.66,34.87 126.98,34.18 124.69,34.18 124.36,34.51 124.36,35.38 124.89,35.9 127.34,35.9
+3V on IN1 (solid shape): 158.32,43.46 158.32,42.92 158.08,42.68 155.69,42.68 155.38,43 155.38,43.5 156.14,44.27 157.51,44.27
+3V on IN1 (solid shape): 154.24,56.01 154.24,55.49 152.85,54.1 151.57,54.1 151.35,54.33 151.35,54.94 152.7,56.29 153.96,56.29
+3V on IN1 (solid shape): 168.97,45.94 168.97,44.39 168.36,43.78 166.88,43.78 166.57,44.09 166.57,44.91 167.26,45.6 167.26,46.04 167.44,46.22 168.69,46.22
+3V on IN1 (solid shape): 150.89,92.51 152.88,92.51 153,92.39 153,91.98 151.94,90.92 149.76,90.92 149.38,91.31 149.38,92.32 149.79,92.73 150.67,92.73
+3V on IN1 (solid shape): 138.71,114.78 138.81,114.71 138.92,114.67 138.99,114.6 138.99,114.08 138,113.1 136.81,113.1 136.68,113.23 136.68,113.95 137.5,114.78
+3V on IN1 (solid shape): 183.78,91.68 183.78,91.06 181.12,88.4 180.08,88.4 179.15,87.47 179.15,86.56 179.01,86.42 178.63,86.42 178.42,86.63 178.42,88.11 179.79,89.48 180.76,89.48 183.15,91.86 183.61,91.86
+3V on IN1 (solid shape): 187.97,64.71 187.97,64.08 187.76,63.86 186.24,63.86 185.98,64.03 185.67,63.97 185.6,64.04 185.6,65.98 185.76,66.13 186.55,66.13
+3V on IN1 (solid shape): 153.88,88.99 153.88,88.96 153.87,88.94 153.82,88.54 154.15,88.31 154.18,88.29 154.19,88.26 154.19,87.03 153.97,86.81 153.32,86.81 152.92,87.21 152.92,88.47 153.5,89.06 153.82,89.06
+3V on IN1 (solid shape): outline of 201 points within 155.92,81.67 161.62,91.66
+3V on IN2 (solid shape): 42.51,12 42.51,11.53 42.32,11.34 41.39,11.34 41.1,11.63 41.1,12.28 41.17,12.35 42.16,12.35
+3V on IN2 (solid shape): 60.96,46.86 60.96,45.76 60.84,45.64 58.55,45.64 58.35,45.84 58.35,46.83 58.73,47.21 60.61,47.21
+3V on IN2 (solid shape): 126.49,34.98 126.49,34.14 126.22,33.87 123.69,33.87 123.22,34.34 123.22,34.97 123.38,35.13 126.33,35.13
+3V on IN2 (solid shape): 170.16,147.95 170.16,146.2 169.85,145.89 169.09,145.89 168.86,146.12 168.86,147.9 169.19,148.23 169.88,148.23
+3V on IN2 (solid shape): 110.55,16.86 110.55,16.05 110.27,15.77 109.38,15.77 109.36,15.75 108.63,15.75 108.44,15.94 108.44,16.6 108.82,16.98 110.42,16.98
+3V on IN2 (solid shape): 117.68,29.25 117.68,28.21 117.25,27.78 117.05,27.78 116.97,27.7 115.35,27.7 115.04,28.01 115.04,29.3 115.28,29.55 117.39,29.55
+3V on IN2 (solid shape): 157.98,89.09 157.98,87.97 157.4,87.39 157.4,86.92 156.39,85.92 155.92,85.92 155.55,86.29 155.55,86.89 155.59,86.93 155.59,88.57 156.33,89.31 157.76,89.31
+3V on IN2 (solid shape): 152.84,91.96 152.84,91.17 152.84,91.14 152.82,91.12 152.66,90.67 153.06,90.4 153.08,90.4 153.1,90.38 154.14,89.35 154.14,89.12 154.12,89.09 154.1,89.08 153.79,88.7 154.1,88.32 154.12,88.31 154.14,88.28 154.14,87.13 154.08,87.07 153.14,87.07 152.85,87.36 152.85,89.08 151.91,90.03 151.91,91.88 152.15,92.12 152.68,92.12
+3V on IN2 (solid shape): outline of 259 points within 172.24,114.56 178.46,124.76
+3V_EC on TOP (solid shape): 163.98,58.7 165.93,58.7 166.7,57.93 166.7,57.04 166.58,56.92 165.8,56.92 165.62,57.09 163.33,57.09 163.21,57.21 163.21,57.93 162.92,58.22 162.92,58.87 163.03,58.97 163.71,58.97
+3V_GFX on TOP (solid shape): 152.68,170.73 152.68,170.27 152.53,170.12 151.26,170.12 150.69,170.69 150.69,171.31 151.15,171.77 151.64,171.77
+3V_GFX on TOP (solid shape): outline of 171 points within 159.47,170.99 169.09,184.02
+3V_GFX on TOP (solid shape): outline of 545 points within 151.04,149.12 169.52,166.87
+3V_GFX on BOTTOM (solid shape): 163.02,183.58 163.02,182.57 162.79,182.34 161.78,182.34 161.17,182.95 161.17,183.41 161.52,183.76 162.84,183.76
+3V_GFX on BOTTOM (solid shape): 164.95,173.25 164.95,172.61 164.32,171.98 163.81,171.98 163.45,171.62 163.45,171.09 163.4,171.04 162.84,171.04 162.69,171.19 162.69,172.56 163.05,172.92 163.53,172.92 164.04,173.42 164.77,173.42
+3V_GFX on BOTTOM (solid shape): 150.17,164.31 150.17,164.1 149.69,163.62 148.44,163.62 148.19,163.87 148.16,163.93 148.13,163.98 148.13,164.29 148.22,164.37 148.41,164.37 148.55,164.24 148.9,164.24 149.39,164.73 149.75,164.73
+3V_GFX on BOTTOM (solid shape): 152.35,152.26 152.35,152.03 151.9,151.58 151.84,151.54 151.82,151.53 151.42,151.53 151.34,151.58 151.26,151.61 151.24,151.61 151.09,151.76 151.09,151.77 151.02,151.89 150.9,151.96 150.89,151.97 150.67,152.18 150.67,152.68 150.81,152.82 151.79,152.82
+3V_GFX on BOTTOM (solid shape): 166.52,166.1 166.53,166.08 166.53,166.05 166.55,165.84 166.69,165.67 166.91,165.6 167.12,165.67 167.13,165.67 167.18,165.69 167.22,165.64 167.22,163.51 167.09,163.27 167.15,163.01 167.15,162.95 166.61,162.41 166.07,162.41 166.02,162.44 165.95,162.5 165.95,166.2 166.04,166.29 166.33,166.29
+3V_GFX on IN2 (solid shape): outline of 352 points within 161.24,161.97 167.36,173.98
+3V_MAIN on TOP (solid shape): outline of 416 points within 148.62,163.21 159.31,181.17
+3V_RTC on BOTTOM (solid shape): 180.12,88.04 180.12,86.42 179.62,85.92 179.43,85.92 179,85.93 178.84,85.52 178.82,85.45 178.76,85.4 178.51,85.22 178.47,84.92 178.46,84.83 178.37,84.79 177.96,84.79 177.75,85 177.75,85.56 178.61,86.42 179.01,86.56 179.04,86.97 179.04,87.57 179.66,88.18 179.97,88.18
+3V_S5 on TOP (solid shape): 184.08,110.51 184.08,109.49 183.54,108.95 182.13,108.95 181.82,109.26 181.82,109.62 182.88,110.69 183.9,110.69
+3V_S5 on TOP (solid shape): 150.21,57.4 150.25,57.38 150.26,57.35 150.26,55.36 150.07,55.16 149.64,55.16 149.48,55.32 149.48,57.16 149.71,57.4
+3V_S5 on TOP (solid shape): 169.96,91.99 169.96,91.66 169.65,91.36 168.91,91.36 168.79,91.23 168.79,91.08 168.66,90.95 167.75,90.95 167.14,91.56 167.14,91.99 167.29,92.14 169.8,92.14
+3V_S5 on TOP (solid shape): 172.76,88.44 172.77,88.41 172.77,88.4 173.07,87.95 173.52,88.26 173.59,88.34 173.69,88.31 174.19,87.81 174.19,87.5 174.02,87.33 172.87,87.33 171.95,86.41 171.95,86.1 171.6,85.75 171.6,84.42 171.88,84.13 172.25,84.13 172.53,84.41 173.14,84.41 173.47,84.74 173.97,84.74 174.12,84.58 174.12,84.19 172.99,83.06 171.31,83.06 171.16,83.21 171.16,84.95 171.37,85.16 171.37,88.56 171.8,89 172.2,89
+3V_S5 on TOP (solid shape): outline of 93 points within 155.86,79.39 160.81,81.78
+3V_S5 on TOP (solid shape): 166.4,74.52 166.4,74.13 166.39,74.09 166.36,74.08 166.01,73.77 166.12,73.32 166.25,73.2 166.27,73.16 166.25,73.12 166.16,73.03 157.44,73.03 157.18,73.13 156.91,73.02 156.75,73.02 156.42,72.69 155.39,72.69 155.23,72.53 155.14,72.5 155.06,72.57 154.72,72.82 154.35,72.59 151.54,72.59 150.87,71.92 150.87,71.41 150.14,70.68 149.64,70.68 149.48,70.84 149.48,71.58 152.29,74.4 153.58,74.4 153.66,74.36 153.68,74.27 153.86,73.86 154.31,73.91 154.38,73.94 154.45,73.91 154.9,73.86 155.08,74.27 155.1,74.36 155.18,74.4 161.54,74.4 161.86,74.72 166.2,74.72
+3V_S5 on BOTTOM (solid shape): 191.47,102.56 191.47,101.03 192,100.5 192,99.91 191.86,99.76 190.82,99.76 190.67,99.91 190.67,102.6 190.73,102.66 191.37,102.66
+3V_S5 on SVCC (solid shape): outline of 412 points within 146.84,80.46 184.56,112.99
+3V_S5 on IN1 (solid shape): outline of 454 points within 158.6,80.61 172.06,93.34
+3V_S5 on IN2 (solid shape): 36.02,42.96 36.02,41.88 35.84,41.7 35.34,41.7 35.01,42.03 35.01,43.33 35.11,43.43 35.55,43.43
+3V_S5 on IN2 (solid shape): 151.01,56.53 151.01,55.43 150.74,55.16 150.05,55.16 149.89,55.33 149.89,56.56 150.09,56.76 150.78,56.76
+3V_S5 on IN2 (solid shape): 166.76,83.94 166.76,80.2 166.72,80.13 166.64,80.1 166.45,80.09 166.28,80 166.13,79.68 166.26,79.34 166.34,79.26 166.34,76.32 165.91,75.92 166.37,75.54 166.72,75.19 166.72,74.35 166.45,74.09 164.65,74.09 164.27,74.47 164.27,79.58 164.28,79.67 164.27,79.76 164.27,80.65 164.27,80.67 164.28,80.69 164.33,80.73 164.33,83.55 165.13,84.35 166.35,84.35
+3V_S5 on IN2 (solid shape): outline of 86 points within 166.9,87.42 169.35,89.76
+3V_S5 on IN2 (solid shape): outline of 136 points within 171.39,88.27 174.05,93.67
+3V_S5 on IN2 (solid shape): outline of 251 points within 176.13,92.07 180.27,98.57
+3V_TPM_VDD on TOP (solid shape): 184.9,69.28 184.9,68.92 184.88,68.88 184.84,68.86 184.42,68.86 184.23,68.67 184.23,68.18 184.2,68.09 184.19,68.01 184.19,67.39 184.14,67.33 183.89,67.33 183.85,67.35 183.84,67.38 183.84,68.66 183.84,68.66 183.84,69.31 183.9,69.37 184.8,69.37
+3V_TPM_VDD on BOTTOM (solid shape): 182.28,78.62 182.28,74.62 182.13,74.47 180.8,74.47 180.65,74.62 180.65,75.57 180.28,75.94 180.28,76.28 180.65,76.64 180.65,77.69 180.9,77.69 180.9,77.63 180.92,77.58 180.94,77.53 180.97,77.48 181.01,77.44 181.05,77.4 181.09,77.37 181.14,77.35 181.2,77.33 181.25,77.32 181.31,77.32 181.36,77.33 181.42,77.35 181.47,77.37 181.51,77.4 181.56,77.44 181.59,77.48 181.62,77.53 181.64,77.58 181.66,77.63 181.66,77.69 181.66,77.75 181.65,77.8 181.63,77.85 181.61,77.9 181.57,77.95 181.54,77.99 181.49,78.02 181.44,78.05 181.39,78.07 181.34,78.08 181.28,78.09 181.22,78.08 181.17,78.07 181.12,78.05 181.07,78.02 181.03,77.99 180.99,77.95 180.95,77.9 180.93,77.85 180.91,77.8 180.9,77.75 180.9,77.69 180.65,77.69 180.65,78.18 181.45,78.98 181.93,78.98
+3VPCU on TOP (solid shape): 91.6,32.3 91.6,31.59 91.44,31.44 89.87,31.44 89.69,31.62 89.69,32.36 89.84,32.5 91.39,32.5
+3VPCU on TOP (solid shape): 62.23,11.63 62.23,5.91 62.24,5.91 62.24,5.86 62.11,5.73 61.65,5.73 61.31,6.14 60.96,6.48 60.94,6.49 60.94,6.52 60.94,11.63 61.19,11.88 61.98,11.88
+3VPCU on TOP (solid shape): 155.23,79.51 155.23,78.34 155.11,78.23 154.06,78.23 154.05,78.22 154.03,78.22 153.78,78.1 153.67,77.86 153.67,77.84 153.29,77.46 152.66,77.46 152.45,77.67 152.45,78.33 153.84,79.72 155.01,79.72
+3VPCU on TOP (solid shape): 161.91,50.73 161.91,49.91 161.93,49.9 161.93,49.35 162.37,48.9 163,48.9 163.22,48.68 163.22,47.36 162.67,46.81 160.4,46.81 160.27,46.93 160.27,47.4 161.73,47.4 161.73,47.35 161.74,47.29 161.76,47.24 161.78,47.19 161.81,47.14 161.85,47.1 161.9,47.07 161.94,47.04 162,47.02 162.05,47.01 162.11,47.01 162.16,47.01 162.22,47.02 162.27,47.04 162.32,47.07 162.36,47.1 162.4,47.14 162.43,47.19 162.46,47.24 162.48,47.29 162.49,47.35 162.49,47.4 162.48,47.46 162.47,47.51 162.45,47.56 162.42,47.61 162.38,47.65 162.34,47.69 162.29,47.72 162.24,47.75 162.19,47.76 162.14,47.77 162.08,47.77 162.02,47.76 161.97,47.75 161.92,47.72 161.87,47.69 161.83,47.65 161.8,47.61 161.77,47.56 161.75,47.51 161.73,47.46 161.73,47.4 160.27,47.4 160.27,48.39 160.58,48.7 160.58,49.09 160.41,49.27 159.92,49.27 159.77,49.12 158.78,49.12 158.6,49.29 158.6,50.05 158.83,50.28 160.91,50.28 161.09,50.46 161.09,50.87 161.17,50.95 161.7,50.95
+3VPCU on TOP (solid shape): outline of 128 points within 159.87,140.15 169.85,144.75
+3VPCU on BOTTOM (solid shape): 169.75,145.15 169.75,143.35 169.45,143.05 168.18,143.05 168,143.22 168,145.08 168.25,145.33 169.57,145.33
+3VPCU on BOTTOM (solid shape): 190.53,91.79 190.53,91.12 189.14,89.73 188.39,89.73 188.28,89.84 188.28,91.04 189.28,92.04 190.28,92.04
+3VPCU on BOTTOM (solid shape): 34.25,104.66 34.25,103.37 35.18,102.43 35.18,101.85 35.13,101.8 34.07,101.8 33.53,102.33 33.53,104.69 33.68,104.84 34.06,104.84
+3VPCU on BOTTOM (solid shape): 190.83,110.51 190.83,107.69 190.76,107.61 189.23,107.61 189.08,107.76 189.08,109.64 189.21,109.77 189.54,109.77 189.77,110 189.77,110.71 189.82,110.76 190.58,110.76
+3VPCU on BOTTOM (solid shape): 173.18,70.63 173.18,70 173.11,69.92 172.77,69.92 171.01,68.17 166.78,68.17 166.6,68.34 166.6,69.18 166.81,69.39 170.34,69.39 171.46,70.51 171.48,70.51 171.75,70.78 173.03,70.78
+3VPCU on BOTTOM (solid shape): 59.77,58.36 61.42,58.36 65.46,54.32 65.46,45.92 64.04,44.49 61.57,44.49 61.14,44.93 61.14,48.23 62.11,49.19 62.11,50.41 61.83,50.69 60.68,50.69 60.56,50.56 60.56,49.52 57.74,46.7 55.42,46.7 55.07,47.06 55.07,58.16 55.93,59.02 59.11,59.02
+3VPCU on BOTTOM (solid shape): 162.01,144.57 162.36,144.34 162.71,144.57 163.39,144.57 163.56,144.4 163.56,142.6 163.39,142.43 162.5,142.43 162.18,142.11 162.18,140.66 162.16,140.63 161.88,140.63 161.88,141.67 161.68,141.67 161.68,140.63 161.32,140.63 161.19,140.51 161.19,140.18 160.12,140.18 159.87,140.43 159.87,143.94 160.5,144.57
+3VPCU on BOTTOM (solid shape): 153.64,50.79 153.67,50.78 153.69,50.76 154.04,50.45 154.48,50.6 154.49,50.61 154.52,50.62 154.92,50.62 155.88,49.65 158.5,49.65 159.16,50.31 160.28,50.31 160.46,50.13 160.46,49.73 159.31,48.58 155.45,48.58 154.7,49.33 154.42,49.33 154.33,49.43 154.09,49.57 153.78,49.58 153.76,49.59 153.7,49.65 152.68,49.65 152.56,49.78 152.56,50.44 152.9,50.78 153.36,50.78 153.37,50.79
+3VPCU on SVCC (solid shape): outline of 364 points within 59.08,30.3 157.25,80.14
+3VPCU on IN1 (solid shape): 61.93,11.65 61.93,10.48 61.73,10.28 61.19,10.28 60.96,10.51 60.96,11.63 61.19,11.85 61.73,11.85
+3VPCU on IN1 (solid shape): 168,69.08 168,68.32 167.67,67.99 166.22,67.99 165.89,68.32 165.89,69.13 166.12,69.36 167.72,69.36
+3VPCU on IN1 (solid shape): 169.88,143.66 169.88,141.91 169.75,141.78 168.71,141.78 168.05,142.44 168.05,143.91 168.38,144.24 169.3,144.24
+3VPCU on IN1 (solid shape): 34.68,102.81 34.68,101.82 34.54,101.68 34.36,101.68 34.35,101.67 33.1,101.67 32.9,101.87 32.9,102.61 33.3,103.02 34.47,103.02
+3VPCU on IN1 (solid shape): 189.88,110.49 189.88,108.07 189.87,108.05 189.86,108.04 189.5,107.68 189.14,107.68 188.72,108.1 188.72,110.48 189.07,110.82 189.54,110.82
+3VPCU on IN1 (solid shape): 189.23,90.9 189.23,90.38 187.67,88.82 186.26,88.82 185.22,89.86 185.22,90.14 185.35,90.26 186.19,90.26 187.2,91.28 188.86,91.28
+3VPCU on IN1 (solid shape): 173.56,71.47 173.56,69.97 173.32,69.72 172.95,69.72 172.8,69.58 171.97,69.58 171.76,69.79 171.76,70.78 172.65,71.67 173.36,71.67
+3VPCU on IN1 (solid shape): 161.98,50.67 161.98,49.75 161.42,49.19 160.39,49.19 160.18,49.26 159.96,49.19 159.57,49.19 159.34,49.42 159.34,50.16 159.52,50.34 159.78,50.34 160.01,50.3 160.23,50.41 160.43,50.41 161.01,51 161.65,51
+3VPCU_EC on TOP (solid shape): 166.21,51.03 166.21,50.72 164.84,49.35 164.84,48.4 164.83,48.4 164.83,47.25 164.57,46.98 163.94,46.98 163.57,47.35 163.57,50.64 163.57,50.64 163.57,50.92 163.59,50.96 163.62,50.97 165.42,50.97 165.64,51.2 166.04,51.2
+3VPCU_EC on TOP (solid shape): 186.6,60.95 186.6,59.03 187.43,58.2 187.43,56.86 187.09,56.51 186.69,56.51 186.51,56.7 186.51,57.52 185.6,58.43 185.6,59.25 185.5,59.35 184.08,59.35 184.04,59.37 184.03,59.4 184.03,59.43 183.24,59.43 183.2,59.44 183.19,59.48 183.19,59.58 183.2,59.62 183.24,59.63 184.03,59.63 184.06,59.66 185.37,59.66 185.6,59.89 185.6,61.02 185.69,61.11 186.44,61.11
+3VPCU_EC on TOP (solid shape): 171.99,65.26 171.99,63.68 171.97,63.65 171.93,63.63 171.82,63.63 171.7,63.75 171.7,63.97 171.7,63.98 171.58,64.43 171.12,64.37 171.04,64.34 170.97,64.37 170.55,64.78 170.55,65.58 170.66,65.68 171.56,65.68
+3VPCU_EC on BOTTOM (solid shape): 187.07,57.83 187.09,57.82 187.11,57.81 187.69,57.23 187.69,56.01 187.38,55.69 186.82,55.69 186.68,55.83 186.68,57.7 186.81,57.83
+3VPCU_EC on BOTTOM (solid shape): 177.31,48.6 177.33,48.59 177.35,48.58 177.61,48.44 177.9,48.54 177.97,48.56 178.04,48.53 178.16,48.41 178.16,47.68 177.7,47.22 176.06,47.22 175.98,47.3 175.98,48.27 176.3,48.6
+3VPCU_EC on IN1 (solid shape): 165.53,51.63 165.53,50.91 164.38,49.76 164.02,49.76 163.95,49.84 163.95,51.42 164.55,52.02 165.13,52.02
+5V on TOP (solid shape): 189.38,41.01 189.38,38.14 188.7,37.46 187.61,37.46 187.3,37.76 187.3,40.94 187.63,41.27 189.13,41.27
+5V on TOP (solid shape): 55.22,59.84 57.02,59.84 57.06,59.8 57.06,57.29 56.9,57.13 52.25,57.13 51.97,57.41 51.97,59.2 53.22,60.44 54.61,60.44
+5V on TOP (solid shape): 19.92,107.52 19.92,105.32 19.68,105.09 19.16,105.09 18.93,105.32 18.93,106.01 17.3,107.64 16.79,107.64 16.66,107.77 16.66,109.16 16.67,109.16 16.67,109.49 16.81,109.63 17.81,109.63
+5V on TOP (solid shape): 30.59,48.3 30.59,48.29 30.87,47.96 31.28,48.11 31.29,48.12 31.32,48.13 32.08,48.13 32.26,47.95 32.26,46.91 31.66,46.31 30.15,46.31 28.78,47.67 28.78,48.41 29.29,48.91 29.98,48.91
+5V on TOP (solid shape): 25.1,65.16 25.1,64.13 24.71,63.73 23.87,63.73 23.86,63.74 23.66,63.77 23.47,63.74 23.46,63.73 23.26,63.73 22.46,64.53 21.26,64.53 20.98,64.25 20.98,62.6 20.71,62.32 20.48,62.32 20.1,61.94 20.1,61.69 18.16,59.76 18.16,59.35 17.55,58.74 16.16,58.74 16.13,58.72 16.11,58.72 15.04,58.72 14.89,58.87 14.89,59.45 15.27,59.84 15.93,59.84 16.26,60.17 16.26,60.65 16.74,61.13 17.3,61.13 18.26,62.09 18.26,63.62 18.42,63.77 18.42,65.4 19.26,66.24 24.03,66.24
+5V on TOP (solid shape): outline of 155 points within 191.26,97.43 194.51,107.59
+5V on BOTTOM (solid shape): 44.72,24.53 44.72,23.32 44.38,22.98 42.85,22.98 42.42,22.55 42.42,21.84 42.37,21.79 40.92,21.79 40.42,22.29 40.42,24.68 40.62,24.88 42.4,24.88 42.57,25.06 42.57,25.77 42.35,26 41.3,26 41.1,26.21 41.1,26.87 41.17,26.93 42.33,26.93
+5V on BOTTOM (solid shape): outline of 114 points within 19.59,61.41 31.47,65.65
+5V on SVCC (solid shape): outline of 643 points within 51.72,19.5 193.96,120.08
+5V on IN1 (solid shape): 42.03,27.75 42.03,27.09 42.83,26.28 42.83,24.04 42.45,23.66 42.45,23.26 42.32,23.13 41.18,23.13 41.09,23.22 41.09,26.65 40.8,26.94 40.78,26.97 40.8,27.01 40.83,27.03 41.07,27.51 40.61,27.78 40.52,27.81 40.49,27.91 40.46,28.17 40.26,28.35 39.95,28.35 39.74,28.12 39.72,28.09 39.68,28.08 39.64,28.09 38.52,29.21 38.52,29.55 38.21,29.86 37.62,29.86 37.27,29.51 36.81,29.51 36.12,30.19 36.12,31.08 36.68,31.64 38.13,31.64
+5V on IN1 (solid shape): outline of 698 points within 27.04,34.08 32.95,65.45
+5V on IN1 (solid shape): outline of 1463 points within 12.4,61.99 32.74,109.6
+5V on IN2 (solid shape): 18.12,109.8 18.21,109.75 18.21,109.64 18.2,109.26 18.52,109.05 18.59,109.02 18.62,108.95 18.62,108.83 18.29,108.5 16.44,108.5 16.18,108.76 16.18,109.62 16.36,109.8
+5V_HDD on TOP (solid shape): 196.32,52.32 196.32,49.12 196.17,48.96 195.58,48.96 194.78,48.16 194.78,46.65 192.97,44.84 192.07,44.84 191.84,44.62 191.84,43.27 192.02,43.09 192.16,43.09 192.31,42.94 192.31,42.61 192.46,42.46 192.94,42.46 193.76,41.65 193.76,40.56 193.35,40.15 192.41,40.15 192.08,40.48 190.41,40.48 189.99,40.9 189.76,41.13 189.14,41.76 187.74,41.76 187.74,43.29 189.05,44.6 189.05,46.69 189.34,46.97 192.72,46.97 193.3,47.56 193.3,51.53 194.14,52.37 196.27,52.37
+5V_HDD on BOTTOM (solid shape): outline of 176 points within 188.72,23.56 194.54,42.89
+5V_KB on BOTTOM (solid shape): 153.37,65.73 153.37,64.81 153.54,64.64 153.59,64.58 153.65,64.53 153.93,64.25 155.02,64.25 155.39,63.89 155.39,62.85 155.24,62.69 153.53,62.69 151.92,64.31 151.52,64.31 151.36,64.46 151.36,65.07 150.75,65.68 150.75,66.11 151.06,66.41 152.68,66.41
+5V_KB_R on BOTTOM (solid shape): 153.79,70.37 154.05,70.1 154.05,67.79 152.91,66.64 151.67,66.64 151.51,66.79 151.51,67.14 151.85,67.48 151.85,67.5 151.86,67.51 151.95,67.77 151.85,68.02 151.85,69.33 151.86,69.37 151.9,69.38 152.27,69.71 152,70.13 151.93,70.21 151.96,70.3 152.05,70.4 153.79,70.4
+5V_ODD on TOP (solid shape): 197.59,104.84 198.5,104.84 198.5,104.84 198.96,104.84 199.45,105.33 200.33,105.33 200.64,105.02 200.64,104.06 199.88,103.29 199.59,103.29 198.85,102.55 198.61,102.55 198.48,102.51 198.4,102.41 198.39,102.39 198.36,102.38 197.88,102.38 197.85,102.39 197.85,102.41 197.76,102.51 197.64,102.55 197.34,102.55 197.18,102.49 197.11,102.33 197.11,102.05 197.13,101.95 197.19,101.87 197.22,101.8 197.19,101.72 197.13,101.64 197.11,101.55 197.11,101.41 197.11,100.95 197.84,100.22 197.84,99.51 197.14,98.81 195.4,98.81 194.82,99.4 194.82,100.98 194.8,100.98 194.77,101.01 194.77,101.39 194.44,101.72 194.44,103.24 194.24,103.45 194.24,105.17 194.67,105.61 196.83,105.61
+5V_ODD on BOTTOM (solid shape): 196.96,107.11 196.96,105.45 197.48,104.93 199.38,104.93 199.75,105.3 200.43,105.3 200.59,105.14 200.59,103.61 200.34,103.36 199.66,103.36 198.22,101.92 194.92,101.92 194.51,102.34 194.51,102.35 194.06,102.8 194.06,107.28 194.26,107.49 196.59,107.49
+5V_S5 on TOP (solid shape): 50.79,64.78 50.79,62.59 50.72,62.52 49.46,62.52 49.39,62.45 47.53,62.45 47.15,62.83 47.15,64.53 47.73,65.12 50.45,65.12
+5V_S5 on TOP (solid shape): 127.38,188.49 127.38,187.57 127.36,187.55 126.78,187.55 126.53,187.79 126.53,188.68 126.27,188.94 125.28,188.94 125.26,188.96 125.26,189.2 126.67,189.2
+5V_S5 on TOP (solid shape): 38.17,43.87 38.17,42.67 37.95,42.45 36.59,42.45 35.95,43.1 35.74,43.1 35.71,43.11 35.69,43.14 35.31,43.48 34.93,43.14 34.91,43.11 34.88,43.1 34.8,43.1 34.29,42.59 28.93,42.59 28.45,43.07 25.66,43.07 25.19,43.54 24.32,43.54 24.08,43.78 24.08,45.08 24.21,45.2 29.04,45.2 29.49,44.75 32.26,44.75 32.96,45.45 36.59,45.45
+5V_S5 on BOTTOM (solid shape): 143.21,18.2 143.21,17.7 142.99,17.48 142.01,17.48 141.81,17.67 141.81,18.02 141.82,18.02 141.84,18.13 141.83,18.25 141.82,18.26 141.83,18.28 141.94,18.39 143.02,18.39
+5V_S5 on BOTTOM (solid shape): 57.4,85.58 57.8,85.58 58.07,85.31 58.07,84.73 57.84,84.5 56.1,84.5 56.1,84.51 55.39,84.51 55.35,84.55 55.35,84.68 55.38,84.7 55.4,84.72 55.43,84.71 55.45,84.71 56.1,84.71 56.1,84.72 56.13,84.75 56.42,84.75 56.62,84.96 56.62,85.31 56.9,85.59 57.38,85.59
+5V_S5 on BOTTOM (solid shape): 184.01,21.37 184.01,17.8 183.91,17.69 182.6,17.69 182.3,17.99 183.9,17.99 183.9,18.19 182.6,18.19 182.6,17.99 182.3,17.99 182.24,18.04 181.93,18.04 181.52,17.63 181.52,16.1 180.57,15.16 179.35,15.16 179.07,15.44 179.07,16.55 180.14,17.62 180.14,18.29 180.34,18.49 183.9,18.49 183.9,18.69 182.6,18.69 182.6,18.49 180.34,18.49 180.84,18.99 183.9,18.99 183.9,19.19 182.6,19.19 182.6,18.99 180.84,18.99 180.85,19 180.85,19.49 183.9,19.49 183.9,19.69 182.6,19.69 182.6,19.49 180.85,19.49 180.85,19.99 183.9,19.99 183.9,20.19 182.6,20.19 182.6,19.99 180.85,19.99 180.85,20.31 181.03,20.49 183.9,20.49 183.9,20.69 182.6,20.69 182.6,20.49 181.03,20.49 181.53,20.99 183.9,20.99 183.9,21.19 182.6,21.19 182.6,20.99 181.53,20.99 182.05,21.51 183.87,21.51
+5V_S5 on SVCC (solid shape): outline of 481 points within 37.37,12.12 181.51,65.73
+5VPCU on TOP (solid shape): 39.98,52.32 39.98,51.35 39.65,51.02 39.17,51.02 38.99,51.2 38.99,51.99 39.45,52.44 39.86,52.44
+5VPCU on TOP (solid shape): 54,35.27 54,34.23 53.78,34 53.27,34 53.14,34.13 53.14,35.27 53.4,35.53 53.75,35.53
+5VPCU on TOP (solid shape): 63.61,9.31 63.61,7.97 63.53,7.74 63.61,7.51 63.61,6.19 63.15,5.73 62.59,5.73 62.38,5.94 62.38,7.02 62.38,7.03 62.38,9.46 62.59,9.67 63.25,9.67
+5VPCU on TOP (solid shape): 60.38,74.59 60.38,68.95 58.96,67.53 58.96,60.85 58.58,60.48 57.99,60.48 57.99,60.48 54.91,60.48 54.15,61.23 51.59,61.23 51.44,61.38 51.44,64.79 51.56,64.92 53.12,64.92 54.21,66 54.21,67.15 56.8,69.74 56.8,74.54 57.13,74.87 60.1,74.87
+5VPCU on BOTTOM (solid shape): 60.38,74.14 60.38,68.8 58.75,67.18 58.75,63.8 58.55,63.59 54.54,63.59 54.21,63.92 54.21,67.15 56.8,69.74 56.8,74.54 57.13,74.87 59.64,74.87
+5VPCU on BOTTOM (solid shape): 54,35.27 54,32.78 53.95,32.73 53.95,31.92 53.93,31.9 53.8,31.9 53.75,31.95 53.75,32.86 53.14,33.47 53.14,35.27 53.4,35.53 53.75,35.53
+5VPCU on IN1 (solid shape): 54,35.27 54,34.23 53.78,34 53.29,34 53.14,34.16 53.14,35.27 53.4,35.53 53.75,35.53
+5VPCU on IN2 (solid shape): 61.15,9.91 63.21,9.91 63.48,9.64 63.48,8.91 63.33,8.76 60.08,8.76 59.67,9.16 59.67,10.31 59.82,10.46 60.61,10.46
+A3VPCU on TOP (solid shape): 187.66,61.44 187.66,60.42 187.51,60.27 186.77,60.27 186.73,60.31 186.73,61 186.67,61.06 186.67,61.44 186.8,61.57 187.53,61.57
+A3VPCU on TOP (solid shape): 188.02,52.72 188.02,51.73 187.63,51.34 185.08,51.34 184.66,51.76 184.66,52.57 184.84,52.75 184.87,52.75 184.89,52.73 185.29,52.73 185.8,52.22 185.8,52.21 185.88,52.07 186.02,52.01 186.13,52 186.17,52 186.98,52 187.12,52.14 187.2,52.14 187.3,52.24 187.3,52.38 187.32,52.48 187.32,52.58 187.31,52.59 187.32,52.61 187.61,52.9 187.84,52.9
+A3VPCU on IN1 (solid shape): outline of 112 points within 186.58,52.34 189.31,61.74
+V1.05M_VCCASW on TOP (solid shape): outline of 100 points within 163.33,101.76 177.3,105.85
+V1.05M_VCCASW on BOTTOM (solid shape): 164.04,104.88 164.31,104.74 164.6,104.84 164.61,104.86 164.81,104.86 164.85,104.82 164.85,104.67 164.82,104.66 164.63,104.34 164.79,104.01 164.85,103.94 164.85,103.04 164.82,103.02 164.62,102.69 164.82,102.35 164.85,102.33 164.85,101.96 164.64,101.75 164.58,101.73 164.1,101.73 164.09,101.73 164.01,101.75 163.93,101.73 163.92,101.73 163.44,101.73 163.43,101.73 163.35,101.75 163.27,101.73 163.26,101.73 162.78,101.73 162.72,101.74 162.66,101.74 162.63,101.74 162.42,101.96 162.42,102.3 162.46,102.32 162.68,102.48 162.73,102.75 162.73,102.79 162.76,102.82 162.78,102.83 162.96,103.15 162.65,103.37 162.63,103.41 162.62,103.46 162.62,103.54 162.63,103.59 162.65,103.63 162.86,103.68 162.97,103.87 162.99,103.91 163.03,103.93 163.32,104.07 163.39,104.38 163.39,104.41 163.43,104.45 163.44,104.45 163.58,104.56 163.63,104.74 163.63,104.77 163.76,104.91 164.02,104.91
+V1.05M_VCCASW on IN1 (solid shape): outline of 159 points within 163.48,102.44 175.4,104.55
+V1.05S_PCH_VCC on TOP (solid shape): 146.05,98.49 146.05,96.84 145.8,96.59 144.68,96.59 144.35,96.26 144.35,95.85 144.17,95.67 140.75,95.67 139.96,96.47 139.96,98.14 140.79,98.98 145.57,98.98
+V1.05S_PCH_VCC on TOP (solid shape): 161.04,105.55 161.13,105.57 161.78,105.57 162.03,105.31 162.03,104.52 161.96,104.45 161.96,101.86 161.88,101.78 161.53,101.78 161.48,101.84 161.48,102.32 161.35,102.44 160.87,102.44 160.76,102.54 160.76,102.82 160.89,102.95 161.32,102.95 161.4,103.03 161.4,103.97 161.35,104.02 160.94,104.02 160.79,104.17 160.79,104.55 160.87,104.63 160.87,105.52 160.92,105.57
+V1.05S_PCH_VCC on BOTTOM (solid shape): 162.25,106.42 162.2,106.36 162.18,106.36 162.11,105.55 162.82,105.94 162.82,105.97 162.94,106.09 163.09,106.09 163.16,106.04 163.23,106.01 163.28,105.71 163.52,105.51 163.56,105.49 163.56,105.24 163.39,105.07 163.37,105.07 163.12,104.99 163,104.77 162.66,104.6 162.57,104.24 162.34,103.96 162.47,103.62 162.49,103.61 162.49,103.39 162.47,103.37 162.38,103.27 162.34,103.14 162,102.97 161.91,102.61 161.77,102.52 161.69,102.39 161.68,102.37 161.4,102.09 160.71,102.09 160.51,102.29 160.51,103.92 160.75,104.16 160.75,104.48 160.54,104.7 160.54,105.11 160.61,105.18 160.64,105.18 160.92,105.24 161.06,105.48 161.39,105.65 161.49,106.01 161.64,106.11 161.72,106.28 161.72,106.29 161.96,106.53 162.14,106.53
+V1.05S_PCH_VCC on IN1 (solid shape): outline of 1355 points within 143.57,95.7 163.4,105.39
+V1.05S_VCC_EXP on TOP (solid shape): outline of 400 points within 152.8,101.73 160,105.88
+V1.05S_VCC_EXP on BOTTOM (solid shape): 144,105.81 144,104.95 144.15,104.79 145.94,104.79 146.71,104.02 146.71,102.99 146.46,102.74 146.46,100.42 145.57,99.54 142.78,99.54 142.63,99.69 142.63,103.8 143.06,104.23 143.06,105.96 143.29,106.19 143.62,106.19
+V1.05S_VCC_EXP on BOTTOM (solid shape): 159.82,104.55 159.87,104.5 159.94,104.46 160,104.39 160,104.36 160,104.31 160,104.26 160,104.23 159.94,104.16 159.93,104.16 159.77,103.96 159.85,103.71 159.85,103.33 159.55,103.03 159.54,103.02 159.34,102.67 159.56,102.34 159.6,102.32 159.6,102.24 159.42,102.06 158.43,102.06 158.38,102.08 158,102.47 158,102.65 158,102.69 158,102.96 158.01,102.98 158.03,103.34 157.68,103.41 157.66,103.41 157.36,103.41 157.34,103.41 157.21,103.45 157.08,103.41 157.07,103.41 156.76,103.41 156.69,103.48 156.68,103.56 156.68,103.76 156.58,103.92 156.57,103.94 156.57,103.96 156.47,104.05 156.47,104.35 156.55,104.42 159.42,104.42 159.44,104.44 159.45,104.45 159.54,104.48 159.61,104.55 159.63,104.58 159.8,104.58
+V1.05S_VCC_EXP on IN1 (solid shape): outline of 1327 points within 143.21,101.93 159.98,110.65
+V1.05S_VCC_SSCFF on TOP (solid shape): 163.28,108.56 163.28,108.48 163.26,108.43 163.26,108.38 163.26,108.08 163.26,108.04 163.28,107.99 163.28,107.32 162.39,106.43 162.01,106.43 161.96,106.48 161.96,106.96 162.21,107.21 162.24,107.2 162.71,107.41 162.55,107.89 162.52,107.91 162.52,108.49 162.7,108.67 163.18,108.67
+V1.05S_VCC_SSCFF on BOTTOM (solid shape): 163.51,108.21 163.51,107.93 163.28,107.7 163.28,107.5 162.8,107.01 162.62,107.01 162.54,107.09 162.54,107.22 162.75,107.42 162.75,107.7 162.54,107.9 162.54,108.28 162.9,108.64 163.08,108.64
+V1.05S_VCCPCPU on BOTTOM (solid shape): 160.33,100.66 160.33,100.28 160.08,100.03 160.08,99.95 159.96,99.84 159.86,99.84 159.64,99.61 159.28,99.61 159.18,99.7 159.18,99.9 159.25,99.97 159.25,100.07 160,100.82 160.18,100.82
+V1.05S_VCCSSCF100 on TOP (solid shape): 161.45,108.51 161.45,107.85 161.45,107.83 161.44,107.82 161.33,107.64 161.34,107.43 161.33,107.34 161.25,107.29 160.31,107.29 160.08,107.52 160.08,108.21 160.49,108.61 161.35,108.61
+V1.05S_VCCSSCF100 on TOP (solid shape): 163.86,116.67 163.86,115.75 163.83,115.71 163.81,115.71 163.19,115.09 163.19,114.72 162.95,114.48 162.13,114.48 161.95,114.67 161.95,115 162.21,115.18 162.24,115.5 162.24,115.54 162.26,115.57 162.39,115.7 162.39,116.52 162.41,116.59 162.42,116.68 162.43,116.7 162.47,116.74 163.79,116.74
+V1.05S_VCCSSCF100 on BOTTOM (solid shape): 161.55,108.11 161.55,107.95 161.3,107.7 161.3,107.4 161.5,107.19 161.5,106.96 161.3,106.76 160.84,106.76 160.75,106.85 160.74,106.87 160.66,107 160.54,107.08 160.53,107.09 160.13,107.49 160.13,107.67 160.18,107.72 160.18,107.72 160.27,107.79 160.32,107.89 160.32,107.91 160.65,108.23 161.43,108.23
+V1.05S_VCCSSCF100 on IN1 (solid shape): outline of 729 points within 158.35,107.24 163.15,115.14
+V1.05S_VCCUSBCORE on TOP (solid shape): 168.77,120.88 169.54,120.88 169.75,120.67 169.75,119.91 169.15,119.31 167.76,119.31 167.01,120.06 167.01,121.07 167.13,121.2 168.46,121.2
+V1.05S_VCCUSBCORE on TOP (solid shape): 164.57,107.73 164.57,107.34 164.5,107.27 164.07,107.27 163.69,106.89 163.69,106.48 163.63,106.43 163.25,106.43 163.2,106.48 163.2,106.97 163.43,107.2 163.43,107.7 163.56,107.83 164.47,107.83
+V1.05S_VCCUSBCORE on BOTTOM (solid shape): 164.55,107.69 164.57,107.69 164.62,107.64 164.62,107.61 164.66,107.4 164.8,107.24 164.83,107.22 164.83,106.91 164.51,106.6 164.46,106.6 164.05,106.19 163.97,106.19 163.92,106.23 163.88,106.26 163.2,106.94 163.2,107.17 163.43,107.4 163.43,107.65 163.56,107.78 163.8,107.78 163.89,107.69 164.13,107.69 164.24,107.8 164.44,107.8
+V1.05S_VCCUSBCORE on IN1 (solid shape): outline of 865 points within 162.96,107.31 169.22,120.44
+V3.3A_VCCPSUS on BOTTOM (solid shape): 181.03,115.21 181.03,114.57 181.23,114.37 181.23,113.1 180.65,112.51 180.65,111.14 180.49,110.98 179.1,110.98 178.89,111.19 178.89,113.88 179.45,114.44 179.45,114.96 179.71,115.23 181.01,115.23
+V3.3A_VCCPSUS on IN1 (solid shape): outline of 519 points within 160.05,103.51 179.91,112.9
+V3.3A_VCCPUSB on BOTTOM (solid shape): 165.47,106.42 165.47,106.27 165.44,106.25 165.38,106.19 165.32,106.11 165.26,106.05 165.26,105.85 165.3,105.8 165.31,105.79 165.38,105.68 165.48,105.6 165.51,105.58 165.51,104.65 165.48,104.64 165.44,104.61 165.39,104.55 165.31,104.55 165.29,104.57 165.21,104.64 165.11,104.69 165.09,104.69 164.98,104.8 164.98,104.87 164.87,104.98 164.76,104.98 164.75,104.99 164.67,105 164.59,104.99 164.57,104.98 164.5,104.94 164.45,104.9 164.42,104.88 164.27,104.88 164.09,105.06 164.09,105.26 164.13,105.28 164.26,105.4 164.29,105.57 164.28,105.6 164.75,106.07 164.77,106.08 164.87,106.14 164.93,106.25 164.94,106.26 165.18,106.51 165.39,106.51
+V3.3A_VCCPUSB on IN1 (solid shape): outline of 1017 points within 164.09,104.84 177.8,113.15
+V3.3M_VCCPSPI on IN2 (solid shape): 161.62,99.94 161.62,99.76 161.48,99.62 161.45,99.62 161.44,99.58 161.4,99.57 161.08,99.34 161.16,98.96 161.19,98.88 161.05,98.56 161.19,98.23 161.06,97.91 161.2,97.58 161.17,97.51 161.08,97.35 161.08,97.16 161.09,97.13 160.82,96.86 160.82,96.85 160.78,96.76 160.69,96.75 160.18,96.37 160.69,95.99 160.78,95.98 160.82,95.89 160.82,95.77 162.44,94.14 162.44,93.85 162.31,93.72 161.9,93.72 161.5,94.12 161.5,94.31 160.76,95.05 160.57,95.05 159.88,95.74 159.88,96.77 160.04,96.93 160.24,96.93 160.71,97.01 160.68,97.48 160.65,97.55 160.68,97.63 160.79,97.88 160.68,98.14 160.66,98.19 160.66,98.24 160.85,98.52 160.72,98.84 160.69,98.9 160.71,98.98 160.79,99.16 160.75,99.36 160.75,99.37 160.75,99.51 160.86,99.63 160.86,99.94 160.99,100.07 161.5,100.07
+V3.3S_VCC_GIO on IN2 (solid shape): outline of 207 points within 165.35,107.26 168.21,111.45
+V3.3S_VCCPCORE on BOTTOM (solid shape): 161.32,101.12 161.32,101.09 161.36,100.88 161.52,100.72 161.55,100.7 161.55,100.46 161.32,100.23 161.31,100.23 161.14,100.13 161.04,99.96 161.04,99.95 160.81,99.72 160.75,99.68 160.7,99.64 160.34,99.64 160.18,99.8 160.18,99.87 160.21,99.9 160.21,99.96 160.21,99.98 160.46,100.23 160.46,100.72 160.43,100.74 160.43,100.82 160.83,101.22 160.88,101.24 160.91,101.27 160.96,101.32 161.11,101.32
+V3.3S_VCCPCORE on IN1 (solid shape): outline of 509 points within 159.72,92.63 163.22,100.4
+V3.3S_VCCPTS on TOP (solid shape): 156.23,110.59 156.25,110.56 156.24,110.53 156.36,110.02 156.87,110.11 156.89,110.12 156.91,110.13 157.17,110.13 157.23,110.07 157.27,110.03 157.33,110 158.09,109.24 158.09,109.21 158.09,109.2 158.16,108.77 158.59,108.69 158.61,108.7 158.64,108.69 159.34,107.99 159.34,107.51 159.13,107.31 158.9,107.31 158.37,107.84 158.04,107.84 157.98,107.9 157.96,107.94 157.98,107.97 157.98,108.51 157.44,108.51 157.4,108.5 157.37,108.51 157.03,108.85 157.03,109.19 156.96,109.35 156.8,109.41 156.52,109.41 156.45,109.4 156.39,109.37 156.38,109.37 156.08,109.37 155.99,109.48 155.91,109.54 155.81,109.64 154.94,109.64 154.66,109.92 154.66,110.56 154.78,110.67 156.15,110.67
+VCC_CPU_XDP on BOTTOM (solid shape): 95,124.2 95.03,124.18 95.05,124.15 95.05,123.84 95.1,123.58 95.25,123.34 95.25,123.33 95.25,121.38 94.97,121.1 93.32,121.1 93.29,121.11 93.27,121.15 93.27,122.1 93.12,122.25 93.12,122.93 94.39,124.2
+VCC_PCH_XDP on BOTTOM (solid shape): 173.01,9.91 173.01,8.88 172.91,8.78 169.98,8.78 169.8,8.96 169.8,9.9 169.93,10.03 172.89,10.03
+VCCAXCK_VRM on TOP (solid shape): 154.07,119.32 154.16,119.27 154.15,119.16 154.3,118.58 154.83,118.86 154.84,118.88 154.85,118.89 154.88,118.91 154.92,118.89 154.93,118.88 159.68,118.88 160.05,118.85 160.28,119.14 162.26,119.14 162.39,119.02 162.39,118.74 161.95,118.31 161.14,118.31 161.11,118.28 161.01,118.28 160.89,118.15 159.74,118.15 159.72,118.13 159.67,118.13 159.52,117.98 158.29,117.98 158.27,117.95 158.09,117.95 157.59,117.44 157.59,116.66 157.38,116.45 155.88,116.45 154.56,117.78 152.65,117.78 152.58,117.85 152.58,119.02 152.89,119.32
+VCCAXCK_VRM on TOP (solid shape): outline of 359 points within 158.61,108.22 160.51,113.6
+VCCAXCK_VRM on IN1 (solid shape): 162.41,118.83 162.41,115.37 162.32,115.28 162.15,115.28 162.03,115.16 161.67,115.16 161.56,115.27 161.56,116.57 161.62,116.63 161.62,118.91 161.81,119.1 162.15,119.1
+VCCAXCK_VRM_R on TOP (solid shape): 160.68,118.03 160.72,118.01 160.74,117.98 160.74,117.62 160.71,117.55 160.64,117.52 160.33,117.33 160.32,116.96 160.32,116.86 160.23,116.81 160.18,116.81 160.16,116.82 160.15,116.83 159.66,116.92 159.5,116.44 159.51,116.39 159.49,116.34 158.46,116.34 158.22,116.58 158.22,117.72 158.35,117.85 159.62,117.85 159.8,118.03
+VCCIN on TOP (solid shape): 82.71,98.9 82.71,86.84 80.73,84.86 79.77,84.11 79.02,83.15 76.97,81.1 75.91,81.1 73.95,79.13 73.3,79.13 73.08,79.35 73.08,90.85 72.71,91.22 71.54,91.22 71.54,91.22 70.85,91.22 70.69,91.38 70.69,97.78 72.69,99.78 81.83,99.78
+VCCIN on TOP (solid shape): outline of 3031 points within 100.53,96.55 124.2,125.03
+VCCIN on BOTTOM (solid shape): outline of 213 points within 64.62,70.48 81.69,101.7
+VCCIN on BOTTOM (solid shape): outline of 2972 points within 100.32,98.75 124.7,118.26
+VCCIN on SVCC (solid shape): outline of 90 points within 66.32,87.32 123.6,133.8
+VCCIN on IN1 (solid shape): outline of 11497 points within 64.9,85.64 125.01,118.2
+VCCIN on IN2 (solid shape): outline of 2576 points within 99.18,98.88 124.7,117.43
+VCCIO_OUT on BOTTOM (solid shape): 91.62,122.07 91.62,120.9 89.59,118.87 88.29,118.87 87.96,118.54 87.96,117.46 88.02,117.41 88.02,116.96 86.03,114.98 84.59,114.98 84.41,115.16 84.41,116.36 90.37,122.32 91.37,122.32
+VCCIOA_OUT on TOP (solid shape): 138.61,109.42 138.61,107.33 138.38,107.1 136.48,107.1 136.02,107.56 136.02,108.76 135.4,109.38 133.65,109.38 132.82,108.55 132.82,108.25 132.55,107.98 132.05,107.98 132.01,108.02 131.93,108.02 130.84,109.11 130.84,109.42 131.27,109.85 132.44,109.85 133.13,110.53 137.49,110.53
+VIN_VCCIN on TOP (solid shape): 55.55,92.65 55.55,89.63 55.78,89.4 55.78,88.08 55.42,87.72 55.42,86.68 55.4,86.66 53.11,86.66 52.66,87.11 52.66,87.14 52.4,87.39 52.4,92.22 52.94,92.75 55.45,92.75
+VIN_VCCIN on TOP (solid shape): 52.76,83.86 52.76,80.87 53.04,80.59 53.04,78.89 52.73,78.58 52.73,77.79 52.66,77.72 50.45,77.72 49.86,78.3 49.86,78.96 49.56,79.26 49.56,83.48 50.02,83.94 52.68,83.94
+VIN_VCCIN on BOTTOM (solid shape): 55.53,92.68 55.53,89.65 55.78,89.4 55.78,88.05 55.43,87.7 55.43,86.73 55.38,86.68 53.14,86.68 52.4,87.42 52.4,91.79 53.35,92.74 55.47,92.74
+VIN_VCCIN on BOTTOM (solid shape): 52.76,83.86 52.76,80.87 53.04,80.59 53.04,78.89 52.73,78.58 52.73,77.79 52.66,77.72 50.65,77.72 49.86,78.51 49.86,78.94 48.95,79.85 48.95,83.7 49.15,83.91 52.71,83.91
+VIN_VCCIN on IN1 (solid shape): 54.82,92.55 54.82,87.09 54.45,86.72 53.15,86.72 52.76,86.33 52.76,77.92 52.56,77.72 50.45,77.72 49.86,78.3 49.86,78.91 49.56,79.22 49.56,83.46 50.3,84.19 50.3,87.48 52.31,89.5 52.31,91.38 52.72,91.78 52.72,92.16 53.31,92.75 54.61,92.75
AGND_CPU on TOP (solid shape): 48.21,93.73 48.21,92.19 48.22,92.19 48.22,91.89 48.17,91.81 48.08,91.79 47.59,91.35 48.23,91.16 48.3,91.19 48.37,91.16 48.53,91 49.71,91 50.14,90.57 50.14,89.96 50.07,89.88 41.3,89.88 41.13,90.05 41.13,90.72 41.46,91.05 41.46,91.69 42.81,93.04 42.82,93.04 42.82,93.79 42.81,93.79 42.81,93.98 43.76,94.94 44.86,94.94 45.32,95.4 46.53,95.4
AGND_CPU on BOTTOM (solid shape): 45.11,95.02 45.11,94.33 45.11,94.33 45.11,94.18 45.21,94.07 46.15,94.07 46.2,94.02 46.2,91.28 46.15,91.23 43.44,91.23 43.41,91.26 43.41,94 43.49,94.07 44.86,94.07 44.91,94.13 44.91,94.99 44.92,95.02 44.96,95.04 45.09,95.04
AGND_CPU on IN1 (solid shape): outline of 638 points within 38.46,86.43 51.9,99.62
AGND_DDR on TOP (solid shape): 50.78,32.81 50.78,31.01 51.28,30.5 53.29,30.5 53.34,30.55 53.34,31.69 53.37,31.72 57.33,31.72 57.48,31.57 57.48,30.05 57.47,30.02 57.45,30 57.36,29.96 57.29,29.9 57.27,29.89 57.25,29.89 57.17,29.9 57.08,29.89 53.37,29.89 53.34,29.91 53.34,30.27 53.32,30.3 52.07,30.3 51.94,30.17 51.94,27.4 51.89,27.35 50.6,27.35 50.07,27.88 50.07,32.73 50.24,32.91 50.67,32.91
AGND_DDR on BOTTOM (solid shape): 55.15,31.67 55.15,29.91 55.1,29.86 53.45,29.86 53.37,29.94 53.37,30.09 53.14,30.32 52.36,30.32 52.35,30.35 52.35,30.5 53.19,30.5 53.34,30.65 53.34,31.62 53.42,31.69 55.12,31.69
AVDD on BOTTOM (solid shape): 34.12,12.4 34.12,11.94 33.85,11.94 33.48,12.31 32.49,12.31 32.45,12.35 32.45,12.53 32.49,12.57 33.95,12.57
DVDD on BOTTOM (solid shape): 29.77,15.16 29.77,14.29 29.24,14.29 29.06,14.47 28.02,14.47 27.89,14.6 27.89,15.64 28.12,15.87 29.06,15.87
DVDD on BOTTOM (solid shape): 31.47,17.15 31.47,16.11 31.78,15.79 31.78,14.37 31.68,14.27 31.51,14.27 31.5,14.27 31.5,15.38 30.93,15.95 30.93,17.2 31,17.26 31.36,17.26
DVDD on BOTTOM (solid shape): 38.47,16.82 38.47,14.41 38.36,14.29 35.64,14.29 35.42,14.08 34.13,14.08 33.84,13.79 32.52,13.79 32.44,13.86 32.44,14.12 33.2,14.88 34.75,14.88 34.95,15.08 36.05,15.08 36.35,15.39 37.37,15.39 37.42,15.44 37.42,16.66 36.99,17.09 36.99,17.32 37.14,17.47 37.82,17.47
DVDD on IN1 (solid shape): outline of 985 points within 26.9,8.45 40.36,20.01
GND on TOP (solid shape): 20.65,92.58 20.65,87.8 20.15,87.29 18.85,87.29 18.06,88.08 18.06,92.68 18.44,93.06 20.17,93.06
GND on TOP (solid shape): 79.15,37.33 79.15,35.48 78.64,34.97 76.54,34.97 76.18,35.33 76.18,37.39 76.5,37.71 78.77,37.71
GND on TOP (solid shape): 105.51,173.35 105.51,170.86 105.16,170.5 103.35,170.5 103.28,170.58 103.28,173.25 103.48,173.45 105.41,173.45
GND on TOP (solid shape): 106.81,177.03 106.81,176.73 106.68,176.6 104.22,176.6 104.12,176.7 104.12,177.56 104.22,177.67 106.17,177.67
GND on TOP (solid shape): 113.87,146.68 113.87,139.82 113.51,139.46 111.91,139.46 111.61,139.77 111.61,146.5 111.89,146.78 113.77,146.78
GND on TOP (solid shape): 114.81,152.8 114.81,152.11 114.68,151.99 112.6,151.99 112.47,152.11 112.47,152.8 112.6,152.93 114.68,152.93
GND on TOP (solid shape): 144.43,163.13 144.43,162.9 144.11,162.58 143.07,162.58 143,162.65 143,163.47 143.04,163.5 144.06,163.5
GND on TOP (solid shape): 162.63,71.63 162.63,69.95 162.43,69.75 157.77,69.75 157.21,70.31 157.21,71.48 157.39,71.65 162.6,71.65
GND on TOP (solid shape): 185.35,140.48 185.35,138.98 185.32,138.96 183.75,138.96 183.72,138.98 183.72,140.48 183.82,140.58 185.25,140.58
GND on TOP (solid shape): 187.94,172.97 187.94,171.9 187.57,171.53 184.24,171.53 183.93,171.85 183.93,173.12 184.13,173.32 187.58,173.32
GND on TOP (solid shape): 189.49,99.74 189.49,98.7 189.27,98.48 188.66,98.48 188.32,98.82 188.32,100.15 188.4,100.22 189.01,100.22
GND on TOP (solid shape): 193.04,39.11 193.04,36.09 192.64,35.68 190.86,35.68 189.84,36.7 189.84,39.77 190.07,40 192.16,40
GND on TOP (solid shape): 198.14,58.21 198.14,29.37 198.05,29.28 197.71,29.28 197.63,29.36 197.63,58.18 197.73,58.29 198.06,58.29
GND on TOP (solid shape): 16.28,109.85 16.28,108.72 16.16,108.59 9.59,108.59 9.18,109 9.18,109.59 9.49,109.9 16.23,109.9
GND on TOP (solid shape): 116.46,52.22 116.46,48.49 116.13,48.16 115.5,48.16 114.98,48.67 114.98,52.57 115.19,52.78 115.9,52.78
GND on TOP (solid shape): 28.66,42.46 28.66,41.09 28.15,40.58 27.26,40.58 27.11,40.73 27.11,41.04 25.76,42.39 25.76,42.79 25.84,42.87 28.25,42.87
GND on TOP (solid shape): 151.03,109.88 151.03,106.55 150.55,106.06 149.28,106.06 148.92,106.42 148.92,109.89 149.17,110.14 150.77,110.14
GND on TOP (solid shape): 170.89,160.01 170.89,157.96 170.61,157.68 169.24,157.68 169.11,157.81 169.11,158.38 169.7,158.97 169.7,160.09 169.83,160.22 170.69,160.22
GND on TOP (solid shape): 98.54,120.71 98.55,120.71 98.69,120.57 98.69,120.35 98.57,120.23 96.17,120.23 96.08,120.33 96.08,121.39 96.22,121.53 97.72,121.53
GND on TOP (solid shape): 16.92,65.98 16.92,65.35 17.3,64.97 18.06,64.97 18.19,64.84 18.19,63.85 17.73,63.39 15.22,63.39 15.14,63.47 15.14,65.4 15.85,66.11 16.79,66.11
GND on TOP (solid shape): 18.63,18.39 18.63,15.99 19.71,14.91 19.71,14.12 19.49,13.89 17.83,13.89 16.99,14.72 16.99,18.42 17.1,18.52 18.49,18.52
GND on TOP (solid shape): 35.11,18.62 35.11,17.29 34.95,17.14 33.68,17.14 32.01,18.82 32.01,20.39 32.2,20.59 33.14,20.59
GND on TOP (solid shape): 54.15,27.63 54.15,25.37 54.05,25.27 51.26,25.27 50.85,25.67 50.85,26.76 51,26.92 51.82,26.92 52.61,27.7 54.08,27.7
GND on TOP (solid shape): 57.08,105.4 57.08,104.08 56.44,103.45 52.25,103.45 52.1,103.6 52.1,104.31 52.32,104.53 52.32,104.83 52.84,105.35 54.94,105.35 55.27,105.68 56.8,105.68
GND on TOP (solid shape): 93.12,74.26 93.12,71.47 93.02,71.37 91.52,71.37 90.78,70.63 89.89,70.63 89.64,70.88 89.64,72.13 89.81,72.29 90.75,72.29 92.8,74.34 93.04,74.34
GND on TOP (solid shape): 120.4,190.52 120.4,189.17 120.3,189.07 120.02,189.07 119.79,189.3 119.36,189.3 119.21,189.45 119.21,189.63 119.88,190.3 119.88,190.41 120.05,190.59 120.33,190.59
GND on TOP (solid shape): 145.97,96.24 145.99,96.23 146.01,96.22 146.1,96.13 146.68,95.55 146.68,93.96 146.13,93.41 144.99,93.41 144.52,93.88 144.52,96.14 144.62,96.24
GND on TOP (solid shape): 161.27,181.13 161.27,179.92 161.21,179.86 160.37,179.86 159.87,179.37 159.06,179.37 158.81,179.62 158.81,181.04 159.03,181.27 161.13,181.27
GND on TOP (solid shape): 192.18,137.08 192.18,135.1 191.98,134.89 191.29,134.89 191.04,135.15 190.5,135.15 189.46,136.19 189.46,137.2 189.95,137.69 191.57,137.69
GND on TOP (solid shape): 105.03,5.35 105.87,5.35 106.13,5.1 106.13,3.17 105.85,2.89 105.26,2.89 104.88,3.27 104.88,3.93 104.2,4.62 104.2,5.38 104.35,5.53 104.86,5.53
GND on TOP (solid shape): 160.05,121.61 160.05,120.12 159.27,119.33 159.26,119.33 158.98,119.05 155.13,119.05 155.02,119.16 155.02,121.9 155.13,122 159.66,122
GND on TOP (solid shape): 183.93,112.64 183.93,111.75 183.8,111.63 181.67,111.63 181.61,111.68 181.61,112.08 181.73,112.2 182.26,112.2 182.74,112.68 182.75,112.69 182.77,112.69 183.87,112.69
GND on TOP (solid shape): 75.29,62 75.29,61.03 75.43,60.88 75.43,59.99 75.2,59.76 73.49,59.76 73.28,59.96 73.28,61.92 73.64,62.27 75.01,62.27
GND on TOP (solid shape): 92.94,36.19 92.94,34.55 92.93,34.52 92.89,34.5 92.52,34.5 92.21,34.82 91.24,34.82 91.01,35.05 91.01,36.14 91.14,36.27 92.87,36.27
GND on TOP (solid shape): 125.05,191.48 125.05,188.08 125.05,188.08 125.05,187.67 124.82,187.44 123.65,187.44 123.37,187.73 123.37,191.48 123.38,191.51 123.42,191.53 125,191.53
GND on TOP (solid shape): 197.98,130.47 198.01,130.46 198.03,130.42 198.03,126.84 197.54,126.36 196.88,126.36 196.78,126.46 196.78,128.9 197.34,129.46 197.34,130.29 197.51,130.47
GND on TOP (solid shape): 81.97,69.39 82.88,69.39 83.01,69.26 83.01,68.63 82.79,68.42 82.37,68.42 82.18,68.23 82.18,67.62 81.89,67.33 80.16,67.33 79.94,67.56 79.94,69.79 80.14,70 81.36,70
GND on TOP (solid shape): 138.38,147.03 138.38,145.44 138.06,145.11 137.92,145.11 137.14,144.33 137.14,140.02 136.83,139.72 135.92,139.72 135.59,140.05 135.59,144.26 136.48,145.16 136.48,147.03 136.94,147.49 137.93,147.49
GND on TOP (solid shape): 197.82,106.18 197.82,105.56 197.67,105.4 197.44,105.4 196.98,105.86 196.73,105.86 194.51,105.86 194.49,105.89 194.49,106.76 194.17,107.08 194.17,107.49 194.33,107.66 196.34,107.66
GND on TOP (solid shape): 183.8,127.04 184.18,126.66 184.18,125.77 185.09,124.86 185.09,123.79 184.84,123.54 182.78,123.54 181.97,124.35 181.97,124.88 181.04,125.82 180.78,125.82 180.5,126.1 180.5,126.71 180.83,127.04 182.09,127.04
GND on TOP (solid shape): 145.39,152.29 145.39,151.91 145.22,151.73 143.59,151.73 143.38,151.53 143.38,148.18 143.28,148.09 143.24,148.05 142.29,148.05 142.11,147.87 141.99,147.87 141.78,148.07 141.78,152.13 142.02,152.36 145.32,152.36
GND on TOP (solid shape): 173.22,181.76 173.22,181.05 173.12,180.94 171.68,180.94 171.4,180.66 171.4,180.03 171.28,179.9 171.09,179.9 169.68,179.9 169.02,180.56 169.02,181.63 169.3,181.91 173.07,181.91
GND on TOP (solid shape): 113.79,160.83 113.79,155.72 113.06,154.98 112.4,154.98 112.26,155.12 112.26,156.11 112.12,156.25 110.54,156.25 110.42,156.38 110.42,157.93 110.52,158.03 111.86,158.03 112.5,158.67 112.5,160.83 112.57,160.9 113.72,160.9
GND on TOP (solid shape): 140.52,191.36 140.52,190.54 140.36,190.39 133,190.39 132.72,190.11 132.72,188.16 132.72,188.15 132.72,187.55 132.47,187.29 130.1,187.29 130.03,187.37 130.03,188.82 130.51,189.3 130.51,190.44 130.81,190.75 130.81,191.28 131.04,191.51 140.36,191.51
GND on TOP (solid shape): 155.13,178.9 155.13,175.71 154.78,175.36 151.79,175.36 151.03,176.12 150.96,176.31 150.82,176.43 150.81,176.44 150.79,176.46 150.79,177.87 151.43,178.5 152.94,178.5 153.41,178.98 155.04,178.98
GND on TOP (solid shape): 55,113.12 55,112.69 54.92,112.62 53.12,112.62 51.79,111.3 49.48,111.3 49.48,111.31 47.73,111.31 47.73,111.3 47.53,111.3 47.35,111.47 47.35,111.84 49.48,111.84 49.48,112.58 47.73,112.58 47.73,111.84 47.35,111.84 47.35,113 47.63,113.28 54.84,113.28
GND on TOP (solid shape): 113.92,176.6 113.92,170.91 114.07,170.76 114.68,170.76 114.78,170.66 114.78,169.94 114.77,169.91 114.73,169.89 112.45,169.89 111.97,170.37 111.97,174.11 112.59,174.73 112.59,176.97 112.7,177.08 113.44,177.08
