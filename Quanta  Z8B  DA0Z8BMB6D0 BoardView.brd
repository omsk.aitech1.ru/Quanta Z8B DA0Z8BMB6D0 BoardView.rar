# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WLAN_CLK_SCLK: length 3.8
  BOTTOM w0.127: CN10.30 173.5,60.37 173.23,60.65 173.23,61.14 172.64,61.73 172.64,62.09 172.83,62.29 R672.1
WLAN_CLK_SDATA: length 3.8
  BOTTOM w0.127: CN10.32 172.7,60.37 172.97,60.65 172.97,61.03 172.38,61.63 172.38,62.1 172.19,62.29 R671.1
WRST#: length 15
  TOP w0.127: v3(165.48,53.86) 165.54,53.91 165.54,54.34 C245.1 166.31,55.11 166.31,55.63 166.61,55.93 U13.14 ; v3(160.18,48.86) 160.02,48.7 R317.1 158.43,48.22 D11.2
  IN1 w0.133: v3(165.48,53.86) 165.48,53.25 163.68,51.44 163.68,50.19 162.46,48.96 160.28,48.96 v3(160.18,48.86)
XDP_BPM#0: length 25.5
  BOTTOM w0.102: R491.2 89.31,111.18 89.52,111.38 90.38,111.38 90.58,111.18 v3(90.58,110.65) 90.58,109.7 90.72,109.56 90.93,109.56 91.07,109.7 91.07,111.49 91.23,111.65 91.46,111.65 91.62,111.49 91.62,109.75 91.8,109.57 92.05,109.57 92.21,109.73 92.21,112.23 92.33,112.34 94.23,112.34 94.32,112.25 94.32,112.13 94.23,112.04 92.7,112.04 92.61,111.95 92.61,111.82 92.7,111.73 93.76,111.73 93.85,111.64 93.85,111.52 93.76,111.43 92.73,111.43 92.58,111.29 92.58,111.08 92.73,110.94 93.25,110.94 93.33,110.85 93.33,110.73 93.25,110.64 92.81,110.64 92.61,110.43 92.61,109.9 92.79,109.71 93.05,109.71 93.81,110.47 93.81,110.92 94.19,111.3 94.83,111.3 95.07,111.07 95.35,111.07 95.4,111.12 U27.AR30
XDP_BPM#1: length 25.6
  BOTTOM w0.102: R487.2 89.35,112.54 89.55,112.34 90.4,112.34 90.61,112.54 v3(90.61,112.69) 90.61,113.12 90.37,113.36 90.37,114.02 90.53,114.18 90.75,114.18 90.91,114.02 90.91,113.25 91,113.16 91.13,113.16 91.21,113.25 91.21,114.76 91.3,114.85 91.43,114.85 91.52,114.76 91.52,113.04 91.61,112.95 91.73,112.95 91.82,113.04 91.82,115.09 91.91,115.18 92.04,115.18 92.13,115.09 92.13,113.14 92.22,113.05 92.34,113.05 92.43,113.14 92.43,115.01 92.54,115.11 92.69,115.11 92.8,115.01 92.8,113.25 92.91,113.14 93.06,113.14 93.16,113.25 93.16,114.53 93.29,114.65 93.46,114.65 93.59,114.53 93.59,113.3 93.79,113.1 97.31,113.1 97.4,113.01 U27.AN31
XDP_BPM#2: length 10.7
  TOP w0.127: v3(96.9,111.28) 97.46,110.72 97.46,108.91 96.63,108.07 93.34,108.07 92.5,108.91 TP29.1
  BOTTOM w0.114: v3(96.9,111.28) 97.4,110.79 U27.AN29
XDP_BPM#3: length 4.9
  TOP w0.127: TP22.1 93.39,113.06 95.92,113.06 v3(96.85,112.13)
  BOTTOM w0.102: U27.AP31 96.4,112.58 v3(96.85,112.13)
XDP_BPM#4: length 6.1
  TOP w0.127: TP23.1 91.67,112.26 93.53,112.26 93.82,112.55 95.6,112.55 v3(95.94,112.21)
  BOTTOM w0.102: U27.AP30 96.4,111.75 v3(95.94,112.21)
XDP_BPM#5: length 8.4
  TOP w0.127: TP26.1 91.27,110.86 93.55,108.58 95.98,108.58 96.39,108.99 96.39,109.54 v3(96.9,110.05)
  BOTTOM w0.114: U27.AN28 97.27,109.69 v3(96.9,110.05)
XDP_BPM#6: length 1.8
  TOP w0.127: v3(95.89,111.21) 95.88,111.19 TP24.1
  BOTTOM w0.114: v3(95.89,111.21) 96.4,110.69 U27.AP29
XDP_BPM#7: length 4.2
  TOP w0.127: TP28.1 93.83,109.7 95.35,109.7 v3(95.82,110.17)
  BOTTOM w0.114: v3(95.82,110.17) 96.31,109.69 U27.AP28
XDP_DBRST#: length 222.8
  IN2 w0.133: v3(149.48,66.08) 150.13,65.43 150.13,59.38 148.24,57.49 148.24,56.91 146.71,55.39 146.71,49.14 144.06,46.48 144.05,46.48 141.84,44.27 141.84,41.98 138.55,38.69 138.55,37.7 138.13,37.28 122.57,37.28 117.86,32.57 113.78,32.57 113.28,32.08 91.64,32.08 91.2,32.51 83.62,32.51 80.88,35.24 77.5,35.24 74.55,38.2 74.4,38.2 66.37,46.22 66.37,59.81 67.58,61.02 67.58,73.54 68.87,74.82 68.87,84.7 82.94,98.77 82.94,100.26 84.26,101.59 v3(84.26,103.24)
  BOTTOM w0.102: U27.AP33 96,115.08 93.82,115.08 93.28,115.63
  BOTTOM w0.127: v3(149.48,66.08) 150.12,66.72 150.12,67.48 151.4,68.76 151.4,68.81 151.4,68.81 151.4,72.48 154.82,75.9 154.9,75.9 156.43,77.43 156.43,78.85 v2(155.6,79.67) 155.6,79.68 155.6,83.1 155.6,84.26 155.61,84.27 R617.1 ; v3(84.26,103.24) 83.9,103.6 83.9,104.39 84.38,104.87 84.38,110.11 86.09,111.82 R486.1 86.64,112.82 87.15,113.33 87.96,113.33 88.25,113.62 R485.1 88.61,114.29 89.97,114.29 91.3,115.63 93.28,115.63
XDP_FN0: length 3.9
  BOTTOM w0.127: R591.2 168.02,86.75 168.84,85.93 168.84,84.39 TP142.1
XDP_FN1: length 2.7
  BOTTOM w0.127: TP138.1 166.65,85.12 166.65,86.51 R602.2
XDP_FN2: length 4.2
  BOTTOM w0.102: 167.02,87.41 167.02,87.67 166.55,88.13 166.31,88.13 166.12,88.33 166.12,89.27 R577.2
  BOTTOM w0.127: 167.02,87.41 167.02,86.02 TP134.1
XDP_FN3: length 4.5
  BOTTOM w0.127: TP148.1 169.38,83.12 169.38,86.11 169.13,86.36 R607.2
XDP_FN4: length 6.3
  BOTTOM w0.127: R603.2 170.64,86.55 170.64,83.05 169.17,81.58 TP152.1
XDP_FN5: length 1.9
  BOTTOM w0.127: TP145.1 166.88,83.53 168.07,84.72 R613.2
XDP_FN6: length 1
  BOTTOM w0.127: R627.2 TP147.1
XDP_FN7: length 1.3
  BOTTOM w0.102: TP131.1 170.04,87.91 170.04,89.08 169.93,89.19 R586.2
XDP_FN8: length 1.4
  BOTTOM w0.127: R610.2 152.07,84.6 TP139.1
XDP_FN9: length 2.2
  BOTTOM w0.102: TP132.1 152.14,88 153.44,89.3 R571.2
XDP_FN10: length 1.8
  BOTTOM w0.127: TP136.1 152.75,85.8 152.75,86.52 153.12,86.89 R595.1
XDP_FN11: length 2.3
  BOTTOM w0.127: TP146.1 156.27,83.31 157.68,84.73 R619.1
XDP_FN12: length 1.5
  BOTTOM w0.127: R597.1 155.51,86.77 TP135.1
XDP_FN13: length 1.4
  TOP w0.127: R228.1 159.04,83.38 TP60.1
XDP_FN14: length 1.3
  BOTTOM w0.127: TP151.1 159.42,81.39 R632.2
XDP_FN15: length 1.5
  BOTTOM w0.127: R630.2 157.21,82.21 TP150.1
XDP_FN_CLK1: length 1
  BOTTOM w0.127: R621.1 165.13,83.79 165.13,83.79 TP141.1
XDP_FN_CLK2: length 1.1
  BOTTOM w0.102: R569.1 156.28,89.55 TP128.1
XDP_PRDY#: length 9.2
  BOTTOM w0.102: U27.AR29 94.96,110.69 94.57,111.07 94.24,111.07 94.01,110.84 94.01,110.39 92.97,109.34 91.88,109.34
  BOTTOM w0.127: TP93.1 88.55,110.08 89.74,110.08 90.47,109.34 91.88,109.34
XDP_PREQ#: length 5.9
  BOTTOM w0.102: TP94.1 89.72,109.11 93.02,109.11 94.4,110.49 U27.AT29
XDP_TCLK: length 4.7
  TOP w0.127: v3(97.93,116.15) 97.93,117.58 TP17.1 98.78,118.59 98.54,118.83 R57.2
  BOTTOM w0.114: v3(97.93,116.15) U27.AM34
XDP_TDI: length 11.5
  BOTTOM w0.102: U27.AM31 97.78,113.3 94.13,113.3 93.92,113.51 93.92,114.67
  BOTTOM w0.127: 93.92,114.67 93.2,115.4 91.4,115.4 89.73,113.73 TP90.1
XDP_TDO: length 9.2
  TOP w0.127: v3(98.85,115.05) 98.85,114.29 98.32,113.75 93.59,113.75 93.23,114.1 TP20.1 R71.2
  BOTTOM w0.114: v3(98.85,115.05) 99.22,114.69 U27.AL33
XDP_TMS: length 12.6
  BOTTOM w0.114: 92.51,115.85 93.68,115.85 94.25,115.29 96.79,115.29 U27.AN33
  BOTTOM w0.127: 92.51,115.85 90.81,115.85 89.76,114.8 86.69,114.8 TP88.1
XDP_TRST#: length 5.9
  TOP w0.127: R56.2 97.01,119.31 TP18.1 97.41,117.01 97.41,115.91 97.88,115.45 v3(97.88,115.03)
  BOTTOM w0.114: U27.AM33 98.22,114.69 v3(97.88,115.03)
XTAL25_IN: length 11.7
  BOTTOM w0.089: U24.AM43 158.55,113.33 158.88,113.66 158.88,114.93 157.48,116.33 157.15,116.33
  BOTTOM w0.127: Y3.1 155.24,120.1 v3(155.24,119) C417.1 R475.1 156.67,118.08 156.67,116.63 156.98,116.32 157,116.32 157,116.33 157.15,116.33
XTAL25_OUT: length 8.6
  BOTTOM w0.089: 157.23,116.83 159.06,115 159.06,113.39 U24.AL44
  BOTTOM w0.127: Y3.3 158.77,119.41 C418.1 R475.2 157.23,117.97 157.23,116.83
XTAL_SSIN: length 11.7
  BOTTOM w0.127: R390.1 155.45,177.42 155.45,174.85 v3(155.07,174.47) 155.07,173.88 154.61,173.42 153.98,173.42 151.48,170.93 151.48,170.51 U19.A10
N35804879: length 2.3
  TOP w0.127: TP56.1 106.93,88.95 v3(106.93,88.16)
  BOTTOM w0.127: v3(106.93,88.16) 107.4,88.62 U27.AC7
N35804889: length 1.4
  TOP w0.127: R191.2 115.78,91.31 v3(115.93,91.16)
  BOTTOM w0.127: U27.R10 v3(115.93,91.16)
N35805453: length 1.4
  TOP w0.127: R192.2 112.86,91.09 v3(112.93,91.16)
  BOTTOM w0.127: v3(112.93,91.16) U27.V10
N35805455: length 1.7
  TOP w0.127: TP54.1 103.72,90.37 v3(103.93,90.16)
  BOTTOM w0.127: v3(103.93,90.16) 103.46,89.69 U27.AG8
N35812272: length 4.6
  TOP w0.127: R59.2 96.47,119.39 96.47,116.7 v3(95.93,116.15)
  BOTTOM w0.127: v3(95.93,116.15) U27.AP34
N35813632: length 3.7
  TOP w0.127: v2(111.61,76.93) 111.58,76.96 R245.2
  TOP w0.508: Q33.3 110.38,75.77 R245.2
N35830956: length 7.2
  TOP w0.127: v2(182.1,90.09) 183.59,88.6 Q25.2
  TOP w0.508: R217.1 186.27,87.88 Q28.3 184.64,86.91 183.59,87.96 Q25.2
N35831177: length 4.5
  TOP w0.089: TP46.1 162.69,96.97 162.59,97.07 162.59,98.83 162.97,99.21 v3(163,99.21)
  BOTTOM w0.102: v3(163,99.21) 162.65,98.86 U24.AB10
N35840776: length 7.9
  TOP w0.089: v3(163,97.26) 163.01,97.25 163.01,96.19 163.24,95.95 163.24,94.63 163.02,94.41 163.02,94.2
  TOP w0.127: R211.2 163.06,90.42 163.06,93.72 163.02,93.76 163.02,94.2
  BOTTOM w0.102: U24.AB6 162.81,97.07 v3(163,97.26)
N35841298: length 3.5
  TOP w0.102: 168.43,97.43 168.67,97.67 169.1,97.67 v3(169.25,97.82)
  TOP w0.127: R165.2 167.42,96.08 168.33,97 168.33,97.33 168.43,97.43
  BOTTOM w0.102: U24.F8 169.58,98.15 v3(169.25,97.82)
N35866291: length 4.9
  BOTTOM w0.508: Q47.2 182.43,116.17 v2(183.16,116.91) 183.86,116.91 R480.2 184.22,115.88 184.69,115.41 Q48.3
N35866556: length 1.5
  TOP w0.254: R210.1 161.48,89.43 160.65,90.26 C213.1
N35875147: length 1.1
  TOP w0.127: TP72.1 166.78,45.1 R326.1
N35875453: length 1.3
  BOTTOM w0.127: TP153.1 172.59,81.47 R639.1
N35918456: length 8.1
  BOTTOM w0.127: U20.4 168.06,153.24 167.79,152.98 164.93,152.98 R436.2 163.45,153.32 v2(163.45,152.45) 163.45,151.26 R437.2
N35932869: length 7.8
  BOTTOM w0.127: R412.2 170.64,166.33 v3(170.64,166.79) ; R412.2 170.27,165.81 169.96,165.5 169.77,165.5 C361.2 169.24,164.91 U18.2 ; R412.2 171.23,165 R743.1
N35932875: length 8.4
  TOP w0.127: R16.2 135.06,168.48 136.58,166.96 136.6,166.96 137.29,166.26 137.87,166.26 138.35,165.79 139.44,165.79 139.49,165.83 139.79,165.83 140.34,165.28 140.34,164.67 v3(140.49,164.52)
  BOTTOM w0.102: U19.F22 140.09,164.92 v3(140.49,164.52)
N35932877: length 1.4
  TOP w0.254: R29.2 140.48,162.02 v3(140.44,162.06)
  BOTTOM w0.254: U19.J22 v3(140.44,162.06)
N35934097: length 4.9
  BOTTOM w0.127: v3(167.47,163.21) 167.34,163.08 R425.2 167.84,162.76 168.38,162.76 168.59,162.97 U18.1 168.59,164.49 R414.2
N35947971: length 12.8
  TOP w0.127: Q5.3 171.07,167.73 171.51,167.3 v2(172.44,167.3)
  TOP w0.254: Q5.3 170.24,168.7 v3(170.36,168.83) ; R11.1 164.34,171.7 164.46,171.81 R324.2 165.15,171.81 v3(165.56,172.23)
  BOTTOM w0.254: v3(165.56,172.23) 167.11,172.23 168.41,170.93 168.41,169.92 169.5,168.83 v3(170.36,168.83)
N35947984: length 5.5
  TOP w0.127: C13.2 v2(162.55,173.78)
  TOP w0.508: C13.2 R11.2 C17.1 161.95,170.58 160.96,169.59 Q4.2
N35948037: length 10.9
  TOP w0.508: Q11.2 167.18,172.84 165.41,171.06 165.41,170.12 165.63,169.9 R82.1 C51.1 164.27,168.05 v2(163.76,167.53) 163.22,167 Q12.3
N35948066: length 3.8
  TOP w0.127: R85.1 156.23,167.92 v2(155.96,168.19)
  TOP w0.508: Q12.2 158.16,168.01 C64.1 R85.1
N35952197: length 13.6
  BOTTOM w0.127: R432.2 161.56,159.09 161.44,158.97 v2(160.56,158.97) 160.19,158.97 157.95,161.21 157.95,161.77 157.66,162.07 156.41,162.07 156.17,162.31 156.17,162.62 155.95,162.84 155.71,162.84 155.41,163.14 155.41,164.26 155.11,164.56 153.67,164.56 U19.F6
N35952201: length 1.6
  TOP w0.127: v3(150.41,165.42) 150.45,165.46 150.45,166.01 TP6.1
  BOTTOM w0.127: U19.E10 150.41,165.44 v3(150.41,165.42)
N35952203: length 1.3
  TOP w0.127: v3(150.41,164.6) 151.08,164.6 TP7.1
  BOTTOM w0.127: U19.F10 v3(150.41,164.6)
N35955659: length 33.8
  TOP w0.254: Q1.2 157.05,179.06 v3(157.71,178.4)
  IN1 w0.254: v3(165.03,156.58) 165.03,156.87 165.58,157.42 167.29,157.42 168.55,158.68 168.55,162.21 168.54,162.21 168.54,162.53 168.48,162.6 168.48,168.07 168.13,168.42 168.13,172.75 165.65,175.23 163.62,175.23 161.74,177.1 159.01,177.1 v3(157.71,178.4)
  BOTTOM w0.254: R434.2 164.05,156.53 164.99,156.53 v3(165.03,156.58)
N35957470: length 10.4
  BOTTOM w0.254: R384.2 163.06,179.1 162.49,178.53 162.49,176.48 v2(162.51,176.46) 162.89,176.08 R401.2 ; R384.2 163.09,179.97 163.38,180.26 Q24.3 ; R384.2 164,179.1 164.45,179.56 R383.1 164.8,179.26 165.54,178.52 R387.1
N35957513: length 34.1
  BOTTOM w0.127: R402.1 169.23,174.21 R404.2 170.06,172.38 170.82,171.62 170.82,168.6 170.39,168.17 169.35,168.17 169.02,168.5 168.41,168.5 Q26.3 168.36,167.94 168.69,167.61 171.11,167.61 171.89,166.83 171.89,160.27 170.72,159.1 v2(170.72,156.13) 170.72,153.34 169.98,152.6 169.98,151.43 169.32,150.77 R441.1 169.78,149.86 169.78,148.74 R445.1
N35977598: length 11.7
  TOP w0.381: v3(184.04,73.05) 184.04,73.18 U11.5 184.04,74.83 183.76,75.11 183.76,75.82 R250.2
  TOP w0.508: v3(184.04,73.05) 187.87,73.05 R259.2 R262.2
  BOTTOM w0.127: v2(185.14,72.66) 185.07,72.74 C503.2
  BOTTOM w0.381: v3(184.04,73.05) 183.8,73.3 C502.1 C503.2
N35977677: length 7.1
  TOP w0.381: U11.6 183.39,72.74 183.77,72.35 186.07,72.35 R270.1
N35977835: length 4
  TOP w0.381: R240.2 180.58,77.28 180.9,76.96 180.9,76.51 181.4,76.01 R249.2 181.51,75.53 181.44,75.46 U11.9
N35977847: length 4.4
  TOP w0.381: U11.7 182.74,75.98 R247.2 182.82,76.02 183.26,76.46 183.26,77.12 182.82,77.56 R238.1
N35977878: length 3
  TOP w0.127: R273.2 186.23,69 185.99,68.76 U11.27
N35978170: length 4.7
  TOP w0.127: v3(176.53,70.45) 176.53,70.3 176.26,70.03 R271.1 176.41,69.61 176.69,69.89 177.88,69.89 178.19,69.58 U11.15
N35990640:
  vias: v2(106.3,169.66) v3(106.05,168.06) v3(106.05,167.4)
N35991360: length 1.9
  TOP w0.127: R1.2 110.01,187.74 v3(110.01,188.13)
  BOTTOM w0.102: CN2.6 110.06,188.08 v3(110.01,188.13)
N35997304: length 27.2
  TOP w0.508: v3(19,52.98) 18.26,52.98 R307.2 R305.2 ; R316.2 18.5,49.51 18.5,48.42 R321.2 19.18,48.39 19.46,48.11 v3(19.46,48.11) ; v3(19,51.81) 18.99,51.82 R310.2 R314.2 ; v3(19.13,57.93) 18.95,58.11 Q42.3
  IN1 w0.508: v3(19.13,57.93) 19.13,57.04 17.05,54.96 v3(17.05,54.93) v3(19,52.98) v3(19,51.81) 19,48.57 19.46,48.11 v3(19.46,48.11)
  BOTTOM w0.381: R676.2 14.62,55.2 14.89,54.93 v3(17.05,54.93) ; R674.2 14.62,57.11 15.4,57.88 18.19,57.88 v2(18.19,57.88) 18.24,57.93 v3(19.13,57.93)
N35997342: length 3.6
  TOP w0.508: R294.2 20.73,61.64 v3(21.01,61.92) 21.84,62.75 D4.1
N35997479: length 3.1
  TOP w0.127: D7.1 21.13,54.26 20.6,54.78 v2(20.6,55.39) 20.6,55.39 R298.2
N36000287: length 5.2
  BOTTOM w0.127: v3(176.56,64.03) 176.56,62.81 R673.1 176.7,61.91 CN10.22
N36002123: length 5.9
  TOP w0.305: CN6.11 198.6,105.92 196.51,108.01 R104.1 R97.1 R94.2
N36002705: length 3.5
  TOP w0.127: R150.2 198.02,97.98 v2(198.48,98.44)
  TOP w0.508: Q20.3 196.95,97.88 R150.2
N36003009: length 3.3
  TOP w0.254: v3(63.35,5.4) 62.23,5.4 61.95,5.12 LED1.4
  BOTTOM w0.254: R725.2 63.89,6.28 63.35,5.75 v3(63.35,5.4)
N36003015: length 3.1
  TOP w0.254: v3(64.09,5.4) 63.13,4.45 LED1.3
  BOTTOM w0.254: R726.2 64.97,6.28 v3(64.09,5.4)
N36003040: length 5.7
  TOP w0.254: v3(67.59,7.1) 67.59,6.67 68.91,5.35 70.64,5.35 70.85,5.14 LED2.3
  BOTTOM w0.254: R724.2 67.78,6.92 v3(67.59,7.1)
N36003063: length 5.8
  TOP w0.254: v3(66.04,6.67) 68.27,4.45 LED2.4
  BOTTOM w0.254: R723.2 66.29,6.92 v3(66.04,6.67)
N36013518:
  vias: v2(13.85,68.29)
N36013572: length 5.1
  TOP w0.127: TP36.1 22.13,100.78 23.9,100.78 24.19,100.49 C180.1 24.19,99.76 25.01,98.94 U7.27
N36013590: length 4
  TOP w0.127: U7.25 25.18,99.74 25.07,99.85 25.07,100.65 24.32,101.41 C175.1 24.32,102.3 TP32.1
N36013594: length 5.7
  TOP w0.127: U7.26 25.11,99.34 24.72,99.73 24.72,100.49 24.18,101.03 22.91,101.03 22.03,101.92 TP33.1
N36013609:
  vias: v2(24.72,91.64)
N36013670: length 3.3
  BOTTOM w0.508: U29.4 28.7,81.2 v3(28.78,81.12) 28.78,82.09 28.4,82.47 U29.3
  vias: v3(29.01,74.64) v3(29.44,75.15)
N36025352: length 5.9
  TOP w0.127: U17.6 103.43,2.23 104.3,3.09 104.3,3.47 v3(104.4,3.57)
  BOTTOM w0.127: R727.2 C567.1 103.99,3.98 v3(104.4,3.57) v3(105.03,3.57) 105.76,3.57 C568.1
N36025378: length 6.4
  TOP w0.127: v2(28.33,40.1) 27.81,39.58 D12.1
  TOP w0.508: D14.1 26.79,36.77 26.27,37.29 R338.2 25.81,37.4 27.21,38.8 D12.1
N36026429: length 3.9
  TOP w0.127: U15.39 33.66,27.63 34.67,26.61 34.85,26.61 v3(35.23,26.23) 36.1,25.37 C324.2
N36026435: length 2
  TOP w0.127: v3(32.11,24.88) 32.11,25.09 31.8,25.39 U15.35
  BOTTOM w0.127: C533.2 32.09,24.86 v3(32.11,24.88)
N36026441: length 4.5
  TOP w0.102: 33.57,26.83 33.58,26.82
  TOP w0.127: 33.58,26.82 33.74,26.66 33.74,25.45 v3(34.19,25) ; U15.37 33.57,26.83
  BOTTOM w0.127: C533.1 33.6,24.02 v2(33.91,24.33) 34.19,24.6 v3(34.19,25)
N36026464: length 3
  TOP w0.127: U15.34 31.4,25.41 31.65,25.16 31.65,23.65 C326.1
N36026466: length 2.4
  TOP w0.127: U15.19 26.42,28.83 26.25,28.66 25.16,28.66 24.93,28.89 C319.1
N36026531: length 2.5
  TOP w0.127: TP73.1 34.26,32.75 33.58,32.07 33.58,31.44 33.37,31.22 U15.48
N36026741: length 2.3
  TOP w0.127: U15.7 29.8,33.77 C307.1
N36026853: length 5.2
  BOTTOM w0.127: v2(36.22,25.62) 36.53,25.62 37.56,24.59 R697.2
  BOTTOM w0.508: R697.2 R696.2 38.38,26.1 38.7,26.42 U31.5
N36027219: length 9.6
  TOP w0.254: v3(24.4,28.26) 24.07,27.92 Q44.2 Q44.5
  BOTTOM w0.381: v3(24.4,28.26) 24.4,28.78 23.75,29.43 v2(22.74,29.43) 22.12,29.43 R695.1 20.99,29 Q57.3
N36027308: length 5.9
  TOP w0.508: v3(18.04,32.15) 18.09,32.2 18.56,32.2 18.81,31.95 R351.1
  BOTTOM w0.127: v2(18.89,34.51) R694.2
  BOTTOM w0.508: R694.2 C531.2 18.89,31.58 Q57.2 18.32,31.03 18.04,31.31 v3(18.04,32.15)
N36030100: length 9.9
  BOTTOM w0.127: Q51.3 159.59,66.11 v2(160.46,66.11)
  BOTTOM w0.508: Q51.3 157.56,64.43 157.1,64.89 R664.2 156.02,64.78 156.42,64.38 156.42,62.05 155.87,61.5 Q52.2
N36030646: length 2.7
  TOP w0.127: U16.7 113.18,10.56 v2(113.49,10.25) 114.07,9.67 R378.2
N36036971: length 2.6
  TOP w0.127: v2(159.54,55.97) 160.23,55.29 C244.2 160.23,55.06 R303.1
N36037219: length 5.5
  TOP w0.127: C243.1 163.17,56.9 165.14,56.9 v2(165.41,56.63) 165.5,56.73 U13.12
N36042425: length 4.4
  TOP w0.508: PR38.1 PC26.1 185.5,191.91 v2(185.58,191.99) 185.58,192.91 PJ2.6
N36042480: length 4.6
  TOP w0.127: PR5.1 193.81,179.8 195.64,179.8 195.86,180.03 PR1.1 ; v3(192.33,181.37) 192.54,181.58 193.2,181.58
N36042482: length 2.6
  BOTTOM w0.127: PR209.2 158.5,189.86 v3(159.29,189.86)
  BOTTOM w0.254: PR209.2 158.9,189.2 PU1.13
N36042487: length 35.5
  TOP w0.127: PD3.1 180.95,179.04 v2(181.69,178.3)
  TOP w0.254: v3(180.65,181.4) 180.95,181.1 PD3.1
  TOP w0.508: PR10.1 154.31,184.35 v3(153.78,183.81)
  IN1 w0.508: v3(153.78,183.81) 153.78,183.3 154.22,182.86 156.05,182.86 157.12,181.79 159.35,181.79 159.71,181.44 169.89,181.44 169.9,181.43 172.25,181.43 173.8,179.88 177.58,179.88 178.55,180.85 180.1,180.85 180.65,181.4 v3(180.65,181.4)
  BOTTOM w0.508: PR9.1 153.32,184.27 v3(153.78,183.81)
N36042489: length 5
  TOP w0.127: v2(150.22,183.2) 150.78,183.2 PR13.1
  TOP w0.254: PR13.1 152.71,185.13 v3(153.47,185.13)
  BOTTOM w0.254: PR9.2 152.74,185.74 153.35,185.13 v3(153.47,185.13)
N36042495: length 2.2
  BOTTOM w0.254: PU1.12 158.4,188.86 158.22,189.05 157.79,189.05 PR210.2
N36042531: length 3.1
  TOP w0.508: PJ2.3 179.86,193.19 179.86,191.99 v2(179.86,191.99) 179.86,191.99 PR37.1
N36042540: length 3.5
  TOP w0.508: PJ2.4 181.13,192.46 v2(181.13,191.99) 180.95,191.81 PR30.1
N36042544: length 3.5
  BOTTOM w0.127: PR23.2 175.8,183.61 175.8,185.36 175.54,185.62 PR20.1
  vias: v2(171.86,181.04)
N36042603: length 21.7
  TOP w0.508: PQ3.6 196.84,172.78 v3(197.38,172.78)
  BOTTOM w0.508: v3(197.38,172.78) 196.05,172.78 194.92,173.91 194.92,174.82 190.89,178.86 v1(190.89,181.5) 187.63,181.5 v1(184.15,184.98)
  vias: v2(182.68,184.63)
N36042641:
  vias: v2(180.5,188.31)
N36042643: length 12.5
  TOP w0.127: v2(179.71,179.27) 179.25,179.72 v3(179.25,180.21)
  TOP w0.508: PQ4.3 178.87,180.59 v3(179.25,180.21) ; v3(182.66,186.78) 182.53,186.91 PR8.2
  BOTTOM w0.508: v3(179.25,180.21) 179.71,180.66 180.9,180.66 182.66,182.42 v3(182.66,186.78)
N36042645: length 6.4
  TOP w0.254: PR33.1 156.3,188.42 v3(156.62,188.74) 156.75,188.87 157.33,188.87 158.04,188.16 160.51,188.16 161.04,188.69 161.29,188.69 PQ8.3
N36042712: length 2.6
  TOP w0.508: PQ3.2 194.59,171.21 194.8,171.01 194.8,170.5 194.51,170.21 PQ3.3
N36042725: length 26.4
  TOP w0.508: PQ4.2 176.48,177.82 178.36,175.94 v2(180.22,175.94) 181,175.94 v3(181.16,175.79) ; PQ3.5 197.03,171.21 197.14,171.32 PR7.1 197.69,171.84 v3(197.44,172.1)
  BOTTOM w0.508: v3(181.16,175.79) 190.81,175.79 193.73,172.87 195.03,172.87 195.8,172.1 v3(197.44,172.1)
N36042869: length 2.2
  TOP w0.127: v2(170.57,187.72) 170.54,187.75 PR22.2
  TOP w0.508: PC22.1 169.57,187.75 PR22.2
N36042962: length 3.6
  TOP w0.508: PC15.2 163.81,190.01 v3(163.94,190.14) 163.35,190.72 PD4.1
  BOTTOM w0.127: v2(163.94,190.87) v3(163.94,190.14)
  BOTTOM w0.508: PR16.1 163.86,190.06 v3(163.94,190.14)
N36043036: length 4.1
  TOP w0.508: PJ2.5 184.31,193.64 v2(184.31,191.99) 184.38,191.92 PC27.1 PR39.1
N36043075: length 50.8
  TOP w0.254: PR15.1 191.42,185.92 191.39,185.89 v3(191.39,185.84)
  IN2 w0.254: v3(191.39,185.84) 191.51,185.72 191.51,181 189.53,179.01 175.21,179.01 172.66,181.56 165.14,181.56 163.94,182.76 163.03,182.76 161.22,184.57 160.8,184.57 160.78,184.59 160.35,184.59 160.33,184.57 157.1,184.57 v3(156.95,184.73)
  BOTTOM w0.254: v3(156.95,184.73) 157.11,184.88 PU1.5 157.9,184.31 157.73,184.13 157.09,184.13 156.32,183.36 156.32,182.52 156.11,182.31 PQ6.2 PQ6.5
N36043093: length 3.4
  BOTTOM w0.254: PQ6.6 152.21,182.96 151.57,183.61 PR14.1 151.36,183.62 151.36,184.77 PR17.2
N36043210: length 2.6
  BOTTOM w0.254: PR19.2 155.23,185.5 155.65,185.92 155.65,186.19 156.04,186.58 156.48,186.58 156.51,186.61 PU1.8
N36043795: length 2.1
  BOTTOM w0.254: PU1.9 156.23,187.11 v3(156.21,187.09) 155.66,187.09 PR21.2
N36047353: length 78.3
  IN1 w0.508: v3(171.28,7.14) 171.28,8.57 170.11,9.75 170.11,10.78 166.62,14.27 134.65,14.27 128.86,8.48 v3(126.27,8.48)
  BOTTOM w0.508: v3(126.27,8.48) PQ21.2 126.09,7.31 125.07,8.32 123.47,8.32 123.19,8.04 123.19,7.36 122.75,6.91 PR61.2 121.05,8.31 PR66.1 119.66,8.39 PQ18.3 ; PQ20.2 v2(177.8,12.26) 177.8,9.47 174.76,6.42 174.76,5.38 174.45,5.07 172.08,5.07 PQ19.2 171.28,7.14 v3(171.28,7.14)
N36047359: length 15.1
  BOTTOM w0.127: PR214.1 126.45,12.13 v2(126.45,12.13)
  BOTTOM w0.508: PQ53.2 135.66,7.13 133.91,7.13 PQ52.2 131.88,7.14 131.18,7.14 130.87,7.45 130.87,8.19 129.49,9.57 PQ51.3 127.77,10.35 PR213.2 126.47,11.16 PR214.1
N36047418: length 4
  BOTTOM w0.127: v3(134.42,11.65) 134.79,11.28 PR217.2
  BOTTOM w0.508: PQ53.3 134.79,9.02 PR217.2
N36047494: length 4.4
  TOP w0.127: PC47.2 42.5,68.73 v2(42.75,68.98)
  TOP w0.508: PD5.1 41.76,67.68 PC47.2 41.74,68.75 PD6.2
N36048419: length 4
  BOTTOM w0.508: PQ19.3 171.69,7.91 172.09,7.51 172.09,7.12 PR62.2
N36048427: length 5.4
  BOTTOM w0.127: v2(179.78,12.67) 179.76,12.69 PR63.2
  BOTTOM w0.508: PR63.2 178.69,14.95 178.69,15.28 177.58,16.4 PQ20.3
N36048469: length 3.1
  TOP w0.508: v1(44.2,57.85) 43.84,57.5 PR48.2
  BOTTOM w0.127: PR48.2 v2(43.84,55.95)
  BOTTOM w0.508: PR48.2 43.84,57.5 v1(44.2,57.85)
N36048510: length 2.3
  TOP w0.127: v2(52.48,53.59) 52.48,53.58 PC43.1
  TOP w0.508: PR51.2 52.48,51.33 PC43.1
N36048553: length 4.3
  TOP w0.127: PU3.7 41.13,57.2 v3(40.92,56.99) 40.53,56.59 PR47.2
  BOTTOM w0.127: PR47.2 40.52,55.75 40.52,56.58 v3(40.92,56.99)
N36048614: length 4.6
  TOP w0.127: PC46.1 38.84,66.44 v2(38.43,66.85)
  TOP w0.508: PD6.3 39.33,68.32 39.33,67.38 39.43,67.28 PC46.1
N36048618: length 4
  TOP w0.127: v2(38.43,64.94) 38.46,64.97 PC46.2
  TOP w0.508: PR56.2 PC45.2 40.31,65.86 PC46.2
N36048690: length 5.2
  TOP w0.127: PD5.3 44.76,65.19 v2(44.96,64.99)
  TOP w0.508: PC45.1 40.8,67.22 42.82,65.19 PD5.3
N36048698: length 2.3
  TOP w0.127: 53.77,70.17 v2(52.76,70.17)
  TOP w0.508: PC44.1 53.77,68.9 53.77,70.17
N36048743: length 3.4
  TOP w0.508: PR49.1 43.87,63.52 v1(44.22,63.87)
  BOTTOM w0.127: PR49.1 v2(44.84,62.81)
  BOTTOM w0.508: PR49.1 43.87,63.52 v1(44.22,63.87)
N36052805: length 2.4
  BOTTOM w0.127: v2(192.76,127.83) 192.76,127.83 PC53.1
  BOTTOM w0.508: PC53.1 193.93,126.84 PR69.1
N36052894: length 1.3
  TOP w0.508: PR73.2 PC56.1
N36054655: length 2.2
  TOP w0.127: PR82.2 v2(57.84,42.33)
  TOP w0.508: PC67.1 57.84,40.2 PR82.2
N36054782: length 3.2
  TOP w0.508: v1(57.13,34.89) 57.13,33.82 PC64.1
  BOTTOM w0.127: v1(57.13,34.89) 56.77,35.25 v3(56.77,35.53)
  BOTTOM w0.508: v1(57.13,34.89) 57.13,33.82 PC64.1
N36062145: length 2.6
  BOTTOM w0.254: PR138.2 158.93,137.64 v3(159.54,138.25) 160.11,138.82 PU8.13
N36062147:
  vias: v2(162.59,135.96)
N36062169: length 3.4
  BOTTOM w0.254: PU8.7 164.72,139.32 165.57,138.46 PR141.1 166.8,138.46 PC102.2
N36062186: length 2.5
  BOTTOM w0.127: PR138.1 v3(157.69,136.16)
  BOTTOM w0.254: PC97.1 PR138.1
N36062192: length 3.6
  BOTTOM w0.254: PC104.1 164.02,136 163.5,136.52 v2(163.5,136.85) 163.03,137.32 PU8.9
N36062196: length 3.7
  BOTTOM w0.127: PR142.1 164.77,137.2 v3(164.75,137.23)
  BOTTOM w0.254: PR142.1 165.73,137.58 164.49,138.82 PU8.8
N36062202: length 1.4
  BOTTOM w0.254: PC103.1 166.73,139.24 PR141.2
N36062254: length 3.7
  BOTTOM w0.127: PR139.2 PC101.2 158.86,140.51 v3(159.39,139.97) 159.55,139.82 PU8.15
N36062279: length 2
  TOP w0.127: PC106.2 52.99,105.91 51.72,104.64 v2(51.67,104.64)
N36062283: length 10.5
  TOP w0.508: PD7.1 v2(41.1,108.78) PR144.1 44.88,107.99 PQ27.1
N36062320: length 4.2
  TOP w0.127: v2(49.89,103.9) 49.81,103.98 PQ27.3
  TOP w0.508: PR151.1 50.96,105.63 50.47,106.11 PQ27.3
N36062324:
  vias: v2(46.16,107.79)
N36062358:
  vias: v2(56.29,108.32)
N36062370: length 29
  TOP w0.508: v3(42.24,111.63) 42.3,111.58 PQ35.3
  BOTTOM w0.508: v3(42.24,111.63) 42.22,111.63 v2(41.43,110.84) 40.21,109.62 24.8,109.62 19.54,104.35 PR156.1
N36062990: length 7.1
  TOP w0.127: PQ31.3 35.59,54.93 v2(36.28,54.25)
  TOP w0.508: PQ31.3 34.06,52.24 33.3,51.47 PR146.2
N36062996: length 4.1
  TOP w0.127: PR147.2 31.15,62.76 v2(31.22,62.83)
  TOP w0.508: PQ32.3 31.15,60.02 PR147.2
N36063064: length 4.1
  TOP w0.127: PR148.2 35.09,62.81 v2(35.11,62.83)
  TOP w0.508: PR148.2 34.06,60.39 PQ28.3
N36065296: length 4.7
  BOTTOM w0.127: PR185.1 177.33,138.7 v3(177.32,138.7)
  BOTTOM w0.254: PR185.1 PR186.2 177.57,136.97 PR180.1 PC130.2
N36065304: length 3.7
  BOTTOM w0.127: PR181.1 PR187.2 PR188.2 v3(178.29,134.44)
N36065323: length 3.1
  TOP w0.127: PQ40.2 191.79,134.44 PC136.1 192.12,134.43 192.71,135.02 v2(192.71,135.3)
N36065338: length 3.6
  TOP w0.127: PR165.1 179.86,134.6 PC113.2 PR163.2 v2(180.6,133.17)
N36065388: length 1.4
  TOP w0.127: PR178.2 183.16,135.16 PR182.1
N36065397: length 6.4
  TOP w0.127: v3(185.09,134.08) 185.09,134.71 PR170.2 PR174.1 186.47,136.09 PR179.1
  BOTTOM w0.127: PR179.1 186.2,135.97 186.06,135.83 186.06,135.35 185.96,135.25 185.51,135.25 PR172.2 185.45,134.43 v3(185.09,134.08)
N36065404: length 3
  TOP w0.508: v1(190.25,141.27) 189.97,141.55 PC114.1
  BOTTOM w0.127: v3(190.66,140.68) 190.66,140.86 v1(190.25,141.27)
  BOTTOM w0.508: PR160.1 189.31,141.27 v1(190.25,141.27)
N36065475: length 2.3
  TOP w0.127: PC120.1 v2(189.74,159.45)
  TOP w0.508: PC120.1 PR168.2
N36065515: length 2.6
  TOP w0.127: PC123.2 PR177.1 177.55,137.97 v2(177.55,137.97)
N36065632: length 2.4
  TOP w0.127: v2(177.07,159.45) 177.09,159.48 PC135.1
  TOP w0.508: PC135.1 178.08,160.7 PR183.2
N36065662: length 2.7
  TOP w0.508: v3(178.59,141.32) 178.79,141.52 179.86,141.52
  BOTTOM w0.508: PR175.1 178.79,141.52 v3(178.59,141.32)
N36065747: length 2.8
  TOP w0.127: PQ40.3 186.85,135.45 PR179.2 186.59,134.36 v2(186.8,134.16)
N36067680: length 4.7
  TOP w0.127: PR200.2 v2(115.06,133.3)
  TOP w0.508: PR200.2 PR202.1 PC146.2 119.78,133.3 PQ45.2
N36067690: length 13.1
  TOP w0.127: PR197.2 v2(117.12,136.62)
  TOP w0.508: PR197.2 PR201.1 119.11,135.59 119.37,135.32 PQ45.3 121.57,135.32 PQ46.2 124.61,134.31 126.39,134.31 PQ44.2
N36067708: length 2.3
  TOP w0.127: v3(130.33,191) PR29.1
  TOP w0.508: PR29.1 129.47,190.49 129.87,190.09 PC138.1
N36067805: length 2.3
  BOTTOM w0.127: PR190.2 v2(129.16,183.38)
  BOTTOM w0.508: PR190.2 PC152.1
N36067912: length 16.7
  TOP w0.508: PQ50.2 PQ49.2 154.97,144.09 155.98,145.1 156.65,145.1 157.64,146.09 157.64,147.77 v2(157.56,147.85) 157.56,148.1 159.01,149.55 PQ48.3 160.23,149.55 160.71,150.03 162.26,150.03 162.46,149.83 PR207.1 PR203.2
N36068493: length 3.1
  TOP w0.508: PQ44.3 128.55,135.45 131.47,135.45 PR198.2
N36068503: length 8.3
  TOP w0.127: PR206.2 v2(165.66,147.52)
  TOP w0.508: 158.78,147.52 158.78,148.17 159.14,148.53 161.7,148.53 162.46,147.77 PR208.1 PC148.2 PR206.2
N36068517: length 3.7
  TOP w0.127: PR204.2 154.75,148.02 154.33,148.43 v2(154.06,148.43)
  TOP w0.508: PR204.2 155.98,147.51 155.98,146.12
N36137819: length 2.8
  TOP w0.508: Q30.2 173.98,78.26 R241.2 173.95,77.26 R244.1
N36209502: length 7
  BOTTOM w0.508: Q50.3 185.8,109.47 v2(188.24,109.47) 188.34,109.47 R492.2 189.3,110.83 190.56,112.08
N36508370: length 2.6
  TOP w0.127: v2(56.01,95.5) 55.81,95.5 PC141.2
  TOP w0.508: PR126.1 55.04,93.44 PC141.2
N36508396: length 3.8
  TOP w0.127: PR184.1 65.76,91.44 65.76,92.2 v3(66.04,92.48)
  BOTTOM w0.127: v3(66.04,92.48) 66.1,92.42 PL12.4
N36508398: length 4
  TOP w0.127: v3(65.39,92.51) 65.51,92.39 65.51,91.55 PR127.1
  BOTTOM w0.127: PL12.3 65.31,92.42 v3(65.39,92.51)
N36508411: length 1.2
  BOTTOM w0.127: PR196.2 PR212.2
N36508780: length 4.7
  TOP w0.191: PR122.1 49.02,94.58 v3(49.3,94.3)
  BOTTOM w0.178: PU7.3 48.03,93.23 49.1,94.3 v3(49.3,94.3) 49.4,94.3 PR118.1
N36509488: length 1.8
  BOTTOM w0.508: PR194.2 60.23,87.14 PC160.1
N36509518: length 2.4
  BOTTOM w0.127: v3(39.09,99.56) PR132.2
  BOTTOM w0.254: PR132.2 40.05,98.52 PC93.2
N36510057: length 2.4
  TOP w0.127: PC84.2 52.22,86.81 v2(52,87.04)
  TOP w0.203: PC84.2 52.25,86.02 PR105.1
N36510083: length 3.8
  TOP w0.127: PR107.1 63.45,84.57 v3(63.45,83.48)
  BOTTOM w0.127: v3(63.45,83.48) 64.37,82.57 PL6.4
N36510087: length 4.1
  TOP w0.127: v3(62.78,83.46) 62.78,84.61 PR106.1
  BOTTOM w0.127: PL6.3 61.89,82.57 v3(62.78,83.46)
N36510102: length 1.1
  BOTTOM w0.127: PR114.2 PR108.2
N36510197: length 1.5
  BOTTOM w0.508: PR104.2 PC85.1
N36763285: length 6.2
  BOTTOM w0.127: R717.2 174.69,10.05 R746.2 ; R717.2 174.07,10.06 173.54,10.58 R716.1 ; R717.2 174.68,10.56 175.02,10.9 R714.2 174.77,12.24 173.77,12.24 173.54,12.01 R713.1
N37442043: length 89.9
  TOP w0.127: v3(190.2,73.58) 189.03,74.75 v2(188.75,74.75) 188.01,74.75 187.29,75.46 186.62,75.46 184.94,77.13 184.94,80.77 187.02,82.84 190.05,82.84 191.41,84.2 191.41,85.88 192.02,86.49 192.02,90.2 191.09,91.13 191.09,92.36 189.46,93.99 189.46,96.09 190.25,96.88 190.25,100.35 187.84,102.76 187.84,103.04 187.26,103.62 186.9,103.62 186.44,104.08 186.44,105.45 v3(186.48,105.49)
  IN1 w0.133: v3(190.2,73.58) 189.31,72.69 189.31,69 191.65,66.66 191.65,62.96 193.96,60.65 193.96,44.39 195.19,43.17 CN11.9
  IN2 w0.133: v3(177.19,105.12) 177.78,104.54 179.88,104.54 181.78,106.44 185.53,106.44 v3(186.48,105.49)
  BOTTOM w0.102: v3(177.19,105.12) 175.78,103.71 R523.2
N38261008:
  vias: v2(20.78,108.12)
N38647309: length 4.3
  TOP w0.127: Q59.1 178.36,174.71 R741.2
N38647316: length 2.1
  TOP w0.127: Q60.2 176.76,175.52 R741.1
N357965030: length 2.5
  TOP w0.127: R264.1 85,70.42 v3(85.25,70.17)
  TOP w0.508: Q34.3 82.85,70.42 R264.1
N360299253: length 3.7
  TOP w0.127: U16.9 117.36,11.9 TP75.1
N360378000: length 1.7
  TOP w0.127: TP67.1 156.51,67.1 SW1.4
N360382040: length 1.9
  TOP w0.127: SW1.1 166.23,70.7 TP65.1

## Copper pours and planes (outline as drawn)
51211V_DRVH on TOP (solid shape): 186.95,129.56 186.95,128.44 186.89,128.39 186.11,128.39 186.03,128.47 186.03,129.48 186.16,129.61 186.89,129.61
51211V_DRVL on TOP (solid shape): 188.32,126.13 188.32,125.44 188.27,125.39 185.98,125.39 185.6,125.77 184.56,125.77 184.43,125.9 184.43,126.66 184.46,126.69 187.76,126.69
51211V_DRVL on BOTTOM (solid shape): 188.77,125.77 188.77,124.88 188.72,124.83 188.32,124.83 187.45,125.7 187.45,125.93 187.56,126.03 188.52,126.03
51211V_SW on TOP (solid shape): 186.91,131.6 186.91,129.93 186.82,129.84 185.83,129.84 185.57,129.58 185.57,127.88 185.93,127.53 189.26,127.53 189.49,127.3 191.67,127.3 191.85,127.12 191.85,126.51 191.8,126.46 190.91,126.46 190.76,126.61 189.87,126.61 189.79,126.54 189.79,124.88 189.74,124.83 189.54,124.83 189.49,124.88 189.49,126.36 188.67,127.17 185.41,127.17 185.28,127.3 182.02,127.3 181.66,127.65 181.66,129.84 181.38,130.12 180.65,130.12 180.53,130.24 180.53,131.57 180.7,131.74 186.77,131.74
51211V_SW on BOTTOM (solid shape): 186.97,131.54 186.97,129.89 186.92,129.84 185.83,129.84 185.57,129.58 185.57,127.88 185.93,127.53 189.26,127.53 189.49,127.3 191.67,127.3 191.85,127.12 191.85,126.51 191.8,126.46 190.91,126.46 190.76,126.61 189.87,126.61 189.79,126.54 189.79,125.69 189.78,125.69 189.78,124.87 189.74,124.83 189.54,124.83 189.5,124.87 189.5,125.69 189.49,125.69 189.49,126.36 188.67,127.17 182.15,127.17 181.66,127.65 181.66,129.84 181.38,130.12 180.6,130.12 180.47,130.24 180.47,131.56 180.65,131.74 186.77,131.74
51211V_VBST on BOTTOM (solid shape): 194.54,125.67 194.54,124.81 194.44,124.71 192.13,124.71 192,124.83 190.53,124.83 190.5,124.86 190.5,125.7 190.53,125.72 194.49,125.72
+1.5V on TOP (solid shape): 148.72,109.09 148.72,107.31 148.44,107.03 147.59,107.03 147.4,107.21 147.4,109.04 147.8,109.44 148.36,109.44
+1.05V on TOP (solid shape): 166.81,127.7 166.81,127.3 166.65,127.15 166.09,127.15 165.41,126.46 162.49,126.46 161.83,127.12 161.83,127.68 161.97,127.82 166.69,127.82
+1.05V on TOP (solid shape): 182.71,118.76 182.71,118.08 182.38,117.75 181.44,117.75 180.88,118.31 180.43,118.31 180.29,118.44 180.29,118.99 180.45,119.14 182.33,119.14
+1.05V on TOP (solid shape): 181.23,104.46 181.23,104.36 181.23,104.36 181.23,103.42 181.4,103.26 181.4,103.05 181.14,102.8 180.48,102.8 180.32,102.96 178.94,102.96 178.87,103.03 178.87,104.46 179.05,104.64 181.05,104.64
+1.05V on TOP (solid shape): 142.75,104.35 142.75,104.35 142.95,104.16 143.77,104.16 144.33,103.6 144.98,103.6 145.9,102.68 145.9,101.24 145.37,100.7 144.33,100.7 143.83,100.21 139.77,100.21 139.53,99.97 139.53,97.33 139.35,97.15 138.64,97.15 137.75,98.04 137.75,102.86 140.36,105.48 141.62,105.48
+1.05V on TOP (solid shape): 147.32,112.21 147.32,110.57 146.63,109.87 145.59,109.87 145.44,110.03 145.44,110.36 145.45,110.38 145.46,110.4 145.6,110.69 145.46,110.98 145.45,110.99 145.44,111.02 145.44,112.03 145.9,112.49 147.04,112.49
+1.05V on TOP (solid shape): 150.14,115.51 150.14,114.6 149.76,114.22 148.62,114.22 148.59,114.24 148.59,114.26 148.41,114.52 148.09,114.55 148.02,114.55 147.97,114.6 147.97,115.96 148.19,116.17 149.48,116.17
+1.5V on TOP (solid shape): 152.09,119.89 152.09,117.84 152.47,117.46 154.54,117.46 155.73,116.27 157.13,116.27 157.31,116.1 157.31,115.51 157.21,115.2 157.31,114.9 157.31,113.84 157.47,113.68 157.65,113.51 157.89,113.45 158.1,113.45 158.16,113.39 158.16,112.94 158.03,112.81 157.39,112.81 156.36,113.84 155.55,113.84 155.27,114.12 155.27,114.8 154.41,115.66 152.78,115.66 152.44,115.33 152.44,114.89 151.82,114.27 150.73,114.27 150.5,114.5 150.5,115.51 150.26,115.75 150.26,116.52 150.25,116.53 150.25,118.32 150.25,118.34 150.27,118.36 150.38,118.63 150.27,118.91 150.25,118.92 150.25,118.94 150.25,119.45 150.85,120.06 151.92,120.06
+1.05V on TOP (solid shape): outline of 184 points within 161.01,116.99 170.26,122.6
+1.05V on BOTTOM (solid shape): 91.19,118.33 91.19,117.34 90.81,116.96 89.01,116.96 88.35,117.62 88.35,118.38 88.45,118.48 91.04,118.48
+1.5V on BOTTOM (solid shape): 141.61,107.41 141.61,106.55 141.39,106.33 139.12,106.33 138.84,106.61 138.84,107.06 139.43,107.65 141.37,107.65
+1.05V on BOTTOM (solid shape): 103.84,122.62 103.84,121.25 103.13,120.54 101.58,120.54 101.45,120.67 101.45,121.2 101.6,121.35 101.96,121.35 102.32,121.71 102.32,122.7 102.67,123.06 103.41,123.06
+1.05V on BOTTOM (solid shape): 168.18,128.35 168.18,126.39 167.94,126.15 162.34,126.15 162.03,126.46 162.03,128.06 162.23,128.26 167.06,128.26 167.28,128.49 168.04,128.49
+1.05V on BOTTOM (solid shape): 149.71,116.63 149.71,115.51 149.61,115.41 147.32,115.41 146.86,115.87 146.86,116.76 146.92,116.96 146.86,117.16 146.86,117.37 147.14,117.65 148.69,117.65
+1.05V on BOTTOM (solid shape): 139.86,105.68 139.86,104.49 139.96,104.39 141.63,104.39 141.75,104.5 141.75,105.31 141.91,105.48 142.83,105.48 142.83,104.26 142.32,103.75 142.32,99.64 139.83,97.15 138.64,97.15 137.89,97.9 137.89,105.39 138.25,105.76 139.78,105.76
+1.5V on BOTTOM (solid shape): outline of 106 points within 150.12,126.15 159.01,135.5
+1.05V on SVCC (solid shape): 173.64,126.99 173.64,125.87 173.64,122.16 173.64,122.12 173.64,122.07 173.64,120.64 173.64,120.59 173.64,120.55 173.64,119.41 171.51,117.28 170.95,117.27 170.95,116.72 168.22,113.99 153.21,113.99 152.81,114.34 152.42,113.99 152.05,113.99 151.85,113.95 151.69,113.84 148.38,110.54 148.27,110.37 148.24,110.17 148.24,107.63 148.1,107.33 148.24,107.03 148.24,102.39 145.97,100.12 145.86,99.96 145.83,99.76 145.83,94.1 145.75,93.87 145.83,93.65 145.83,93.37 145.36,92.91 139.43,92.91 137.06,95.28 137.06,115.05 137.21,115.2 137.7,115.26 137.75,115.74 147.88,125.87 147.96,125.93 148.03,126.01 149.46,127.45 173.17,127.45
+1.05V on IN1 (solid shape): 91.19,118.33 91.19,117.09 91.04,116.93 90.23,116.93 90.07,117.09 90.07,118.1 90.43,118.46 91.06,118.46
+1.05V on IN1 (solid shape): 104.22,121.38 104.22,120.74 103.94,120.47 101.6,120.47 101.48,120.59 101.48,121.47 101.68,121.67 103.93,121.67
+1.05V on IN1 (solid shape): 139.3,116.77 139.3,115.05 139.16,114.92 137.99,114.92 137.88,115.03 137.88,116.77 138,116.89 139.18,116.89
+1.05V on IN1 (solid shape): 182.45,118.63 182.48,118.62 182.99,118.12 182.99,117.32 182.86,117.19 181.87,117.19 181.35,117.71 181.35,117.91 181.33,117.93 181.33,118.42 181.55,118.63
+1.05V on IN1 (solid shape): 184.44,106.32 184.44,106.22 184.37,106.13 184.26,106.16 183.56,105.91 184.26,105.66 184.37,105.7 184.44,105.6 184.44,105 184.38,104.91 184.28,104.91 183.66,104.59 184.28,104.27 184.38,104.27 184.44,104.18 184.44,103.72 183.62,102.89 183,102.89 183.01,102.98 182.81,103.4 182.34,103.34 182.22,103.21 182.22,100.82 180.75,99.36 178.97,99.36 178.49,99.84 178.49,100.25 178.74,100.5 180.12,100.5 180.67,101.06 180.67,104.16 181.05,104.53 181.14,104.56 181.21,104.51 181.49,104.3 181.83,104.4 181.9,104.43 181.97,104.4 182.39,104.32 182.64,104.67 182.4,105.05 181.95,104.96 181.89,104.95 181.83,104.98 181.79,105.01 181.73,105.05 181.73,106.67 182.13,107.06 183.69,107.06
+1.5V on IN1 (solid shape): outline of 1937 points within 138.28,99.78 171,126.92
+1.05V_GFX on TOP (solid shape): 132.16,134.59 132.16,132.71 131.88,132.43 131.04,132.43 130.81,132.66 130.81,134.61 130.89,134.69 132.06,134.69
+1.05V_GFX on TOP (solid shape): 138.56,140.53 138.56,139.74 138.28,139.46 138.26,139.46 138.25,139.46 137.94,139.36 137.82,139.08 138.01,138.53 138.58,138.61 138.65,138.64 138.73,138.61 139.08,138.26 139.08,135.62 137.77,134.31 136.22,134.31 135.95,134.58 135.95,136.38 136.09,136.52 136.67,136.52 136.78,136.63 136.78,137.58 135.56,138.8 135.56,139.18 135.84,139.46 137.39,139.46 137.98,140.05 137.98,140.3 138.26,140.58 138.51,140.58
+1.05V_GFX on TOP (solid shape): outline of 311 points within 135.13,144.87 155.38,154.5
+1.05V_GFX on BOTTOM (solid shape): outline of 492 points within 130.88,132.45 150.49,153.36
+1.05V_GFX on IN1 (solid shape): outline of 2356 points within 132.19,137.84 150.22,153.45
+1.05V_S5 on TOP (solid shape): 179.71,130.73 179.71,121.68 179.49,121.47 176.17,121.47 175.77,121.86 175.77,129.46 177.3,130.98 179.45,130.98
+1.05V_S5 on TOP (solid shape): 134.98,137.66 135.02,137.68 135.05,137.66 135.29,137.43 135.29,134.29 134.93,133.93 134.93,133.01 134.04,132.12 132.62,132.12 132.36,132.38 132.36,136.57 132.95,137.15 133.76,137.15 134.27,137.66
+1.05V_S5 on BOTTOM (solid shape): 179.71,131.49 179.71,121.63 179.3,121.23 176.13,121.23 175.77,121.58 175.77,123.87 174.32,125.32 172.8,125.32 172.58,125.1 172.58,124.7 172.57,124.68 172.52,124.67 172.39,124.59 172.3,124.47 172.3,124.46 172.25,124.43 170.97,124.43 170.81,124.59 169.15,124.59 168.3,125.44 168.3,125.95 168.87,126.52 168.87,129.62 169.14,129.89 172.42,129.89 174.53,132 179.2,132
+1.05V_S5 on IN1 (solid shape): outline of 413 points within 132.26,124.05 170.1,134.92
+1.5VA on TOP (solid shape): 36.2,27.94 36.27,27.91 36.3,27.84 36.31,27.71 36.36,27.57 36.39,27.5 36.39,26.41 36.27,26.29 35.83,26.29 35.12,27 35.11,27.01 35.11,27.03 35.11,27.4 35.65,27.94
+1.5VA on BOTTOM (solid shape): 36.01,27.37 36.01,26.36 35.84,26.18 35.15,26.18 35.01,26.32 35.01,27.38 35.19,27.57 35.81,27.57
+1.35V_GFX on TOP (solid shape): 115.75,160.83 115.75,157.42 115.73,157.34 115.73,157.26 115.73,157.03 115.73,156.95 115.75,156.86 115.75,156.76 115.76,156.75 115.76,154.11 115.63,153.97 115.27,153.97 115.12,154.12 113.97,154.12 113.92,154.17 113.92,154.59 113.94,154.78 113.92,154.97 113.92,155.67 113.92,155.67 113.92,156.22 113.92,156.26 113.92,156.56 113.92,156.59 113.92,160.83 113.97,160.88 115.7,160.88
+1.35V_GFX on TOP (solid shape): 114.55,165.78 115.62,165.78 116.21,165.19 117.94,165.19 118,165.14 118,165.05 118.2,164.85 118.21,164.85 118.24,164.82 118.24,164.68 117.99,164.43 117.99,164.26 117.99,164.25 117.48,164.25 117.47,164.26 117.36,164.28 117.24,164.26 117.2,164.25 117.17,164.23 117.1,164.17 117.05,164.1 116.87,163.92 116.87,163.59 116.95,163.52 118.04,163.52 118.22,163.34 118.22,162.93 118.04,162.76 114.23,162.76 114.17,162.81 114.17,163.2 114.22,163.28 114.31,163.29 114.84,163.65 114.31,164 114.22,164.01 114.17,164.09 114.17,165.75 114.25,165.83 114.5,165.83
+1.35V_GFX on TOP (solid shape): outline of 141 points within 114.1,170 118.09,177.08
+1.35V_GFX on TOP (solid shape): outline of 288 points within 113.99,139.52 118.93,149.49
+1.35V_GFX on TOP (solid shape): outline of 136 points within 138.54,156.78 147.89,164.87
+1.35V_GFX on TOP (solid shape): outline of 806 points within 122.94,143.34 126.88,156.15
+1.35V_GFX on BOTTOM (solid shape): 115.72,159.81 115.72,157.22 115.77,157.17 115.77,151.07 115.44,150.74 114.25,150.74 114,151 114,159.73 114.05,159.78 114.94,159.78 115.19,160.04 115.5,160.04
+1.35V_GFX on BOTTOM (solid shape): 115.8,145.43 115.8,145 116.79,144.01 116.79,142.94 116.23,142.39 116.23,139.52 116.03,139.31 114.1,139.31 113.84,139.58 113.84,141.83 114.2,142.19 114.2,143.22 113.95,143.48 113.95,145.46 114.15,145.66 115.57,145.66
+1.35V_GFX on BOTTOM (solid shape): 141.56,187.19 141.56,185.69 141.63,185.62 143.18,185.62 143.44,185.36 143.44,184.94 143.44,184.93 143.44,182.77 144.63,181.58 144.63,181.58 145.32,180.89 145.32,176.85 145.67,176.5 146.03,176.5 146.33,176.19 146.33,175.94 146.08,175.68 144.23,175.68 143.39,176.52 143.36,176.52 139.98,179.9 139.98,179.9 138.75,181.14 138.58,181.14 137.72,182 137.72,186.73 137.98,186.99 139.04,186.99 139.53,187.47 141.28,187.47
+1.35V_GFX on BOTTOM (solid shape): 128.27,171.09 128.27,166.44 128.02,166.19 128.02,165.7 128.27,165.45 128.27,165.15 126.03,162.9 125.95,162.87 125.87,162.91 125.6,163.05 125.32,162.92 125.25,162.88 125.17,162.9 124.93,162.98 124.69,162.88 124.53,162.88 124.48,162.83 124.47,162.83 124.2,163.1 124.2,163.46 124.41,163.67 124.46,163.69 124.61,163.69 124.64,163.68 124.65,163.67 125.14,163.57 125.25,164.06 125.25,165.52 124.97,165.8 124.97,166.85 125.15,167.02 125.76,167.02 126.2,167.47 126.2,168.08 125.28,169 125.28,169.36 125.48,169.56 125.68,169.56 126.01,169.23 126.67,169.23 126.93,169.48 126.93,170.93 127.31,171.32 128.05,171.32
+1.35V_GFX on BOTTOM (solid shape): outline of 120 points within 139.85,153.96 147.94,165.23
+1.35V_GFX on BOTTOM (solid shape): outline of 458 points within 114.02,166.95 119.71,175.94
+1.35V_GFX on IN1 (solid shape): outline of 7370 points within 110.09,140.81 157.86,188.21
+1.35V_GFX on IN2 (solid shape): outline of 1544 points within 113.9,153.04 128.66,165.82
+1.35V_GFX on IN2 (solid shape): outline of 1583 points within 141.14,160.42 153.04,178.17
+1.35V_SUS on TOP (solid shape): outline of 14400 points within 92.04,25.93 124.17,96.05
+1.35V_SUS on BOTTOM (solid shape): 54.74,29.68 54.74,28.69 54.94,28.49 55.27,28.49 55.45,28.31 55.45,28.06 55.27,27.88 55.02,27.88 54.84,28.06 54.84,28.39 54.56,28.67 54.56,29.66 54.61,29.71 54.71,29.71
+1.35V_SUS on BOTTOM (solid shape): outline of 118 points within 96.07,46 113.59,52.71
+1.35V_SUS on BOTTOM (solid shape): outline of 442 points within 68.44,49.09 113.24,73.37
+1.35V_SUS on BOTTOM (solid shape): outline of 475 points within 61.24,18.87 113.49,42.18
+1.35V_SUS on BOTTOM (solid shape): outline of 1529 points within 101.97,91.75 122.42,98.24
+1.35V_SUS on IN1 (solid shape): outline of 1682 points within 102.09,91.49 124.45,98.12
+1.35V_SUS on IN2 (solid shape): outline of 1477 points within 99.43,89.76 120.68,98.63
+3V on TOP (solid shape): 146.58,21.7 146.58,20.58 146.36,20.36 144.58,20.36 144.28,20.67 144.28,21.79 144.43,21.94 146.34,21.94
+3V on TOP (solid shape): 112.88,17.53 112.88,15.86 112.55,15.54 111.89,15.54 111.71,15.72 109.28,15.72 109.17,15.82 109.17,17.57 109.4,17.8 112.61,17.8
+3V on TOP (solid shape): 156.24,89.55 156.24,88.46 154.68,86.91 153.75,86.91 153.65,87.01 153.65,87.24 153.98,87.57 154.55,87.57 155.92,88.94 155.92,89.62 155.94,89.65 155.97,89.67 156.12,89.67
+3V on TOP (solid shape): 138.77,114.75 138.99,114.67 139.22,114.75 141.81,114.75 142.34,114.22 142.34,113.91 141.51,113.07 138.22,113.07 137.93,113.36 137.93,114.05 138.63,114.75
+3V on TOP (solid shape): 168.15,177.36 168.15,177.16 168.33,176.98 168.37,176.98 168.37,176.97 169.82,176.97 169.82,176.98 170.62,176.98 171.33,176.27 171.33,175.71 171.26,175.64 171.23,175.63 171.19,175.64 171.17,175.66 170.21,175.66 169.56,176.31 167.86,176.31 167.47,176.7 167.47,177.28 167.62,177.44 168.08,177.44
+3V on TOP (solid shape): 151.08,126.48 151.08,124 150.33,123.25 150.11,123.25 150.09,123.23 149.69,123.23 149.61,123.28 149.6,123.37 149.63,123.69 149.48,123.98 149.48,124.36 149.64,124.76 149.48,125.15 149.48,126.51 149.67,126.7 150.87,126.7
+3V on TOP (solid shape): 111.74,177.06 111.75,177 111.76,176.95 111.76,176.21 111.46,175.91 110.93,175.91 110.88,175.86 110.88,175.59 110.37,175.08 110.37,175.07 110.31,175.02 109.79,175.02 109.76,175.06 109.76,176.37 109.56,176.57 108.54,176.57 108.37,176.4 108.37,175.01 108.32,174.96 107.89,174.96 107.86,174.99 107.86,175.04 107.86,176.37 106.38,177.85 106.18,177.85 106.17,177.85 105.4,177.85 105.19,177.92 104.97,177.85 104.44,177.85 104.29,178.01 104.29,178.6 104.4,178.72 110.08,178.72
+3V on TOP (solid shape): 173.24,125.78 173.24,122.2 173.05,122.01 171.55,122.01 171.36,122.21 171.36,123.61 171.36,123.61 171.36,123.72 171.51,123.87 171.51,124.23 171.42,124.31 172.27,124.31 172.27,124.28 172.28,124.23 172.29,124.17 172.32,124.12 172.35,124.08 172.38,124.03 172.43,124 172.47,123.97 172.53,123.95 172.58,123.93 172.63,123.93 172.69,123.93 172.74,123.94 172.8,123.96 172.85,123.98 172.89,124.02 172.93,124.05 172.97,124.1 172.99,124.15 173.01,124.2 173.03,124.25 173.03,124.31 173.03,124.37 173.01,124.42 172.99,124.47 172.97,124.52 172.93,124.56 172.89,124.6 172.85,124.64 172.8,124.66 172.74,124.68 172.69,124.69 172.63,124.69 172.58,124.69 172.53,124.67 172.47,124.65 172.43,124.62 172.38,124.58 172.35,124.54 172.32,124.5 172.29,124.45 172.28,124.39 172.27,124.34 172.27,124.31 171.42,124.31 171.36,124.38 171.36,125.16 170.54,125.98 170.54,126.51 170.76,126.73 172.28,126.73
+3V on TOP (solid shape): 171.31,115.63 171.31,115.6 171.43,115.21 171.82,115.09 171.85,115.09 172.01,114.93 172.01,114.04 171.86,113.89 171.11,113.89 170.95,114.06 170.72,114.13 170.7,114.13 170.61,114.22 170.63,114.25 170.44,114.8 169.98,114.44 169.96,114.36 169.88,114.33 169.31,114.33 169.17,114.47 169.17,115.29 169.59,115.72 171.22,115.72
+3V on TOP (solid shape): 170.49,156.56 170.49,146.78 170.29,146.58 169.04,146.58 168.79,146.83 168.79,147.47 168.13,148.13 168.13,149.59 168.13,149.6 168.15,149.73 168.13,149.85 168.13,149.86 168.13,153.71 166.91,154.93 165.43,154.93 165.18,155.19 165.18,156.19 165.19,156.22 165.21,156.24 165.29,156.3 165.36,156.39 165.38,156.43 165.41,156.5 165.44,156.51 165.57,156.51 165.58,156.5 165.71,156.45 165.85,156.45 165.94,156.44 166.04,156.47 167.08,156.47 167.13,156.41 167.14,156.39 167.13,156.38 167.15,156.26 167.2,156.14 167.29,156.04 167.42,155.99 167.43,155.98 167.49,155.92 168.15,155.92 168.86,156.64 168.88,156.64 169.03,156.71 169.09,156.87 169.1,156.98 169.11,157.02 169.11,157.34 169.24,157.47 169.57,157.47
+3V on TOP (solid shape): 151.52,96.02 151.52,95.55 151.22,95.25 151.22,95.13 151.19,95.09 151.18,95.08 150.96,94.74 151.18,94.39 151.19,94.38 151.22,94.34 151.22,94.14 151.21,94.12 151.19,94.1 150.98,93.76 151.19,93.41 151.2,93.41 151.22,93.38 151.22,93.19 151.46,92.94 152.51,92.94 152.64,92.81 152.64,92.34 152.88,92.1 153.38,92.1 153.4,92.09 153.42,92.07 154.04,92.03 153.88,92.63 153.85,92.65 153.85,92.68 153.85,93.39 153.86,93.41 153.87,93.42 154.07,93.64 154.05,93.93 154.06,93.96 154.18,94.08 154.71,94.08 154.77,94.02 154.77,92.3 153.49,91.02 153.41,90.99 153.33,91.02 152.99,91.17 152.69,90.96 152.69,90.95 152.52,90.79 150.87,90.79 150.07,91.59 150.07,95.55 150.64,96.11 151.43,96.11
+3V on TOP (solid shape): 178.32,114.61 178.32,113.83 177.24,112.74 177.22,112.74 176.98,112.64 176.86,112.4 176.88,112.25 176.95,112.12 176.95,107.59 176.46,107.59 176.46,107.21 176.07,106.82 176.05,106.83 175.86,106.79 175.71,106.66 175.57,106.52 174.95,106.52 174.19,105.76 173.03,105.76 172.83,105.96 172.83,106.67 173,106.85 173.18,106.85 173.49,106.69 173.8,106.85 173.94,106.85 174.6,107.51 175.79,107.51 175.86,107.58 175.86,109.01 174.8,109.01 174.78,109.01 174.54,109.04 174.33,108.91 174.32,108.9 174.3,108.89 174.19,108.89 174.17,108.9 174.15,108.91 173.86,109.04 173.58,108.91 173.56,108.9 173.54,108.89 173.3,108.89 173.2,108.99 173.2,109.69 173.24,109.7 173.35,109.74 173.45,109.81 173.47,109.83 173.51,109.85 174.12,109.85 174.19,109.82 174.22,109.75 174.64,109.37 174.97,109.83 174.97,109.86 175.42,110.31 175.43,110.32 175.59,110.4 175.69,110.54 175.7,110.55 175.72,110.57 175.72,111.39 175.98,111.64 175.98,112.98 176.42,113.43 176.66,113.43 176.66,114.8 176.78,114.93 178.01,114.93
