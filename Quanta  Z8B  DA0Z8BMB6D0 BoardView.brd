# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CC0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
CC0603
  rect 0.813x0.711 smd: 1(0.737,0) 2(-0.737,0)
CC0805
  rect 0.94x1.346 smd: 1(0.895,0) 2(-0.895,0)
CC1206
  rect 1.6x1.6 smd: 1(1.702,0) 2(-1.702,0)
CC1808
  rect 2.159x2.286 smd: 1(-2.349,0) 2(2.349,0)
CC1812
  rect 1.778x3.2 smd: 1(2.54,0) 2(-2.54,0)
CC3528
  rect 2.032x2.413 smd: 1(1.6,0) 2(-1.6,0)
CC7343
  rect 2.413x2.819 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-ETQP4LR36AFM
  rect 2.794x2.591 smd: 1(-3.2,0) 2(3.2,0)
CHOKE-PCMC063T-3R3MN-SMT
  rect 1.854x3.505 smd: 1(-3.275,0) 2(3.275,0)
CHOKE-PCMC063T-R82MN-4P-SMT
  custom 0.591x0.591 smd: 1(-3.596,0) 2(3.596,0)
  rect 1.473x0.305 smd: 3(-2.452,0) 4(2.452,0)
D-DO-214AC
  rect 1.88x2.032 smd: 1(-2.1,0) 2(2.1,0)
D-SOD523-1_2X0_8-0_65H
  rect 0.787x0.61 smd: 1(-0.55,0) 2(0.55,0)
DDR-DDRSK-20401-TP8D-204P-LDV
  round 1.6 hole 1.6 unplated: (-33.4,0)
  round 1.092 hole 1.092 unplated: (33.4,0)
  rect 0.356x2.007 smd: 1(-31.65,-4.1) 2(-31.35,4.1) 3(-31.05,-4.1) 4(-30.75,4.1) 5(-30.45,-4.1) 6(-30.15,4.1) 7(-29.85,-4.1) 8(-29.55,4.1) 9(-29.25,-4.1) 10(-28.95,4.1) 11(-28.65,-4.1) 12(-28.35,4.1) 13(-28.05,-4.1) 14(-27.75,4.1) 15(-27.45,-4.1) 16(-27.15,4.1) 17(-26.85,-4.1) 18(-26.55,4.1) 19(-26.25,-4.1) 20(-25.95,4.1) 21(-25.65,-4.1) 22(-25.35,4.1) 23(-25.05,-4.1) 24(-24.75,4.1) 25(-24.45,-4.1) 26(-24.15,4.1) 27(-23.85,-4.1) 28(-23.55,4.1) 29(-23.25,-4.1) 30(-22.95,4.1) 31(-22.65,-4.1) 32(-22.35,4.1) 33(-22.05,-4.1) 34(-21.75,4.1) 35(-21.45,-4.1) 36(-21.15,4.1) 37(-20.85,-4.1) 38(-20.55,4.1) 39(-20.25,-4.1) 40(-19.95,4.1) 41(-19.65,-4.1) 42(-19.35,4.1) 43(-19.05,-4.1) 44(-18.75,4.1) 45(-18.45,-4.1) 46(-18.15,4.1) 47(-17.85,-4.1) 48(-17.55,4.1) 49(-17.25,-4.1) 50(-16.95,4.1) 51(-16.65,-4.1) 52(-16.35,4.1) 53(-16.05,-4.1) 54(-15.75,4.1) 55(-15.45,-4.1) 56(-15.15,4.1) 57(-14.85,-4.1) 58(-14.55,4.1) 59(-14.25,-4.1) 60(-13.95,4.1) 61(-13.65,-4.1) 62(-13.35,4.1) 63(-13.05,-4.1) 64(-12.75,4.1) 65(-12.45,-4.1) 66(-12.15,4.1) 67(-11.85,-4.1) 68(-11.55,4.1) 69(-11.25,-4.1) 70(-10.95,4.1) 71(-10.65,-4.1) 72(-10.35,4.1) 73(-7.65,-4.1) 74(-7.35,4.1) 75(-7.05,-4.1) 76(-6.75,4.1) 77(-6.45,-4.1) 78(-6.15,4.1) 79(-5.85,-4.1) 80(-5.55,4.1) 81(-5.25,-4.1) 82(-4.95,4.1) 83(-4.65,-4.1) 84(-4.35,4.1) 85(-4.05,-4.1) 86(-3.75,4.1) 87(-3.45,-4.1) 88(-3.15,4.1) 89(-2.85,-4.1) 90(-2.55,4.1) 91(-2.25,-4.1) 92(-1.95,4.1) 93(-1.65,-4.1) 94(-1.35,4.1) 95(-1.05,-4.1) 96(-0.75,4.1) 97(-0.45,-4.1) 98(-0.15,4.1) 99(0.15,-4.1) 100(0.45,4.1) 101(0.75,-4.1) 102(1.05,4.1) 103(1.35,-4.1) 104(1.65,4.1) 105(1.95,-4.1) 106(2.25,4.1) 107(2.55,-4.1) 108(2.85,4.1) 109(3.15,-4.1) 110(3.45,4.1) 111(3.75,-4.1) 112(4.05,4.1) 113(4.35,-4.1) 114(4.65,4.1) 115(4.95,-4.1) 116(5.25,4.1) 117(5.55,-4.1) 118(5.85,4.1) 119(6.15,-4.1) 120(6.45,4.1) 121(6.75,-4.1) 122(7.05,4.1) 123(7.35,-4.1) 124(7.65,4.1) 125(7.95,-4.1) 126(8.25,4.1) 127(8.55,-4.1) 128(8.85,4.1) 129(9.15,-4.1) 130(9.45,4.1) 131(9.75,-4.1) 132(10.05,4.1) 133(10.35,-4.1) 134(10.65,4.1) 135(10.95,-4.1) 136(11.25,4.1) 137(11.55,-4.1) 138(11.85,4.1) 139(12.15,-4.1) 140(12.45,4.1) 141(12.75,-4.1) 142(13.05,4.1) 143(13.35,-4.1) 144(13.65,4.1) 145(13.95,-4.1) 146(14.25,4.1) 147(14.55,-4.1) 148(14.85,4.1) 149(15.15,-4.1) 150(15.45,4.1) 151(15.75,-4.1) 152(16.05,4.1) 153(16.35,-4.1) 154(16.65,4.1) 155(16.95,-4.1) 156(17.25,4.1) 157(17.55,-4.1) 158(17.85,4.1) 159(18.15,-4.1) 160(18.45,4.1) 161(18.75,-4.1) 162(19.05,4.1) 163(19.35,-4.1) 164(19.65,4.1) 165(19.95,-4.1) 166(20.25,4.1) 167(20.55,-4.1) 168(20.85,4.1) 169(21.15,-4.1) 170(21.45,4.1) 171(21.75,-4.1) 172(22.05,4.1) 173(22.35,-4.1) 174(22.65,4.1) 175(22.95,-4.1) 176(23.25,4.1) 177(23.55,-4.1) 178(23.85,4.1) 179(24.15,-4.1) 180(24.45,4.1) 181(24.75,-4.1) 182(25.05,4.1) 183(25.35,-4.1) 184(25.65,4.1) 185(25.95,-4.1) 186(26.25,4.1) 187(26.55,-4.1) 188(26.85,4.1) 189(27.15,-4.1) 190(27.45,4.1) 191(27.75,-4.1) 192(28.05,4.1) 193(28.35,-4.1) 194(28.65,4.1) 195(28.95,-4.1) 196(29.25,4.1) 197(29.55,-4.1) 198(29.85,4.1) 199(30.15,-4.1) 200(30.45,4.1) 201(30.75,-4.1) 202(31.05,4.1) 203(31.35,-4.1) 204(31.65,4.1)
  rect 4.496x4.597 smd: 205(-37.45,12) 206(37.45,12)
DDR-DS2SK-20401-TP4B-STD-204P
  round 1.6 hole 1.6 unplated: (-33.4,0)
  round 1.092 hole 1.092 unplated: (33.4,0)
  rect 0.356x2.007 smd: 1(-31.65,-4.1) 2(-31.35,4.1) 3(-31.05,-4.1) 4(-30.75,4.1) 5(-30.45,-4.1) 6(-30.15,4.1) 7(-29.85,-4.1) 8(-29.55,4.1) 9(-29.25,-4.1) 10(-28.95,4.1) 11(-28.65,-4.1) 12(-28.35,4.1) 13(-28.05,-4.1) 14(-27.75,4.1) 15(-27.45,-4.1) 16(-27.15,4.1) 17(-26.85,-4.1) 18(-26.55,4.1) 19(-26.25,-4.1) 20(-25.95,4.1) 21(-25.65,-4.1) 22(-25.35,4.1) 23(-25.05,-4.1) 24(-24.75,4.1) 25(-24.45,-4.1) 26(-24.15,4.1) 27(-23.85,-4.1) 28(-23.55,4.1) 29(-23.25,-4.1) 30(-22.95,4.1) 31(-22.65,-4.1) 32(-22.35,4.1) 33(-22.05,-4.1) 34(-21.75,4.1) 35(-21.45,-4.1) 36(-21.15,4.1) 37(-20.85,-4.1) 38(-20.55,4.1) 39(-20.25,-4.1) 40(-19.95,4.1) 41(-19.65,-4.1) 42(-19.35,4.1) 43(-19.05,-4.1) 44(-18.75,4.1) 45(-18.45,-4.1) 46(-18.15,4.1) 47(-17.85,-4.1) 48(-17.55,4.1) 49(-17.25,-4.1) 50(-16.95,4.1) 51(-16.65,-4.1) 52(-16.35,4.1) 53(-16.05,-4.1) 54(-15.75,4.1) 55(-15.45,-4.1) 56(-15.15,4.1) 57(-14.85,-4.1) 58(-14.55,4.1) 59(-14.25,-4.1) 60(-13.95,4.1) 61(-13.65,-4.1) 62(-13.35,4.1) 63(-13.05,-4.1) 64(-12.75,4.1) 65(-12.45,-4.1) 66(-12.15,4.1) 67(-11.85,-4.1) 68(-11.55,4.1) 69(-11.25,-4.1) 70(-10.95,4.1) 71(-10.65,-4.1) 72(-10.35,4.1) 73(-7.65,-4.1) 74(-7.35,4.1) 75(-7.05,-4.1) 76(-6.75,4.1) 77(-6.45,-4.1) 78(-6.15,4.1) 79(-5.85,-4.1) 80(-5.55,4.1) 81(-5.25,-4.1) 82(-4.95,4.1) 83(-4.65,-4.1) 84(-4.35,4.1) 85(-4.05,-4.1) 86(-3.75,4.1) 87(-3.45,-4.1) 88(-3.15,4.1) 89(-2.85,-4.1) 90(-2.55,4.1) 91(-2.25,-4.1) 92(-1.95,4.1) 93(-1.65,-4.1) 94(-1.35,4.1) 95(-1.05,-4.1) 96(-0.75,4.1) 97(-0.45,-4.1) 98(-0.15,4.1) 99(0.15,-4.1) 100(0.45,4.1) 101(0.75,-4.1) 102(1.05,4.1) 103(1.35,-4.1) 104(1.65,4.1) 105(1.95,-4.1) 106(2.25,4.1) 107(2.55,-4.1) 108(2.85,4.1) 109(3.15,-4.1) 110(3.45,4.1) 111(3.75,-4.1) 112(4.05,4.1) 113(4.35,-4.1) 114(4.65,4.1) 115(4.95,-4.1) 116(5.25,4.1) 117(5.55,-4.1) 118(5.85,4.1) 119(6.15,-4.1) 120(6.45,4.1) 121(6.75,-4.1) 122(7.05,4.1) 123(7.35,-4.1) 124(7.65,4.1) 125(7.95,-4.1) 126(8.25,4.1) 127(8.55,-4.1) 128(8.85,4.1) 129(9.15,-4.1) 130(9.45,4.1) 131(9.75,-4.1) 132(10.05,4.1) 133(10.35,-4.1) 134(10.65,4.1) 135(10.95,-4.1) 136(11.25,4.1) 137(11.55,-4.1) 138(11.85,4.1) 139(12.15,-4.1) 140(12.45,4.1) 141(12.75,-4.1) 142(13.05,4.1) 143(13.35,-4.1) 144(13.65,4.1) 145(13.95,-4.1) 146(14.25,4.1) 147(14.55,-4.1) 148(14.85,4.1) 149(15.15,-4.1) 150(15.45,4.1) 151(15.75,-4.1) 152(16.05,4.1) 153(16.35,-4.1) 154(16.65,4.1) 155(16.95,-4.1) 156(17.25,4.1) 157(17.55,-4.1) 158(17.85,4.1) 159(18.15,-4.1) 160(18.45,4.1) 161(18.75,-4.1) 162(19.05,4.1) 163(19.35,-4.1) 164(19.65,4.1) 165(19.95,-4.1) 166(20.25,4.1) 167(20.55,-4.1) 168(20.85,4.1) 169(21.15,-4.1) 170(21.45,4.1) 171(21.75,-4.1) 172(22.05,4.1) 173(22.35,-4.1) 174(22.65,4.1) 175(22.95,-4.1) 176(23.25,4.1) 177(23.55,-4.1) 178(23.85,4.1) 179(24.15,-4.1) 180(24.45,4.1) 181(24.75,-4.1) 182(25.05,4.1) 183(25.35,-4.1) 184(25.65,4.1) 185(25.95,-4.1) 186(26.25,4.1) 187(26.55,-4.1) 188(26.85,4.1) 189(27.15,-4.1) 190(27.45,4.1) 191(27.75,-4.1) 192(28.05,4.1) 193(28.35,-4.1) 194(28.65,4.1) 195(28.95,-4.1) 196(29.25,4.1) 197(29.55,-4.1) 198(29.85,4.1) 199(30.15,-4.1) 200(30.45,4.1) 201(30.75,-4.1) 202(31.05,4.1) 203(31.35,-4.1) 204(31.65,4.1)
  rect 3.505x4.597 smd: 205(-32.8,12) 206(32.8,12)
DSM
  rect 1.016x0.508 smd: 1(-1.3,0) 2(1.321,0)
DSMV
  rect 1.016x0.762 smd: 1(-1.27,0) 2(1.27,0)
DSUB-070546FR015S265ZR-15P-V
  round 0.965 hole 0.711: 1(4.58,-0.1) 2(2.29,-0.1) 3(0,-0.1) 4(-2.29,-0.1) 5(-4.58,-0.1) 6(5.725,-0.1) 7(3.435,-0.1) 8(1.145,-0.1) 9(-1.145,-0.1) 10(-3.435,-0.1)
  round 1.118 hole 0.711: 11(4.58,-1.5) 12(2.29,-1.5) 13(0,-1.5) 14(-2.29,-1.5) 15(-4.58,-1.5)
  oval 1.626x3.505 hole 0.61x2.489: 16(-10.05,0) 17(10.05,0)
ECAP6_3X6_1-7_2
  rect 1.6x3.505 smd: 1(0,-2.8) 2(0,2.8)
ECAP6D3S
  rect 0.991x3.099 smd: 1(0,-2.565) 2(0,2.565)
FBGA96-AMD-23EY4187MA11
  round 0.356 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
GS12401-1011-40P-R-NH-SMT
  round 0.94 hole 0.94 unplated: (-10.5,0) (10.5,0)
  rect 0.254x1.143 smd: 1(9.75,2.125) 2(9.25,2.125) 3(8.75,2.125) 4(8.25,2.125) 5(7.75,2.125) 6(7.25,2.125) 7(6.75,2.125) 8(6.25,2.125) 9(5.75,2.125) 10(5.25,2.125) 11(4.75,2.125) 12(4.25,2.125) 13(3.75,2.125) 14(3.25,2.125) 15(2.75,2.125) 16(2.25,2.125) 17(1.75,2.125) 18(1.25,2.125) 19(0.75,2.125) 20(0.25,2.125) 21(-0.25,2.125) 22(-0.75,2.125) 23(-1.25,2.125) 24(-1.75,2.125) 25(-2.25,2.125) 26(-2.75,2.125) 27(-3.25,2.125) 28(-3.75,2.125) 29(-4.25,2.125) 30(-4.75,2.125) 31(-5.25,2.125) 32(-5.75,2.125) 33(-6.25,2.125) 34(-6.75,2.125) 35(-7.25,2.125) 36(-7.75,2.125) 37(-8.25,2.125) 38(-8.75,2.125) 39(-9.25,2.125) 40(-9.75,2.125)
  rect 1.499x2.997 smd: 41(12.65,0) 42(-12.65,0)
  rect 2.794x1.499 smd: 43(5.7,-2.45) 44(-5.7,-2.45)
H-C102D102N
  round 2.591 hole 2.591 unplated: (0,0)
H-C177D177N
  round 4.496 hole 4.496 unplated: (0,0)
H-TC217BC197D140P2
  round 5.004 hole 3.556: 1(0,0)
H-TC236I140BC266D140P2
  round 6.756 hole 3.556: 1(0,0)
H-TC276BC217D118P2
  round 7.01 hole 2.997: 1(0,0)
H-TC315I158BC197D158P2
  round 8.001 hole 4.013: 1(0,0)
H-TS315I118BC315D118P2
  rect 8.001x8.001 hole 2.997: 1(0,0)
H-Z8B-1
  custom 2x2 hole 2.997: 1(0,0)
H-ZQ0-1
  custom 2x2 hole 2.997: 1(0,0)
HDD-193204-1-22P-R
  round 1.194 hole 1.194 unplated: (-15.595,0) (15.595,0)
  round 1.041 hole 0.787: 1(15.875,1.84) 2(14.605,1.84) 3(13.335,1.84) 4(12.065,1.84) 5(10.795,1.84) 6(9.525,1.84) 7(8.255,1.84) 8(1.905,1.84) 9(0.635,1.84) 10(-0.635,1.84) 11(-1.905,1.84) 12(-3.175,1.84) 13(-4.445,1.84) 14(-5.715,1.84) 15(-6.985,1.84) 16(-8.255,1.84) 17(-9.525,1.84) 18(-10.795,1.84) 19(-12.065,1.84) 20(-13.335,1.84) 21(-14.605,1.84) 22(-15.875,1.84)
  oval 1.803x3.2 hole 0.991x2.388: 23(18.075,1.11) 24(-18.075,1.11)
HDMI-2HE1638-000111F-19P
  round 0.838 hole 0.559: 1(-4.5,7.75) 2(-4,9.3) 3(-3.5,7.75) 4(-3,9.3) 5(-2.5,7.75) 6(-2,9.3) 7(-1.5,7.75) 8(-1,9.3) 9(-0.5,7.75) 10(0,9.3) 11(0.5,7.75) 12(1,9.3) 13(1.5,7.75) 14(2,9.3) 15(2.5,7.75) 16(3,9.3) 17(3.5,7.75) 18(4,9.3) 19(4.5,7.75)
  oval 1.499x2.21 hole 0.889x1.6: 20(-9.15,1.25) 22(9.15,0)
  oval 1.499x2.896 hole 0.889x2.311: 21(-7.75,9.3) 23(7.75,9.3)
HG-C276D118P2
  round 7.01 hole 2.997: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.502) 3(1.769,1.769) 4(2.502,0) 5(1.769,-1.769) 6(0,-2.502) 7(-1.769,-1.769) 8(-2.502,0) 9(-1.769,1.769)
HG-C315D189P2
  round 8.001 hole 4.801: 1(0,0)
  round 1.016 hole 0.61: 2(0,3.175) 3(2.245,2.245) 4(3.175,0) 5(2.245,-2.245) 6(0,-3.175) 7(-2.245,-2.245) 8(-3.175,0) 9(-2.245,2.245)
HG-TC276BC315D118P2
  round 7.01 hole 2.997: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.502) 3(1.769,1.769) 4(2.502,0) 5(1.769,-1.769) 6(0,-2.502) 7(-1.769,-1.769) 8(-2.502,0) 9(-1.769,1.769)
HG-TC394BC217D118P2
  round 10.008 hole 2.997: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.159) 3(1.527,1.527) 4(2.159,0) 5(1.527,-1.527) 6(0,-2.159) 7(-1.527,-1.527) 8(-2.159,0) 9(-1.527,1.527)
HG-TC394BC315D118P2
  round 10.008 hole 2.997: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.794) 3(1.976,1.976) 4(2.794,0) 5(1.976,-1.976) 6(0,-2.794) 7(-1.976,-1.976) 8(-2.794,0) 9(-1.976,1.976)
HG-TR299X327BC315D118P2
  rect 7.595x8.306 hole 2.997: 1(0,0)
  round 1.016 hole 0.61: 2(0,2.794) 3(1.976,1.976) 4(2.794,0) 5(1.976,-1.976) 6(0,-2.794) 7(-1.976,-1.976) 8(-2.794,0) 9(-1.976,1.976)
HS8803F-3P-L
  rect 0.787x1.905 smd: 1(-1.25,4.875) 2(0,4.875) 3(1.25,4.875)
  rect 1.295x3.353 smd: 4(-4.1,0) 5(4.1,0)
IMD
  rect 1.016x0.813 smd: 1(1.2,-1) 3(1.2,1) 4(-1.2,1) 6(-1.2,-1)
  rect 1.016x0.61 smd: 2(1.2,0) 5(-1.2,0)
L3_2X2_5-3_2
  rect 1.194x2.007 smd: 1(-1.6,0) 2(1.6,0)
LED19-123-Y2ST1D-C30-2T-4P
  rect 1.092x0.61 smd: 1(0.95,0.45) 2(0.95,-0.45) 3(-0.95,-0.45) 4(-0.95,0.45)
LQFP128-16X16-4-1_6H
  rect 0.203x1.499 smd: 1(-6.2,-7.85) 2(-5.8,-7.85) 3(-5.4,-7.85) 4(-5,-7.85) 5(-4.6,-7.85) 6(-4.2,-7.85) 7(-3.8,-7.85) 8(-3.4,-7.85) 9(-3,-7.85) 10(-2.6,-7.85) 11(-2.2,-7.85) 12(-1.8,-7.85) 13(-1.4,-7.85) 14(-1,-7.85) 15(-0.6,-7.85) 16(-0.2,-7.85) 17(0.2,-7.85) 18(0.6,-7.85) 19(1,-7.85) 20(1.4,-7.85) 21(1.8,-7.85) 22(2.2,-7.85) 23(2.6,-7.85) 24(3,-7.85) 25(3.4,-7.85) 26(3.8,-7.85) 27(4.2,-7.85) 28(4.6,-7.85) 29(5,-7.85) 30(5.4,-7.85) 31(5.8,-7.85) 32(6.2,-7.85) 65(6.2,7.85) 66(5.8,7.85) 67(5.4,7.85) 68(5,7.85) 69(4.6,7.85) 70(4.2,7.85) 71(3.8,7.85) 72(3.4,7.85) 73(3,7.85) 74(2.6,7.85) 75(2.2,7.85) 76(1.8,7.85) 77(1.4,7.85) 78(1,7.85) 79(0.6,7.85) 80(0.2,7.85) 81(-0.2,7.85) 82(-0.6,7.85) 83(-1,7.85) 84(-1.4,7.85) 85(-1.8,7.85) 86(-2.2,7.85) 87(-2.6,7.85) 88(-3,7.85) 89(-3.4,7.85) 90(-3.8,7.85) 91(-4.2,7.85) 92(-4.6,7.85) 93(-5,7.85) 94(-5.4,7.85) 95(-5.8,7.85) 96(-6.2,7.85)
  rect 1.499x0.203 smd: 33(7.85,-6.2) 34(7.85,-5.8) 35(7.85,-5.4) 36(7.85,-5) 37(7.85,-4.6) 38(7.85,-4.2) 39(7.85,-3.8) 40(7.85,-3.4) 41(7.85,-3) 42(7.85,-2.6) 43(7.85,-2.2) 44(7.85,-1.8) 45(7.85,-1.4) 46(7.85,-1) 47(7.85,-0.6) 48(7.85,-0.2) 49(7.85,0.2) 50(7.85,0.6) 51(7.85,1) 52(7.85,1.4) 53(7.85,1.8) 54(7.85,2.2) 55(7.85,2.6) 56(7.85,3) 57(7.85,3.4) 58(7.85,3.8) 59(7.85,4.2) 60(7.85,4.6) 61(7.85,5) 62(7.85,5.4) 63(7.85,5.8) 64(7.85,6.2) 97(-7.85,6.2) 98(-7.85,5.8) 99(-7.85,5.4) 100(-7.85,5) 101(-7.85,4.6) 102(-7.85,4.2) 103(-7.85,3.8) 104(-7.85,3.4) 105(-7.85,3) 106(-7.85,2.6) 107(-7.85,2.2) 108(-7.85,1.8) 109(-7.85,1.4) 110(-7.85,1) 111(-7.85,0.6) 112(-7.85,0.2) 113(-7.85,-0.2) 114(-7.85,-0.6) 115(-7.85,-1) 116(-7.85,-1.4) 117(-7.85,-1.8) 118(-7.85,-2.2) 119(-7.85,-2.6) 120(-7.85,-3) 121(-7.85,-3.4) 122(-7.85,-3.8) 123(-7.85,-4.2) 124(-7.85,-4.6) 125(-7.85,-5) 126(-7.85,-5.4) 127(-7.85,-5.8) 128(-7.85,-6.2)
MIC-MP45DT02TR-6P
  round 0.914 smd: 1(-1.175,1.65) 2(-1.175,0) 3(-1.175,-1.65) 4(1.175,-1.65) 5(1.175,0)
  oval 0.914x1.194 smd rot 135: 6(1.07,1.55)
MIPCI-800055FB052GX00PL-52P-SMT
  round 1.6 hole 1.6 unplated: (-12.5,0)
  round 1.092 hole 1.092 unplated: (12.5,0)
  rect 0.508x2.007 smd: 1(-11.8,-4.1) 2(-11.4,4.1) 3(-11,-4.1) 4(-10.6,4.1) 5(-10.2,-4.1) 6(-9.8,4.1) 7(-9.4,-4.1) 8(-9,4.1) 9(-8.6,-4.1) 10(-8.2,4.1) 11(-7.8,-4.1) 12(-7.4,4.1) 13(-7,-4.1) 14(-6.6,4.1) 15(-6.2,-4.1) 16(-5.8,4.1) 17(-2.2,-4.1) 18(-1.8,4.1) 19(-1.4,-4.1) 20(-1,4.1) 21(-0.6,-4.1) 22(-0.2,4.1) 23(0.2,-4.1) 24(0.6,4.1) 25(1,-4.1) 26(1.4,4.1) 27(1.8,-4.1) 28(2.2,4.1) 29(2.6,-4.1) 30(3,4.1) 31(3.4,-4.1) 32(3.8,4.1) 33(4.2,-4.1) 34(4.6,4.1) 35(5,-4.1) 36(5.4,4.1) 37(5.8,-4.1) 38(6.2,4.1) 39(6.6,-4.1) 40(7,4.1) 41(7.4,-4.1) 42(7.8,4.1) 43(8.2,-4.1) 44(8.6,4.1) 45(9,-4.1) 46(9.4,4.1) 47(9.8,-4.1) 48(10.2,4.1) 49(10.6,-4.1) 50(11,4.1) 51(11.4,-4.1) 52(11.8,4.1)
  rect 2.311x3.2 smd: 53(-14.65,-3.5) 54(14.65,-3.5)
ML1220-SMT
  round 1.092 hole 1.092 unplated: (0,3.988)
  round 0.711 hole 0.711 unplated: (0,-3.988)
  rect 2.997x1.499 smd: 1(-7.391,0) 2(7.391,0)
MSOP8-4_9-65
  rect 0.406x1.448 smd: 1(-0.975,-2.325) 2(-0.325,-2.325) 3(0.325,-2.325) 4(0.975,-2.325) 5(0.975,2.325) 6(0.325,2.325) 7(-0.325,2.325) 8(-0.975,2.325)
O-Z8B-1
  round 7.62 hole 7.62 unplated: (0,0)
POWER-3_3X3_3-65-5P-SMT
  rect 0.762x0.432 smd: 1(1.43,-0.975) 2(1.43,-0.325) 3(1.43,0.325) 4(1.43,0.975)
  custom 0.562x0.562 smd: 5(-0.725,0)
POWER-5X6-1_27-7P
  rect 0.635x0.66 smd: 1(2.835,-1.905) 5(-2.835,1.905) 6(-2.835,0.635) 7(-2.835,-0.635) 8(-2.835,-1.905)
  custom 0.485x0.485 smd: 2(2.18,0.115)
  rect 2.159x3.988 smd: 9(-0.525,0)
POWER-6_5-1_84-3P
  rect 0.787x1.397 smd: 1(3.532,0.9) 2(3.532,-0.9)
  rect 4.699x3.607 smd: 3(-0.338,0)
PVQFN20-3_5X3_5-5-25P
  rect 0.279x0.838 smd: 1(-1,-1.725) 2(-0.5,-1.725) 3(0,-1.725) 4(0.5,-1.725) 5(1,-1.725) 11(1,1.725) 12(0.5,1.725) 13(0,1.725) 14(-0.5,1.725) 15(-1,1.725)
  rect 0.838x0.279 smd: 6(1.725,-1) 7(1.725,-0.5) 8(1.725,0) 9(1.725,0.5) 10(1.725,1) 16(-1.725,1) 17(-1.725,0.5) 18(-1.725,0) 19(-1.725,-0.5) 20(-1.725,-1)
  rect 2.057x2.057 smd: 21(0,0)
  round 0.61 hole 0.305: 22(-0.5,-0.5) 23(0.5,-0.5) 24(0.5,0.5) 25(-0.5,0.5)
PZ94726-3641-41H-SOCKET
  round 0.457 smd: A2(-17.5,-16) A3(-17.5,-15) A4(-17.5,-14) A5(-17.5,-13) A6(-17.5,-12) A7(-17.5,-11) A8(-17.5,-10) A9(-17.5,-9) A10(-17.5,-8) A11(-17.5,-7) A12(-17.5,-6) A13(-17.5,-5) A14(-17.5,-4) A15(-17.5,-3) A16(-17.5,-2) A17(-17.5,-1) A18(-17.5,0) A19(-17.5,1) A20(-17.5,2) A21(-17.5,3) A22(-17.5,4) A23(-17.5,5) A24(-17.5,6) A25(-17.5,7) A26(-17.5,8) A27(-17.5,9) A28(-17.5,10) A29(-17.5,11) A30(-17.5,12) A31(-17.5,13) A32(-17.5,14) A33(-17.5,15) A34(-17.5,16) A35(-17.5,17) AA1(2.5,-17) AA2(2.5,-16) AA3(2.5,-15) AA4(2.5,-14) AA5(2.5,-13) AA6(2.5,-12) AA7(2.5,-11) AA8(2.5,-10) AA9(2.5,-9) AA10(2.5,-8) AA11(2.5,-7) AA25(2.5,7) AA26(2.5,8) AA27(2.5,9) AA28(2.5,10) AA29(2.5,11) AA30(2.5,12) AA31(2.5,13) AA32(2.5,14) AA33(2.5,15) AA34(2.5,16) AA35(2.5,17) AB1(3.5,-17) AB2(3.5,-16) AB3(3.5,-15) AB4(3.5,-14) AB5(3.5,-13) AB6(3.5,-12) AB7(3.5,-11) AB8(3.5,-10) AB9(3.5,-9) AB10(3.5,-8) AB11(3.5,-7) AB25(3.5,7) AB26(3.5,8) AB27(3.5,9) AB28(3.5,10) AB29(3.5,11) AB30(3.5,12) AB31(3.5,13) AB32(3.5,14) AB33(3.5,15) AB34(3.5,16) AB35(3.5,17) AC1(4.5,-17) AC2(4.5,-16) AC3(4.5,-15) AC4(4.5,-14) AC5(4.5,-13) AC6(4.5,-12) AC7(4.5,-11) AC8(4.5,-10) AC9(4.5,-9) AC10(4.5,-8) AC11(4.5,-7) AC25(4.5,7) AC26(4.5,8) AC27(4.5,9) AC28(4.5,10) AC29(4.5,11) AC30(4.5,12) AC31(4.5,13) AC32(4.5,14) AC33(4.5,15) AC34(4.5,16) AC35(4.5,17) AD1(5.5,-17) AD2(5.5,-16) AD3(5.5,-15) AD4(5.5,-14) AD5(5.5,-13) AD6(5.5,-12) AD7(5.5,-11) AD8(5.5,-10) AD9(5.5,-9) AD10(5.5,-8) AD11(5.5,-7) AD25(5.5,7) AD26(5.5,8) AD27(5.5,9) AD28(5.5,10) AD29(5.5,11) AD30(5.5,12) AD31(5.5,13) AD32(5.5,14) AD33(5.5,15) AD34(5.5,16) AD35(5.5,17) AE1(6.5,-17) AE2(6.5,-16) AE3(6.5,-15) AE4(6.5,-14) AE5(6.5,-13) AE6(6.5,-12) AE7(6.5,-11) AE8(6.5,-10) AE9(6.5,-9) AE10(6.5,-8) AE11(6.5,-7) AE25(6.5,7) AE26(6.5,8) AE27(6.5,9) AE28(6.5,10) AE29(6.5,11) AE30(6.5,12) AE31(6.5,13) AE32(6.5,14) AE33(6.5,15) AE34(6.5,16) AE35(6.5,17) AF1(7.5,-17) AF2(7.5,-16) AF3(7.5,-15) AF4(7.5,-14) AF5(7.5,-13) AF6(7.5,-12) AF7(7.5,-11) AF8(7.5,-10) AF9(7.5,-9) AF10(7.5,-8) AF11(7.5,-7) AF25(7.5,7) AF26(7.5,8) AF27(7.5,9) AF28(7.5,10) AF29(7.5,11) AF30(7.5,12) AF31(7.5,13) AF32(7.5,14) AF33(7.5,15) AF34(7.5,16) AF35(7.5,17) AG1(8.5,-17) AG2(8.5,-16) AG3(8.5,-15) AG4(8.5,-14) AG5(8.5,-13) AG6(8.5,-12) AG7(8.5,-11) AG8(8.5,-10) AG9(8.5,-9) AG10(8.5,-8) AG11(8.5,-7) AG25(8.5,7) AG26(8.5,8) AG27(8.5,9) AG28(8.5,10) AG29(8.5,11) AG30(8.5,12) AG31(8.5,13) AG32(8.5,14) AG33(8.5,15) AG34(8.5,16) AG35(8.5,17) AH1(9.5,-17) AH2(9.5,-16) AH3(9.5,-15) AH4(9.5,-14) AH5(9.5,-13) AH6(9.5,-12) AH7(9.5,-11) AH8(9.5,-10) AH9(9.5,-9) AH10(9.5,-8) AH11(9.5,-7) AH25(9.5,7) AH26(9.5,8) AH27(9.5,9) AH28(9.5,10) AH29(9.5,11) AH30(9.5,12) AH31(9.5,13) AH32(9.5,14) AH33(9.5,15) AH34(9.5,16) AH35(9.5,17) AJ1(10.5,-17) AJ2(10.5,-16) AJ3(10.5,-15) AJ4(10.5,-14) AJ5(10.5,-13) AJ6(10.5,-12) AJ7(10.5,-11) AJ8(10.5,-10) AJ9(10.5,-9) AJ10(10.5,-8) AJ11(10.5,-7) AJ25(10.5,7) AJ26(10.5,8) AJ27(10.5,9) AJ28(10.5,10) AJ29(10.5,11) AJ30(10.5,12) AJ31(10.5,13) AJ32(10.5,14) AJ33(10.5,15) AJ34(10.5,16) AJ35(10.5,17) AK1(11.5,-17) AK2(11.5,-16) AK3(11.5,-15) AK4(11.5,-14) AK5(11.5,-13) AK6(11.5,-12) AK7(11.5,-11) AK8(11.5,-10) AK9(11.5,-9) AK10(11.5,-8) AK11(11.5,-7) AK25(11.5,7) AK26(11.5,8) AK27(11.5,9) AK28(11.5,10) AK29(11.5,11) AK30(11.5,12) AK31(11.5,13) AK32(11.5,14) AK33(11.5,15) AK34(11.5,16) AK35(11.5,17) AL1(12.5,-17) AL2(12.5,-16) AL3(12.5,-15) AL4(12.5,-14) AL5(12.5,-13) AL6(12.5,-12) AL7(12.5,-11) AL8(12.5,-10) AL9(12.5,-9) AL10(12.5,-8) AL11(12.5,-7) AL12(12.5,-6) AL13(12.5,-5) AL14(12.5,-4) AL15(12.5,-3) AL16(12.5,-2) AL17(12.5,-1) AL18(12.5,0) AL19(12.5,1) AL20(12.5,2) AL21(12.5,3) AL22(12.5,4) AL23(12.5,5) AL24(12.5,6) AL25(12.5,7) AL26(12.5,8) AL27(12.5,9) AL28(12.5,10) AL29(12.5,11) AL30(12.5,12) AL31(12.5,13) AL32(12.5,14) AL33(12.5,15) AL34(12.5,16) AL35(12.5,17) AM1(13.5,-17) AM2(13.5,-16) AM3(13.5,-15) AM4(13.5,-14) AM5(13.5,-13) AM6(13.5,-12) AM7(13.5,-11) AM8(13.5,-10) AM9(13.5,-9) AM10(13.5,-8) AM11(13.5,-7) AM12(13.5,-6) AM13(13.5,-5) AM14(13.5,-4) AM15(13.5,-3) AM16(13.5,-2) AM17(13.5,-1) AM18(13.5,0) AM19(13.5,1) AM20(13.5,2) AM21(13.5,3) AM22(13.5,4) AM23(13.5,5) AM24(13.5,6) AM25(13.5,7) AM26(13.5,8) AM27(13.5,9) AM28(13.5,10) AM29(13.5,11) AM30(13.5,12) AM31(13.5,13) AM32(13.5,14) AM33(13.5,15) AM34(13.5,16) AM35(13.5,17) AN1(14.5,-17) AN2(14.5,-16) AN3(14.5,-15) AN4(14.5,-14) AN5(14.5,-13) AN6(14.5,-12) AN7(14.5,-11) AN8(14.5,-10) AN9(14.5,-9) AN10(14.5,-8) AN11(14.5,-7) AN12(14.5,-6) AN13(14.5,-5) AN14(14.5,-4) AN15(14.5,-3) AN16(14.5,-2) AN17(14.5,-1) AN18(14.5,0) AN19(14.5,1) AN20(14.5,2) AN21(14.5,3) AN22(14.5,4) AN23(14.5,5) AN24(14.5,6) AN25(14.5,7) AN26(14.5,8) AN27(14.5,9) AN28(14.5,10) AN29(14.5,11) AN30(14.5,12) AN31(14.5,13) AN32(14.5,14) AN33(14.5,15) AN34(14.5,16) AN35(14.5,17) AP1(15.5,-17) AP2(15.5,-16) AP3(15.5,-15) AP4(15.5,-14) AP5(15.5,-13) AP6(15.5,-12) AP7(15.5,-11) AP8(15.5,-10) AP9(15.5,-9) AP10(15.5,-8) AP11(15.5,-7) AP12(15.5,-6) AP13(15.5,-5) AP14(15.5,-4) AP15(15.5,-3) AP16(15.5,-2) AP17(15.5,-1) AP18(15.5,0) AP19(15.5,1) AP20(15.5,2) AP21(15.5,3) AP22(15.5,4) AP23(15.5,5) AP24(15.5,6) AP25(15.5,7) AP26(15.5,8) AP27(15.5,9) AP28(15.5,10) AP29(15.5,11) AP30(15.5,12) AP31(15.5,13) AP32(15.5,14) AP33(15.5,15) AP34(15.5,16) AP35(15.5,17) AR1(16.5,-17) AR2(16.5,-16) AR3(16.5,-15) AR4(16.5,-14) AR5(16.5,-13) AR6(16.5,-12) AR7(16.5,-11) AR8(16.5,-10) AR9(16.5,-9) AR10(16.5,-8) AR11(16.5,-7) AR12(16.5,-6) AR13(16.5,-5) AR14(16.5,-4) AR15(16.5,-3) AR16(16.5,-2) AR17(16.5,-1) AR18(16.5,0) AR19(16.5,1) AR20(16.5,2) AR21(16.5,3) AR22(16.5,4) AR23(16.5,5) AR24(16.5,6) AR25(16.5,7) AR26(16.5,8) AR27(16.5,9) AR28(16.5,10) AR29(16.5,11) AR30(16.5,12) AR31(16.5,13) AR32(16.5,14) AR33(16.5,15) AR34(16.5,16) AR35(16.5,17) AT1(17.5,-17) AT2(17.5,-16) AT3(17.5,-15) AT4(17.5,-14) AT5(17.5,-13) AT6(17.5,-12) AT7(17.5,-11) AT8(17.5,-10) AT9(17.5,-9) AT10(17.5,-8) AT11(17.5,-7) AT12(17.5,-6) AT13(17.5,-5) AT14(17.5,-4) AT15(17.5,-3) AT16(17.5,-2) AT17(17.5,-1) AT18(17.5,0) AT19(17.5,1) AT20(17.5,2) AT21(17.5,3) AT22(17.5,4) AT23(17.5,5) AT24(17.5,6) AT25(17.5,7) AT26(17.5,8) AT27(17.5,9) AT28(17.5,10) AT29(17.5,11) AT30(17.5,12) AT31(17.5,13) AT32(17.5,14) AT33(17.5,15) AT34(17.5,16) AT35(17.5,17) B1(-16.5,-17) B2(-16.5,-16) B3(-16.5,-15) B4(-16.5,-14) B5(-16.5,-13) B6(-16.5,-12) B7(-16.5,-11) B8(-16.5,-10) B9(-16.5,-9) B10(-16.5,-8) B11(-16.5,-7) B12(-16.5,-6) B13(-16.5,-5) B14(-16.5,-4) B15(-16.5,-3) B16(-16.5,-2) B17(-16.5,-1) B18(-16.5,0) B19(-16.5,1) B20(-16.5,2) B21(-16.5,3) B22(-16.5,4) B23(-16.5,5) B24(-16.5,6) B25(-16.5,7) B26(-16.5,8) B27(-16.5,9) B28(-16.5,10) B29(-16.5,11) B30(-16.5,12) B31(-16.5,13) B32(-16.5,14) B33(-16.5,15) B34(-16.5,16) B35(-16.5,17) C1(-15.5,-17) C2(-15.5,-16) C3(-15.5,-15) C4(-15.5,-14) C5(-15.5,-13) C6(-15.5,-12) C7(-15.5,-11) C8(-15.5,-10) C9(-15.5,-9) C10(-15.5,-8) C11(-15.5,-7) C12(-15.5,-6) C13(-15.5,-5) C14(-15.5,-4) C15(-15.5,-3) C16(-15.5,-2) C17(-15.5,-1) C18(-15.5,0) C19(-15.5,1) C20(-15.5,2) C21(-15.5,3) C22(-15.5,4) C23(-15.5,5) C24(-15.5,6) C25(-15.5,7) C26(-15.5,8) C27(-15.5,9) C28(-15.5,10) C29(-15.5,11) C30(-15.5,12) C31(-15.5,13) C32(-15.5,14) C33(-15.5,15) C34(-15.5,16) C35(-15.5,17) D1(-14.5,-17) D2(-14.5,-16) D3(-14.5,-15) D4(-14.5,-14) D5(-14.5,-13) D6(-14.5,-12) D7(-14.5,-11) D8(-14.5,-10) D9(-14.5,-9) D10(-14.5,-8) D11(-14.5,-7) D12(-14.5,-6) D13(-14.5,-5) D14(-14.5,-4) D15(-14.5,-3) D16(-14.5,-2) D17(-14.5,-1) D18(-14.5,0) D19(-14.5,1) D20(-14.5,2) D21(-14.5,3) D22(-14.5,4) D23(-14.5,5) D24(-14.5,6) D25(-14.5,7) D26(-14.5,8) D27(-14.5,9) D28(-14.5,10) D29(-14.5,11) D30(-14.5,12) D31(-14.5,13) D32(-14.5,14) D33(-14.5,15) D34(-14.5,16) D35(-14.5,17) E1(-13.5,-17) E2(-13.5,-16) E3(-13.5,-15) E4(-13.5,-14) E5(-13.5,-13) E6(-13.5,-12) E7(-13.5,-11) E8(-13.5,-10) E9(-13.5,-9) E10(-13.5,-8) E11(-13.5,-7) E12(-13.5,-6) E13(-13.5,-5) E14(-13.5,-4) E15(-13.5,-3) E16(-13.5,-2) E17(-13.5,-1) E18(-13.5,0) E19(-13.5,1) E20(-13.5,2) E21(-13.5,3) E22(-13.5,4) E23(-13.5,5) E24(-13.5,6) E25(-13.5,7) E26(-13.5,8) E27(-13.5,9) E28(-13.5,10) E29(-13.5,11) E30(-13.5,12) E31(-13.5,13) E32(-13.5,14) E33(-13.5,15) E34(-13.5,16) E35(-13.5,17) F1(-12.5,-17) F2(-12.5,-16) F3(-12.5,-15) F4(-12.5,-14) F5(-12.5,-13) F6(-12.5,-12) F7(-12.5,-11) F8(-12.5,-10) F9(-12.5,-9) F10(-12.5,-8) F11(-12.5,-7) F12(-12.5,-6) F13(-12.5,-5) F14(-12.5,-4) F15(-12.5,-3) F16(-12.5,-2) F17(-12.5,-1) F18(-12.5,0) F19(-12.5,1) F20(-12.5,2) F21(-12.5,3) F22(-12.5,4) F23(-12.5,5) F24(-12.5,6) F25(-12.5,7) F26(-12.5,8) F27(-12.5,9) F28(-12.5,10) F29(-12.5,11) F30(-12.5,12) F31(-12.5,13) F32(-12.5,14) F33(-12.5,15) F34(-12.5,16) F35(-12.5,17) G1(-11.5,-17) G2(-11.5,-16) G3(-11.5,-15) G4(-11.5,-14) G5(-11.5,-13) G6(-11.5,-12) G7(-11.5,-11) G8(-11.5,-10) G9(-11.5,-9) G10(-11.5,-8) G11(-11.5,-7) G25(-11.5,7) G26(-11.5,8) G27(-11.5,9) G28(-11.5,10) G29(-11.5,11) G30(-11.5,12) G31(-11.5,13) G32(-11.5,14) G33(-11.5,15) G34(-11.5,16) G35(-11.5,17) H1(-10.5,-17) H2(-10.5,-16) H3(-10.5,-15) H4(-10.5,-14) H5(-10.5,-13) H6(-10.5,-12) H7(-10.5,-11) H8(-10.5,-10) H9(-10.5,-9) H10(-10.5,-8) H11(-10.5,-7) H25(-10.5,7) H26(-10.5,8) H27(-10.5,9) H28(-10.5,10) H29(-10.5,11) H30(-10.5,12) H31(-10.5,13) H32(-10.5,14) H33(-10.5,15) H34(-10.5,16) H35(-10.5,17) J1(-9.5,-17) J2(-9.5,-16) J3(-9.5,-15) J4(-9.5,-14) J5(-9.5,-13) J6(-9.5,-12) J7(-9.5,-11) J8(-9.5,-10) J9(-9.5,-9) J10(-9.5,-8) J11(-9.5,-7) J25(-9.5,7) J26(-9.5,8) J27(-9.5,9) J28(-9.5,10) J29(-9.5,11) J30(-9.5,12) J31(-9.5,13) J32(-9.5,14) J33(-9.5,15) J34(-9.5,16) J35(-9.5,17) K1(-8.5,-17) K2(-8.5,-16) K3(-8.5,-15) K4(-8.5,-14) K5(-8.5,-13) K6(-8.5,-12) K7(-8.5,-11) K8(-8.5,-10) K9(-8.5,-9) K10(-8.5,-8) K11(-8.5,-7) K25(-8.5,7) K26(-8.5,8) K27(-8.5,9) K28(-8.5,10) K29(-8.5,11) K30(-8.5,12) K31(-8.5,13) K32(-8.5,14) K33(-8.5,15) K34(-8.5,16) K35(-8.5,17) L1(-7.5,-17) L2(-7.5,-16) L3(-7.5,-15) L4(-7.5,-14) L5(-7.5,-13) L6(-7.5,-12) L7(-7.5,-11) L8(-7.5,-10) L9(-7.5,-9) L10(-7.5,-8) L11(-7.5,-7) L25(-7.5,7) L26(-7.5,8) L27(-7.5,9) L28(-7.5,10) L29(-7.5,11) L30(-7.5,12) L31(-7.5,13) L32(-7.5,14) L33(-7.5,15) L34(-7.5,16) L35(-7.5,17) M1(-6.5,-17) M2(-6.5,-16) M3(-6.5,-15) M4(-6.5,-14) M5(-6.5,-13) M6(-6.5,-12) M7(-6.5,-11) M8(-6.5,-10) M9(-6.5,-9) M10(-6.5,-8) M11(-6.5,-7) M25(-6.5,7) M26(-6.5,8) M27(-6.5,9) M28(-6.5,10) M29(-6.5,11) M30(-6.5,12) M31(-6.5,13) M32(-6.5,14) M33(-6.5,15) M34(-6.5,16) M35(-6.5,17) N1(-5.5,-17) N2(-5.5,-16) N3(-5.5,-15) N4(-5.5,-14) N5(-5.5,-13) N6(-5.5,-12) N7(-5.5,-11) N8(-5.5,-10) N9(-5.5,-9) N10(-5.5,-8) N11(-5.5,-7) N25(-5.5,7) N26(-5.5,8) N27(-5.5,9) N28(-5.5,10) N29(-5.5,11) N30(-5.5,12) N31(-5.5,13) N32(-5.5,14) N33(-5.5,15) N34(-5.5,16) N35(-5.5,17) P1(-4.5,-17) P2(-4.5,-16) P3(-4.5,-15) P4(-4.5,-14) P5(-4.5,-13) P6(-4.5,-12) P7(-4.5,-11) P8(-4.5,-10) P9(-4.5,-9) P10(-4.5,-8) P11(-4.5,-7) P25(-4.5,7) P26(-4.5,8) P27(-4.5,9) P28(-4.5,10) P29(-4.5,11) P30(-4.5,12) P31(-4.5,13) P32(-4.5,14) P33(-4.5,15) P34(-4.5,16) P35(-4.5,17) R1(-3.5,-17) R2(-3.5,-16) R3(-3.5,-15) R4(-3.5,-14) R5(-3.5,-13) R6(-3.5,-12) R7(-3.5,-11) R8(-3.5,-10) R9(-3.5,-9) R10(-3.5,-8) R11(-3.5,-7) R25(-3.5,7) R26(-3.5,8) R27(-3.5,9) R28(-3.5,10) R29(-3.5,11) R30(-3.5,12) R31(-3.5,13) R32(-3.5,14) R33(-3.5,15) R34(-3.5,16) R35(-3.5,17) T1(-2.5,-17) T2(-2.5,-16) T3(-2.5,-15) T4(-2.5,-14) T5(-2.5,-13) T6(-2.5,-12) T7(-2.5,-11) T8(-2.5,-10) T9(-2.5,-9) T10(-2.5,-8) T11(-2.5,-7) T25(-2.5,7) T26(-2.5,8) T27(-2.5,9) T28(-2.5,10) T29(-2.5,11) T30(-2.5,12) T31(-2.5,13) T32(-2.5,14) T33(-2.5,15) T34(-2.5,16) T35(-2.5,17) U1(-1.5,-17) U2(-1.5,-16) U3(-1.5,-15) U4(-1.5,-14) U5(-1.5,-13) U6(-1.5,-12) U7(-1.5,-11) U8(-1.5,-10) U9(-1.5,-9) U10(-1.5,-8) U11(-1.5,-7) U25(-1.5,7) U26(-1.5,8) U27(-1.5,9) U28(-1.5,10) U29(-1.5,11) U30(-1.5,12) U31(-1.5,13) U32(-1.5,14) U33(-1.5,15) U34(-1.5,16) U35(-1.5,17) V1(-0.5,-17) V2(-0.5,-16) V3(-0.5,-15) V4(-0.5,-14) V5(-0.5,-13) V6(-0.5,-12) V7(-0.5,-11) V8(-0.5,-10) V9(-0.5,-9) V10(-0.5,-8) V11(-0.5,-7) V25(-0.5,7) V26(-0.5,8) V27(-0.5,9) V28(-0.5,10) V29(-0.5,11) V30(-0.5,12) V31(-0.5,13) V32(-0.5,14) V33(-0.5,15) V34(-0.5,16) V35(-0.5,17) W1(0.5,-17) W2(0.5,-16) W3(0.5,-15) W4(0.5,-14) W5(0.5,-13) W6(0.5,-12) W7(0.5,-11) W8(0.5,-10) W9(0.5,-9) W10(0.5,-8) W11(0.5,-7) W25(0.5,7) W26(0.5,8) W27(0.5,9) W28(0.5,10) W29(0.5,11) W30(0.5,12) W31(0.5,13) W32(0.5,14) W33(0.5,15) W34(0.5,16) W35(0.5,17) Y1(1.5,-17) Y2(1.5,-16) Y3(1.5,-15) Y4(1.5,-14) Y5(1.5,-13) Y6(1.5,-12) Y7(1.5,-11) Y8(1.5,-10) Y9(1.5,-9) Y10(1.5,-8) Y11(1.5,-7) Y25(1.5,7) Y26(1.5,8) Y27(1.5,9) Y28(1.5,10) Y29(1.5,11) Y30(1.5,12) Y31(1.5,13) Y32(1.5,14) Y33(1.5,15) Y34(1.5,16) Y35(1.5,17)
QFN16-3X3-5-22P
  rect 0.305x0.991 smd: 1(-0.75,-1.6) 2(-0.25,-1.6) 3(0.25,-1.6) 4(0.75,-1.6) 9(0.75,1.6) 10(0.25,1.6) 11(-0.25,1.6) 12(-0.75,1.6)
  rect 0.991x0.305 smd: 5(1.6,-0.75) 6(1.6,-0.25) 7(1.6,0.25) 8(1.6,0.75) 13(-1.6,0.75) 14(-1.6,0.25) 15(-1.6,-0.25) 16(-1.6,-0.75)
  rect 1.702x1.702 smd: 17(0,0)
  round 0.508 hole 0.305: 18(-0.5,0.5) 19(0.5,0.5) 20(0,0) 21(-0.5,-0.5) 22(0.5,-0.5)
QFN20-3X3-4-21P-0_8H
  rect 0.203x0.991 smd: 1(-0.8,-1.6) 2(-0.4,-1.6) 3(0,-1.6) 4(0.4,-1.6) 5(0.8,-1.6) 11(0.8,1.6) 12(0.4,1.6) 13(0,1.6) 14(-0.4,1.6) 15(-0.8,1.6)
  rect 0.991x0.203 smd: 6(1.6,-0.8) 7(1.6,-0.4) 8(1.6,0) 9(1.6,0.4) 10(1.6,0.8) 16(-1.6,0.8) 17(-1.6,0.4) 18(-1.6,0) 19(-1.6,-0.4) 20(-1.6,-0.8)
  rect 1.6x1.6 smd: 21(0,0)
QFN20-3X3-4-26P
  rect 0.787x0.203 smd: 1(-1.5,0.8) 2(-1.5,0.4) 3(-1.5,0) 4(-1.5,-0.4) 5(-1.5,-0.8) 11(1.5,-0.8) 12(1.5,-0.4) 13(1.5,0) 14(1.5,0.4) 15(1.5,0.8)
  rect 0.203x0.787 smd: 6(-0.8,-1.5) 7(-0.4,-1.5) 8(0,-1.5) 9(0.4,-1.5) 10(0.8,-1.5) 16(0.8,1.5) 17(0.4,1.5) 18(0,1.5) 19(-0.4,1.5) 20(-0.8,1.5)
  rect 1.803x1.803 smd: 21(0,0)
  round 0.508 hole 0.305: 22(-0.5,0.5) 23(-0.5,-0.5) 24(0.5,-0.5) 25(0.5,0.5) 26(0,0)
QFN24-4X4-5-25P-1H
  rect 0.991x0.305 smd: 1(-2.1,1.25) 2(-2.1,0.75) 3(-2.1,0.25) 4(-2.1,-0.25) 5(-2.1,-0.75) 6(-2.1,-1.25) 13(2.1,-1.25) 14(2.1,-0.75) 15(2.1,-0.25) 16(2.1,0.25) 17(2.1,0.75) 18(2.1,1.25)
  rect 0.305x0.991 smd: 7(-1.25,-2.1) 8(-0.75,-2.1) 9(-0.25,-2.1) 10(0.25,-2.1) 11(0.75,-2.1) 12(1.25,-2.1) 19(1.25,2.1) 20(0.75,2.1) 21(0.25,2.1) 22(-0.25,2.1) 23(-0.75,2.1) 24(-1.25,2.1)
  rect 2.159x2.159 smd: 25(0,0)
QFN32-4X4-4-33P-0_9H
  custom 0.051x0.051 smd: 1(-1.4,-2.1) 8(1.4,-2.1) 9(2.1,-1.4) 16(2.1,1.4) 17(1.4,2.1) 24(-1.4,2.1) 25(-2.1,1.4) 32(-2.1,-1.4)
  rect 0.203x0.991 smd: 2(-1,-2.1) 3(-0.6,-2.1) 4(-0.2,-2.1) 5(0.2,-2.1) 6(0.6,-2.1) 7(1,-2.1) 18(1,2.1) 19(0.6,2.1) 20(0.2,2.1) 21(-0.2,2.1) 22(-0.6,2.1) 23(-1,2.1)
  rect 0.991x0.203 smd: 10(2.1,-1) 11(2.1,-0.6) 12(2.1,-0.2) 13(2.1,0.2) 14(2.1,0.6) 15(2.1,1) 26(-2.1,1) 27(-2.1,0.6) 28(-2.1,0.2) 29(-2.1,-0.2) 30(-2.1,-0.6) 31(-2.1,-1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32-4X4-4-42P-1H
  custom 0.05x0.05 smd: 1(-2,1.4) 2(-2,1) 3(-2,0.6) 4(-2,0.2) 5(-2,-0.2) 6(-2,-0.6) 7(-2,-1) 8(-2,-1.4) 9(-1.4,-2) 10(-1,-2) 11(-0.6,-2) 12(-0.2,-2) 13(0.2,-2) 14(0.6,-2) 15(1,-2) 16(1.4,-2) 17(2,-1.4) 18(2,-1) 19(2,-0.6) 20(2,-0.2) 21(2,0.2) 22(2,0.6) 23(2,1) 24(2,1.4) 25(1.4,2) 26(1,2) 27(0.6,2) 28(0.2,2) 29(-0.2,2) 30(-0.6,2) 31(-1,2) 32(-1.4,2)
  rect 2.794x2.794 smd: 33(0,0)
  round 0.61 hole 0.305: 34(-1,1) 35(-1,0) 36(-1,-1) 37(0,-1) 38(1,-1) 39(1,0) 40(1,1) 41(0,1) 42(0,0)
QFN48-6X6-4-49P-ALC280
  rect 0.203x0.991 smd: 1(-2.2,-3.1) 2(-1.8,-3.1) 3(-1.4,-3.1) 4(-1,-3.1) 5(-0.6,-3.1) 6(-0.2,-3.1) 7(0.2,-3.1) 8(0.6,-3.1) 9(1,-3.1) 10(1.4,-3.1) 11(1.8,-3.1) 12(2.2,-3.1) 25(2.2,3.1) 26(1.8,3.1) 27(1.4,3.1) 28(1,3.1) 29(0.6,3.1) 30(0.2,3.1) 31(-0.2,3.1) 32(-0.6,3.1) 33(-1,3.1) 34(-1.4,3.1) 35(-1.8,3.1) 36(-2.2,3.1)
  rect 0.991x0.203 smd: 13(3.1,-2.2) 14(3.1,-1.8) 15(3.1,-1.4) 16(3.1,-1) 17(3.1,-0.6) 18(3.1,-0.2) 19(3.1,0.2) 20(3.1,0.6) 21(3.1,1) 22(3.1,1.4) 23(3.1,1.8) 24(3.1,2.2) 37(-3.1,2.2) 38(-3.1,1.8) 39(-3.1,1.4) 40(-3.1,1) 41(-3.1,0.6) 42(-3.1,0.2) 43(-3.1,-0.2) 44(-3.1,-0.6) 45(-3.1,-1) 46(-3.1,-1.4) 47(-3.1,-1.8) 48(-3.1,-2.2)
  rect 4.394x4.394 smd: 49(0,0)
RC0402
  custom 0.12x0.12 smd: 1(0.39,0) 2(-0.39,0)
RC0603
  rect 0.813x0.711 smd: 1(0.737,0) 2(-0.737,0)
RC0805
  rect 0.94x1.346 smd: 1(0.895,0) 2(-0.895,0)
RC1206
  rect 1.6x1.6 smd: 1(1.702,0) 2(-1.702,0)
RC2512
  rect 3.099x3.988 smd: 1(-2.2,0) 2(2.2,0)
RC3216
  rect 3.2x0.94 smd: 1(0,0.825) 2(0,-0.825)
RJ45-C100JH-10805-L-8P
  round 1.295 hole 0.889: 1(3.57,9.5) 2(2.55,8.4) 3(1.53,9.5) 4(0.51,8.4) 5(-0.51,9.5) 6(-1.53,8.4) 7(-2.55,9.5) 8(-3.57,8.4)
  oval 1.727x3.404 hole 0.711x2.388: 9(8,0) 10(-8,0)
SATA-C185Q2-11311-L-13P-R
  round 1.092 hole 1.092 unplated: (-11.85,0) (11.85,0)
  round 1.067 hole 0.711: 1(9.38,0) 2(8.11,0) 3(6.84,0) 4(5.57,0) 5(4.3,0) 6(3.03,0) 7(1.76,0)
  round 1.016 hole 0.61: 8(-4.45,0) 9(-5.45,1.5) 10(-6.45,0) 11(-7.45,1.5) 12(-8.45,0) 13(-9.45,1.5)
  oval 1.803x3.2 hole 0.991x2.388: 14(13.43,0.7) 15(-13.43,0.7)
SC70-2_1-65-6P
  rect 1.27x0.279 smd: 1(1.02,-0.65) 2(1.02,0) 3(1.02,0.65) 4(-1.02,0.65) 5(-1.02,0) 6(-1.02,-0.65)
SDCARD-5-251301001000-6-11P-SMT
  round 1.295 hole 1.295 unplated: (-11.5,0)
  round 1.803 hole 1.803 unplated: (9.5,0)
  rect 0.991x1.803 smd: 1(6.875,2.9) 2(4.375,2.9) 3(1.875,2.9) 4(-0.625,2.9) 5(-3.125,2.9) 6(-5.625,2.9) 7(-8.125,2.9) 8(-9.745,2.9) 9(9.375,2.9)
  rect 0.711x1.803 smd: 10(-11.045,2.9) 11(-12.245,2.9)
  rect 1.499x2.794 smd: 12(11.45,0.95) 13(-13.65,0.95) 14(13.65,-13.65) 15(-13.65,-13.65)
SENSOR-3X3-5-16P-SMT
  rect 0.762x0.254 smd: 1(-1.377,1) 2(-1.377,0.5) 3(-1.377,0) 4(-1.377,-0.5) 5(-1.377,-1) 9(1.377,-1) 10(1.377,-0.5) 11(1.377,0) 12(1.377,0.5) 13(1.377,1)
  rect 0.254x0.762 smd: 6(-0.5,-1.377) 7(0,-1.377) 8(0.5,-1.377) 14(0.5,1.377) 15(0,1.377) 16(-0.5,1.377)
SHORT0402
  rect 0.648x0.5 smd: 1(-0.39,0) 2(0.39,0)
SHORT0603
  rect 1.168x0.711 smd: 1(0.737,0) 2(-0.737,0)
SHORT0805
  rect 1.397x1.346 smd: 1(0.895,0) 2(-0.895,0)
SLP10-2_5X1-5-10P
  rect 0.203x0.686 smd: 1(-1,-0.437) 2(-0.5,-0.437) 4(0.5,-0.437) 5(1,-0.437) 6(1,0.437) 7(0.5,0.437) 9(-0.5,0.437) 10(-1,0.437)
  rect 0.406x1.549 smd: 3(0,0)
SO-8FL-5P-OA
  rect 0.991x0.762 smd: 1(3.73,-1.905) 2(3.73,-0.635) 3(3.73,0.635) 4(3.73,1.905)
  custom 1.132x1.132 smd: 5(0,0)
SOIC8-6-1_27
  rect 0.533x1.753 smd: 1(-1.905,-2.73) 2(-0.635,-2.73) 3(0.635,-2.73) 4(1.905,-2.73) 5(1.905,2.73) 6(0.635,2.73) 7(-0.635,2.73) 8(-1.905,2.73)
SOIC8-7_9-1_27
  rect 0.533x1.549 smd: 1(-1.905,-3.775) 2(-0.635,-3.775) 3(0.635,-3.775) 4(1.905,-3.775) 5(1.905,3.775) 6(0.635,3.775) 7(-0.635,3.775) 8(-1.905,3.775)
SOLDERJUMPER-2
  custom 0.381x0.381 smd: 1(-1.016,0) 2(1.016,0)
SON8-4_5X3_5-5-9P-SMT
  custom 0.05x0.05 smd: 1(-1.6,-1.6) 2(-1.2,-1.6) 3(-0.8,-1.6) 6(-0.8,1.6) 7(-1.2,1.6) 8(-1.6,1.6)
  custom 0.188x0.188 smd: 4(0.6,-1.6) 5(0.6,1.6)
  rect 4.039x2.21 smd: 9(0,0)
SON10-3X3-5-16P
  rect 0.279x0.838 smd: 1(-1,-1.475) 2(-0.5,-1.475) 3(0,-1.475) 4(0.5,-1.475) 5(1,-1.475) 6(1,1.475) 7(0.5,1.475) 8(0,1.475) 9(-0.5,1.475) 10(-1,1.475)
  custom 0.413x0.413 smd: 11(0,0)
  round 0.61 hole 0.305: 12(-0.75,-0.5) 13(0.75,-0.5) 14(0.75,0.5) 15(-0.75,0.5) 16(0,0)
SOT23-2_8-95-6P
  rect 1.346x0.508 smd: 1(1.325,-0.95) 2(1.325,0) 3(1.325,0.95) 4(-1.325,0.95) 5(-1.325,0) 6(-1.325,-0.95)
SOT23-5
  rect 1.016x0.711 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,-0.95)
SOT23-6-2_8-95-6P
  rect 1.194x0.508 smd: 1(1.5,-0.95) 2(1.5,0) 3(1.5,0.95) 4(-1.5,0.95) 5(-1.5,0) 6(-1.5,-0.95)
SOT23_213-3_3-2
  rect 1.27x1.016 smd: 1(1.016,1.016) 2(1.016,-1.016) 3(-1.016,0)
SOT323_213-2_1-1_3-2N7002W
  rect 0.787x0.61 smd: 1(0.8,0.65) 2(0.8,-0.65) 3(-0.8,0)
SOT353-1-2_125-65-5P
  rect 1.245x0.279 smd: 1(1.045,-0.65) 2(1.045,0) 3(1.045,0.65) 4(-1.045,0.65) 5(-1.045,-0.65)
SOT353-2_1-65-5P-1_1H
  rect 1.194x0.305 smd: 1(1.05,-0.65) 2(1.05,0) 3(1.05,0.65) 4(-1.05,0.65) 5(-1.05,-0.65)
SPAD-C236NSNP
  round 5.994 smd: 1(0,0)
SSOP5-P-A-TOSHIBA-B
  rect 1.067x0.305 smd: 1(0.85,-0.65) 2(0.85,0) 3(0.85,0.65) 4(-0.85,0.65) 5(-0.85,-0.65)
SW-TC901-AA1G-A160T-6P
  rect 0.991x1.702 smd: 1(-1.8,3.15) 2(1.8,3.15) 3(-1.8,-3.15) 4(1.8,-3.15)
  rect 0.457x0.991 smd: 5(-2.525,0) 6(2.525,0)
TP2050
  round 0.508 smd: 1(0,0)
TP2650
  round 0.66 smd: 1(0,0)
TP2675
  round 0.66 smd: 1(0,0)
TRF-9_4-1_27-24P
  rect 0.762x1.219 smd: 1(-6.985,-4.35) 2(-5.715,-4.35) 3(-4.445,-4.35) 4(-3.175,-4.35) 5(-1.905,-4.35) 6(-0.635,-4.35) 7(0.635,-4.35) 8(1.905,-4.35) 9(3.175,-4.35) 10(4.445,-4.35) 11(5.715,-4.35) 12(6.985,-4.35) 13(6.985,4.35) 14(5.715,4.35) 15(4.445,4.35) 16(3.175,4.35) 17(1.905,4.35) 18(0.635,4.35) 19(-0.635,4.35) 20(-1.905,4.35) 21(-3.175,4.35) 22(-4.445,4.35) 23(-5.715,4.35) 24(-6.985,4.35)
TSOP6-2_8-95
  rect 0.787x0.635 smd: 1(1.2,-0.95) 2(1.2,0) 3(1.2,0.95) 4(-1.2,0.95) 5(-1.2,0) 6(-1.2,-0.95)
TSSOP28-6_4-65-SLB9635TT
  rect 0.406x1.295 smd: 1(-4.225,-3.05) 2(-3.575,-3.05) 3(-2.925,-3.05) 4(-2.275,-3.05) 5(-1.625,-3.05) 6(-0.975,-3.05) 7(-0.325,-3.05) 8(0.325,-3.05) 9(0.975,-3.05) 10(1.625,-3.05) 11(2.275,-3.05) 12(2.925,-3.05) 13(3.575,-3.05) 14(4.225,-3.05) 15(4.225,3.05) 16(3.575,3.05) 17(2.925,3.05) 18(2.275,3.05) 19(1.625,3.05) 20(0.975,3.05) 21(0.325,3.05) 22(-0.325,3.05) 23(-0.975,3.05) 24(-1.625,3.05) 25(-2.275,3.05) 26(-2.925,3.05) 27(-3.575,3.05) 28(-4.225,3.05)
UMT_213-3-1_3
  rect 1.016x0.762 smd: 1(0.991,0.66) 2(0.991,-0.66) 3(-0.991,0)
unnamed#2
  round 1.016 smd: 1(0,0)
USB-C19083-90905-L-9P
  round 1.397 hole 0.787: 1(3.5,8.95) 2(1,8.95) 3(-1,8.95) 4(-3.5,8.95) 5(-4,7.45) 6(-2,7.45) 7(0,7.45) 8(2,7.45) 9(4,7.45)
  oval 1.194x2.311 hole 0.61x1.702: 10(6.4,9.25) 11(-6.4,9.25)
  oval 1.295x2.007 hole 0.711x1.397: 12(-7.7,0) 13(7.7,0)
WDFN5-3_05X3_05-65
  rect 0.66x0.432 smd: 1(1.385,-0.975) 2(1.385,-0.325) 3(1.385,0.325) 4(1.385,0.975)
  custom 0.575x0.575 smd: 5(-0.735,0)
XTL-3_2X1_5-2_5-0_8H
  rect 0.991x1.803 smd: 1(-1.25,0) 2(1.25,0)
XTL-3_2X2_5-2_2X1_6
  rect 1.397x1.194 smd: 1(-1.1,-0.8) 2(1.1,-0.8) 3(1.1,0.8) 4(-1.1,0.8)
XTL-3_2X2_5-2_2X1_7
  rect 1.397x1.194 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)

## Nets
1.5V_VSNS: PR140.2 PR143.1 PU8.6
2.469V: PR154.2 PR157.1 PU9.3
3V_LDO: PC34.1 PR44.1 PU3.3
3V_MAIN_EN: Q5.2 R406.2 R407.1 U19.A3
3V_MAIN_PWGD: PR162.2 PR164.1 PR200.1 Q11.3 R83.2 R84.1
51211V_DRVH: PQ22.4 PU4.9
51211V_DRVL: PQ23.4 PU4.6
51211V_EN: PR68.1 PR71.2 PU4.3
51211V_FB: PR74.2 PR75.1 PU4.4
51211V_SW: PC53.2 PL4.1 PQ22.1 PQ22.2 PQ22.3 PQ23.5 PR73.1 PU4.8
51211V_TRIP: PR70.2 PU4.2
51211V_TST: PR72.2 PU4.5
51211V_VBST: PR69.2 PU4.10
+1.05V: C716.2 L6.1 L7.1 L8.1 L23.1 PC88.1 PQ24.1 PQ24.2 PQ24.3 PR40.2 PR110.1 PR111.1 PR112.1 PR113.1 PR148.1 Q59.3 R53.1 R54.1 R60.2 R62.1 R64.1 R67.2 R70.2 R71.1 R73.1 R89.2 R113.1 R116.2 R128.1 R139.1 R144.1 R145.1 R459.1 R462.1 R468.1 R477.1 R525.1 R528.1 R570.2 R742.2 TP101.1 U3.5
+1.5V: C321.2 L4.2 PC98.2 PC99.1 PC100.1 PL7.2 PR140.1 R61.1 R66.2 R75.1 R78.1 R79.1 R101.1 R138.2 R142.1 R161.1 R166.2 R354.1 R470.2 R471.1 R499.1 R503.2 R512.1 R531.1 R666.1 R692.2
+1.05V_GFX: C72.1 C73.1 C74.1 C75.1 C76.2 C77.1 C78.2 C79.2 C81.2 C380.1 C382.1 C384.2 C385.1 C386.2 L1.1 L2.2 L3.2 PQ43.1 PQ43.2 PQ43.3 PR198.1 R45.2 U19.AA10 U19.AA12 U19.AA13 U19.AA16 U19.AA18 U19.AA19 U19.AA20 U19.AA21 U19.AA22 U19.AB22 U19.AB23 U19.AC23 U19.AC24 U19.AD24 U19.AD25 U19.AE25 U19.AE26 U19.AE27 U19.AF26 U19.AF27
+1.05V_S5: C111.2 C389.2 PC54.2 PC55.1 PL4.2 PQ24.5 PQ43.5 PR74.1
+1.5V_WLAN: C231.1 C513.1 C514.1 CN10.6 CN10.28 CN10.48 R666.2
+1.5VA: C322.1 C532.1 R354.2 U15.40
+1.35V_GFX: C3.2 C8.1 C9.2 C12.2 C15.2 C18.1 C22.2 C23.2 C25.1 C29.2 C36.1 C43.1 C50.2 C58.1 C80.2 C82.2 C85.1 C96.2 C99.2 C102.2 C350.2 C351.2 C352.2 C355.2 C356.2 C357.2 C359.1 C360.1 C365.2 C366.1 C368.1 C372.1 C373.2 C374.2 C375.2 C377.1 C378.1 C379.2 C381.2 C383.2 PC151.2 PC153.1 PL11.2 PR97.1 R16.1 R18.2 R20.1 R29.1 R37.2 R428.2 R447.2 U19.B26 U19.C25 U19.E23 U19.E26 U19.F14 U19.F21 U19.G13 U19.G14 U19.G15 U19.G16 U19.G18 U19.G19 U19.G20 U19.G21 U19.H24 U19.H26 U19.J21 U19.K21 U19.L22 U19.L24 U19.L26 U19.M21 U19.N21 U19.R21 U19.T21 U19.V21 U19.W21 VRAM1.A1 VRAM1.A8 VRAM1.B2 VRAM1.C1 VRAM1.C9 VRAM1.D2 VRAM1.D9 VRAM1.E9 VRAM1.F1 VRAM1.G7 VRAM1.H2 VRAM1.H9 VRAM1.K2 VRAM1.K8 VRAM1.N1 VRAM1.N9 VRAM1.R1 VRAM1.R9 VRAM2.A1 VRAM2.A8 VRAM2.B2 VRAM2.C1 VRAM2.C9 VRAM2.D2 VRAM2.D9 VRAM2.E9 VRAM2.F1 VRAM2.G7 VRAM2.H2 VRAM2.H9 VRAM2.K2 VRAM2.K8 VRAM2.N1 VRAM2.N9 VRAM2.R1 VRAM2.R9 VRAM3.A1 VRAM3.A8 VRAM3.B2 VRAM3.C1 VRAM3.C9 VRAM3.D2 VRAM3.D9 VRAM3.E9 VRAM3.F1 VRAM3.G7 VRAM3.H2 VRAM3.H9 VRAM3.K2 VRAM3.K8 VRAM3.N1 VRAM3.N9 VRAM3.R1 VRAM3.R9 VRAM4.A1 VRAM4.A8 VRAM4.B2 VRAM4.C1 VRAM4.C9 VRAM4.D2 VRAM4.D9 VRAM4.E9 VRAM4.F1 VRAM4.G7 VRAM4.H2 VRAM4.H9 VRAM4.K2 VRAM4.K8 VRAM4.N1 VRAM4.N9 VRAM4.R1 VRAM4.R9
+1.35V_SUS: C199.2 C200.1 C201.2 C202.2 C203.2 C206.1 C207.1 C208.1 C209.2 C210.1 C218.1 C218.2 C219.1 C219.2 C223.1 C224.1 C225.2 C226.2 C249.1 C251.1 C252.2 C253.2 C254.2 C255.2 C256.1 C257.1 C267.1 C268.2 C269.2 C275.2 C276.2 C277.1 C278.1 C279.2 C280.2 C290.1 C291.1 C293.2 C294.2 C295.2 C298.2 C299.1 C476.2 C477.2 C478.2 C479.1 C480.1 C486.2 C489.2 C490.1 C491.1 C492.2 C493.1 C505.1 C743.2 C744.2 JDIM1.75 JDIM1.76 JDIM1.81 JDIM1.82 JDIM1.87 JDIM1.88 JDIM1.93 JDIM1.94 JDIM1.99 JDIM1.100 JDIM1.105 JDIM1.106 JDIM1.111 JDIM1.112 JDIM1.117 JDIM1.118 JDIM1.123 JDIM1.124 JDIM2.75 JDIM2.76 JDIM2.81 JDIM2.82 JDIM2.87 JDIM2.88 JDIM2.93 JDIM2.94 JDIM2.99 JDIM2.100 JDIM2.105 JDIM2.106 JDIM2.111 JDIM2.112 JDIM2.117 JDIM2.118 JDIM2.123 JDIM2.124 PC60.2 PC65.2 PC66.1 PL13.2 PU5.2 PU5.9 Q31.1 Q31.2 Q31.3 Q31.5 R245.1 R246.1 R255.1 R278.1 R293.2 R318.1 R343.2 U27.AB2 U27.AB5 U27.AB8 U27.AB11 U27.AE2 U27.AE5 U27.AE8 U27.AE11 U27.AH11 U27.K11 U27.N8 U27.N11 U27.T2 U27.T5 U27.T8 U27.T11 U27.W2 U27.W5 U27.W8 U27.W11
+3V: C1.1 C7.1 C124.2 C144.2 C233.1 C235.1 C261.1 C270.1 C335.2 C367.2 C369.2 C370.2 C538.2 C550.1 C552.1 C717.2 C718.2 CN16.1 JDIM1.199 JDIM2.199 L33.1 PQ16.1 PR27.2 PR67.2 PR76.2 PR118.2 PR119.2 PR120.2 PR137.2 PR146.1 PR169.2 Q22.2 Q23.2 Q27.2 Q29.2 Q37.2 Q41.2 Q43.2 Q54.2 Q55.2 Q58.2 Q58.5 R2.2 R3.1 R4.1 R5.2 R6.2 R34.2 R35.2 R47.2 R48.2 R55.1 R63.1 R74.2 R76.1 R77.1 R82.2 R95.1 R98.2 R99.2 R104.2 R106.1 R108.2 R109.1 R111.1 R114.2 R119.1 R121.1 R137.2 R143.1 R162.2 R176.2 R178.2 R179.2 R181.1 R190.2 R198.2 R199.2 R205.2 R206.1 R207.2 R208.1 R209.2 R227.2 R295.1 R300.2 R302.2 R333.1 R334.1 R351.2 R365.1 R508.2 R509.2 R510.1 R513.1 R514.2 R515.2 R517.2 R536.2 R551.2 R555.2 R556.2 R559.2 R568.2 R596.2 R598.2 R599.1 R600.1 R618.2 R620.2 R622.1 R628.2 R631.1 R656.1 R677.2 R678.2 R685.1 R690.2 R693.2 R709.2 R727.1 R728.2 R729.2 R740.2 R746.1 RP7.5 RP7.10 U1.1 U2.4 U2.6 U5.5 U18.5 U20.5 U21.5
+3V_BG: Q14.1 R72.1
+3V_DS3: C419.2 Q49.3 R203.2 R481.2 R579.2
+3V_DSW: D3.1 Q28.2 R136.1 R151.1 R160.2 R197.2 R216.2
+3V_EC: C242.1 R295.2 U13.11
+3V_GFX: C13.1 C34.1 C39.1 C45.1 C65.1 C69.1 C71.2 C719.2 C720.2 C723.2 C724.2 PQ47.1 PR204.1 Q4.1 Q10.2 Q24.2 Q26.2 Q45.2 R8.2 R10.1 R12.1 R15.2 R24.2 R36.2 R84.2 R308.2 R324.1 R399.2 R402.2 R403.2 R405.2 R406.1 R407.2 R408.2 R411.2 R418.2 R421.2 R423.2 R430.1 R433.2 R439.2 R440.2 R444.2 R451.2 R732.2 R733.2 U19.AA8 U19.AA9 U19.AB8 U19.G10 U19.G12
+3V_MAIN: C24.1 C26.1 C27.1 C28.1 C721.2 C722.2 Q3.2 Q3.5 Q4.3 R7.1 R8.1 R85.2 R386.1 R394.2 U19.G8 U19.G9
+3V_PCH_ME: C501.1 R644.1 R652.1 R657.1 U30.8
+3V_RTC: C237.1 C475.2 C481.1 C482.2 C483.1 D22.3 R158.1 R171.1 R173.1 R183.1 R542.2 U13.3 U24.A6
+3V_RTC_0: BT1.1 Q30.1 R589.1
+3V_RTC_1: D22.1 R589.2 TP181.1
+3V_RTC_2: D22.2 R562.1
+3V_S5: C127.2 C216.2 C221.2 C387.2 C457.2 D3.2 L29.2 PQ17.1 PR62.1 PR88.2 PR136.1 PR173.1 Q14.3 Q17.2 Q18.2 Q47.1 Q49.1 R125.2 R127.1 R133.1 R149.1 R169.2 R172.1 R174.2 R180.1 R184.2 R185.2 R186.1 R187.1 R188.1 R189.2 R196.1 R214.1 R219.1 R220.1 R223.2 R224.1 R230.1 R250.1 R265.1 R288.2 R330.2 R331.2 R481.1 R488.1 R489.2 R493.2 R522.1 R537.1 R573.1 R575.1 R576.1 R578.1 R580.2 R584.2 R585.2 R590.1 R614.1 R633.1 R636.2 R642.1 R652.2 R717.1 R720.2 RP1.5 RP1.10 U8.5 U12.5 U28.5
+3V_SUS: L30.1 PQ42.1 PR217.1 R259.1 R714.1
+3V_TPM_VDD: C220.1 C506.2 C507.1 R238.2 R262.1 R270.2 R656.2 U11.10 U11.19 U11.24
+3VPCU: C98.2 C420.2 C449.2 C745.2 C746.2 CN4.1 D11.1 LED1.1 LED2.1 PC13.1 PC41.2 PC42.1 PC95.1 PC96.2 PL3.1 PQ16.3 PQ17.3 PQ42.3 PQ47.3 PR12.2 PR14.2 PR15.2 PR25.2 PR26.2 PR28.2 PR35.2 PR47.1 PR52.1 PR189.1 PU2.5 PU8.1 PU8.2 PU8.16 R30.2 R38.1 R182.1 R216.1 R217.2 R276.2 R315.2 R317.2 R322.1 R332.2 R340.2 R480.1 R492.1 R562.2 R695.2 R718.2 R721.2 RP2.2 RP2.10
+3VPCU_EC: C228.1 C229.1 C240.1 C260.1 C263.1 C526.1 L9.2 L10.1 R322.2 U13.26 U13.50 U13.92 U13.114 U13.121
+3VPCU_ECPLL: C227.1 L9.1 U13.127
+5V: C313.1 C318.1 C429.2 C434.2 C437.2 C516.2 C535.2 C536.1 C737.2 C738.2 C739.2 C740.2 C747.2 C748.2 C753.2 C754.2 D4.2 D7.2 D23.2 L28.1 PQ15.1 PQ15.2 PQ15.3 PR147.1 Q13.2 Q15.2 Q16.3 Q19.1 Q19.2 Q19.5 Q19.6 Q40.3 Q42.2 Q52.1 R134.2 R296.2 R327.2 R483.2 R664.1 U15.41 U15.46 U22.5 U25.5 U26.2 U31.1 U31.3
+5V_HDD: C271.1 C272.1 C273.1 C282.1 C284.1 C287.1 CN11.14 CN11.15 CN11.16 CN13.8 CN13.9 CN13.10 R327.1
+5V_KB: C508.2 C509.2 Q52.3 R662.1
+5V_KB_R: CN8.3 CN8.4 R662.2
+5V_ODD: C146.1 C147.1 C148.1 C428.1 C450.1 C452.1 CN6.9 CN6.10 Q19.4 R134.1 R150.1
+5V_S5: C285.1 C715.1 CN17.1 CN17.2 CN17.3 CN17.4 CN17.5 CN17.6 CN17.7 CN17.8 PC70.1 PC140.2 PC155.1 PQ14.1 PQ14.2 PQ14.3 PR63.1 PR94.2 PR158.2 PU6.2 PU11.7 PU12.2 R241.1 R242.1 R479.2 U33.5 VC1.2
+5VA: C327.1 C331.1 C534.1 C537.2 L28.2 R697.1 U15.26 U31.4
+5VPCU: LED1.2 LED2.2 PC39.1 PC40.2 PC52.2 PC61.2 PD5.2 PL2.1 PQ14.5 PQ15.5 PR50.2 PU3.14 PU4.7 PU5.12 R719.2 R722.2
+15V: PR60.1 PR64.1 PR149.1 PR199.1 PR205.1 PR216.1 R159.2
+15V_ALWP: PC48.2 PD6.1 PR60.2
+A3VPCU: C247.1 L10.2 U13.74
+V1.05M_VCCASW: C149.2 C159.2 C162.1 C165.1 C435.2 R128.2 U24.AA18 U24.U18 U24.U20 U24.U22 U24.U24 U24.V18 U24.V20 U24.V22 U24.V24 U24.Y18 U24.Y20 U24.Y22
+V1.05M_VCCDUSBSUS: C125.1 U24.Y35
+V1.05M_VCCSUS: C198.1 U24.Y12
+V1.05S_PCH_VCC: C151.1 C161.1 C163.1 C197.1 R145.2 U24.AA24 U24.AA26 U24.AD20 U24.AD22 U24.AD24 U24.AD26 U24.AD28 U24.AE18 U24.AE20 U24.AE22 U24.AE24 U24.AE26 U24.AG18 U24.AG20 U24.AG22 U24.AG24 U24.Y26
+V1.05S_VCC_AXCK_DCB: C408.1 C412.1 L22.2 U24.AP45
+V1.05S_VCC_EXP: C123.1 C150.1 C155.1 C158.1 C160.1 C164.1 R528.2 U24.AK18 U24.AK20 U24.AK22 U24.AM18 U24.AM20 U24.AM22 U24.AN34 U24.AN35 U24.AP22 U24.AR22 U24.AT22
+V1.05S_VCC_SSCFF: C141.1 R53.2 U24.AA30 U24.AA32 U24.Y32
+V1.05S_VCCAPLL_EXP: C431.1 L23.2 R512.2 U24.BE22
+V1.05S_VCCAPLL_FDI: C118.1 L6.2 R75.2 U24.BB44
+V1.05S_VCCAPLL_SATA3: C176.1 L8.2 R142.2 U24.AN11
+V1.5S_VCCATS: R78.2 U24.AW40
+V1.05S_VCCAUSB: C136.2 R67.1 U24.U35
+V1.05S_VCCAUX: R73.2 U24.U36
+V1.05S_VCCCLKF100: C122.1 R64.2 U24.AD35 U24.AD36
+V1.05S_VCCPCPU: C169.1 C181.2 C182.2 R129.2 U24.AJ12 U24.AJ14
+V1.05S_VCCSSCF100: C135.1 R62.2 U24.AE30 U24.AE32 U24.AG30 U24.AG32
+V1.05S_VCCUSBCORE: C142.1 R54.2 U24.U30 U24.V28 U24.V30 U24.Y30
+V3.3A_VCCPSUS: C153.2 Q47.3 R489.1 U24.AJ30 U24.AJ32 U24.R20 U24.R22
+V3.3A_VCCPUSB: C152.2 R488.2 U24.R24 U24.R26 U24.R28 U24.U26
+V3.3M_VCCPSPI: C183.1 R181.2 R522.2 U24.AD12
+V3.3S_ADACBG: R72.2 R76.2 U24.M31
+V3.3S_VCC_ASEPCI: C126.1 R74.1 U24.U32 U24.V32
+V3.3S_VCC_FLEX0: C130.1 R98.1 U24.M29
+V3.3S_VCC_FLEX1: C140.1 R99.1 U24.L29
+V3.3S_VCC_FLEX23: C143.1 R114.1 U24.L26 U24.M26
+V3.3S_VCC_GIO: C137.2 R55.2 U24.R30 U24.R32
+V3.3S_VCCAUBG: C154.2 R108.1 U24.L24
+V3.3S_VCCPCORE: C179.2 R190.1 U24.AE14 U24.AF12 U24.AG14
+V3.3S_VCCPFUSE: C166.1 R139.2 R143.2 U24.P18 U24.P20
+V3.3S_VCCPTS: C129.2 R95.2 U24.AK30 U24.AK32
+VCC_AXCK_DCB: L22.1 R477.2
+VCC_CPU_XDP: C391.2 C407.2 R458.1 TP83.1 TP84.1
+VCC_HDA_IO: C427.2 R493.1 R501.2 U24.A26
+VCC_PCH_XDP: R720.1 TP167.1 TP168.1
+VCCA_DAC_1_2: C114.2 C115.1 C416.2 L4.1 U24.P45
+VCCA_USBSUS: C139.1 C145.1 U24.AJ26 U24.AJ28
+VCCAPLL_USB3: C128.1 L7.2 R101.2 U24.AK26 U24.AK28
+VCCAXCK_VRM: C117.1 L5.2 R61.2 R80.1 U24.AF34
+VCCAXCK_VRM_R: L5.1 R60.1
+VCCCLKF135: C121.1 R70.1 U24.AD34
+VCCIN: C112.2 C113.2 C170.2 C171.1 C172.1 C173.2 C174.1 C184.2 C185.1 C186.2 C187.1 C188.2 C191.2 C192.1 C193.1 C194.1 C195.2 C439.2 C440.1 C441.2 C442.2 C443.2 C451.2 C453.1 C454.2 C455.2 C456.2 C464.2 C465.2 C466.2 C467.1 C468.2 C741.2 C742.1 C751.2 C752.1 PC80.1 PC82.1 PC83.1 PC142.1 PC143.1 PC150.1 PC162.1 PL6.2 PL12.2 PR130.2 R460.2 U27.AA26 U27.AA28 U27.AA30 U27.AA32 U27.AA34 U27.AB25 U27.AB26 U27.AB27 U27.AB28 U27.AB29 U27.AB30 U27.AB31 U27.AB32 U27.AB33 U27.AB34 U27.AB35 U27.AC26 U27.AC28 U27.AC30 U27.AC32 U27.AC34 U27.AD25 U27.AD26 U27.AD27 U27.AD28 U27.AD29 U27.AD30 U27.AD31 U27.AD32 U27.AD33 U27.AD34 U27.AD35 U27.AE26 U27.AE28 U27.AE30 U27.AE32 U27.AE34 U27.AF25 U27.AF26 U27.AF27 U27.AF28 U27.AF29 U27.AF30 U27.AF31 U27.AF32 U27.AF33 U27.AF34 U27.AF35 U27.AG26 U27.AG28 U27.AG30 U27.AG32 U27.AG34 U27.AH25 U27.AH26 U27.AH27 U27.AH28 U27.AH29 U27.AH30 U27.AH31 U27.AH32 U27.AH33 U27.AH34 U27.AH35 U27.AJ25 U27.AJ26 U27.AJ27 U27.AJ28 U27.AJ29 U27.AJ30 U27.AJ31 U27.AJ32 U27.AJ33 U27.AJ34 U27.AJ35 U27.F25 U27.G25 U27.H25 U27.J25 U27.K25 U27.K26 U27.L25 U27.M25 U27.N25 U27.P25 U27.R25 U27.T25 U27.U25 U27.U26 U27.V25 U27.V26 U27.W26 U27.W27 U27.Y25 U27.Y26 U27.Y27 U27.Y28 U27.Y29 U27.Y30 U27.Y31 U27.Y32 U27.Y33 U27.Y34 U27.Y35
