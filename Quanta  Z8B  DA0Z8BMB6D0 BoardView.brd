# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_TXN0_C: length 3.6
  TOP w0.127: R336.1 19.84,37.92 19.93,38 20.18,38 20.5,38.32 20.64,38.32 v3(21.11,37.85) 21.67,38.41 21.81,38.41 C300.2
USB3_TXN0_R: length 10.6
  TOP w0.127: R336.2 18.6,38 18.09,38 17.76,38.33 16.45,38.33 v3(15.93,37.81) 15.45,38.3 14.82,38.3 v3(14.62,38.09) 14.43,38.28 13.36,38.28 12.72,38.93 12.32,38.93 12.22,38.83 CN12.8
  BOTTOM w0.127: RV2.1 16.24,38.33 14.86,38.33 v3(14.62,38.09)
USB3_TXP0: length 208.7
  TOP w0.127: v4(24.62,40.53) 24.62,40.37 24.49,40.24 24.06,40.24 23.66,39.84 23.66,38.83 23.56,38.72 23.42,38.72 C289.1
  IN2 w0.133: v3(143.58,111.32) 143.58,111.5 143.43,111.65 138.47,111.65 134.34,115.77 134.34,120.56 133.02,121.89 117.2,121.89 116.46,121.15 104.95,121.15 104.37,121.74 99.29,121.74 98.32,120.76 98.32,120.23 97.25,119.16 94.93,119.16 87.55,111.78 85.63,111.78 72.31,98.46 53.2,98.46 51.89,99.77 48.93,99.77 47.42,98.26 39.9,98.26 36.35,94.71 36.35,91.54 33.9,89.09 33.9,73.41 27.11,66.63 27.11,61.59 21.31,55.79 21.31,46.66 21.87,46.1 21.87,43.63 23.47,42.03 23.47,40.56 23.81,40.22 24.52,40.22 24.62,40.31 v4(24.62,40.53)
  BOTTOM w0.089: U24.BD23 153.26,104.56 152.47,104.56 152.28,104.75 152.28,104.98 152.25,105.01 152.25,105.03
  BOTTOM w0.127: 152.25,105.03 152.25,105.2 151.15,106.3 147.55,106.3 146.39,107.46 146.39,110.66 145.48,111.58 143.68,111.58 143.58,111.48 v3(143.58,111.32)
USB3_TXP0_C: length 3.6
  TOP w0.127: R328.1 19.84,38.93 19.93,38.85 20.2,38.85 20.49,38.56 20.58,38.56 v3(21.16,39.15) 21.66,38.65 21.82,38.65 C289.2
USB3_TXP0_R: length 10.6
  TOP w0.127: R328.2 18.6,38.85 18.23,38.85 17.95,38.58 16.44,38.58 v3(15.93,39.08) 15.38,38.54 14.82,38.54 v3(14.61,38.75) 14.38,38.52 13.46,38.52 12.82,39.17 12.41,39.17 12.22,39.36 CN12.9
  BOTTOM w0.127: v3(14.61,38.75) 14.78,38.58 16.17,38.58 RV1.1
USB_OC0#: length 221.6
  TOP w0.127: v3(168.84,83.54) 168.84,83.74 168,84.58 168,85.29 168.21,85.5 RP1.2 ; U33.3 23.31,42.81 23.8,43.3 23.8,45.31 24.57,46.07 v2(25.56,46.07) 28.86,46.07 29.7,45.23 32.11,45.23 32.77,45.89 36.83,45.89 39.48,43.25 39.48,41.75 40.77,40.46 v3(40.77,39.77)
  IN1 w0.133: v3(168.84,83.54) 168.84,82.99 166.11,80.26 166.11,79.03 160.96,73.88 160.96,64.81 162.04,63.74 162.04,60.57 161.35,59.88 161.35,59.33 147.21,45.2 147.21,44.2 146.56,43.54 145.73,43.54 142.38,40.18 142.38,38.25 141.53,37.4 140.99,37.4 133.04,29.46 83.67,29.46 75.82,21.61 52.66,21.61 49.41,24.86 49.41,31.64 48.78,32.27 47.75,32.27 45.84,34.18 44.87,34.18 42.59,36.47 42.59,37.28 40.77,39.09 v3(40.77,39.77)
  BOTTOM w0.102: U24.P3 165.77,95.95 165.77,95.48 165.64,95.35 165.64,95.34 165.56,95.26 165.56,94.87 165.86,94.56 165.86,93.38 165.9,93.35 165.9,93.34 167.75,91.49 167.75,90.58 168.24,90.09 168.24,88.7 167.97,88.43 167.97,87.73 R591.1 168.3,87.69 168.51,87.47
  BOTTOM w0.127: v3(168.84,83.54) 169.09,83.79 169.09,86.04 168.56,86.57 168.56,87.43 168.51,87.47
USB_OC1#: length 107.8
  TOP w0.127: RP1.8 166.15,86.14 v3(166.02,86.26)
  IN2 w0.133: v3(178.57,27.01) 178.57,27.05 179.63,28.11 183.01,28.11 186.64,31.75 186.64,36.34 186.39,36.59 186.39,39.65 182.31,43.73 181.16,43.73 177.74,47.16 174.7,47.16 172.53,49.33 172.53,55.06 170.93,56.67 169.48,56.67 169.32,56.51 168.79,56.51 168.51,56.8 168.51,58.38 166.02,60.86 166.02,61.73 166.78,62.49 166.78,64.22 167.31,64.75 167.31,66.26 167.04,66.53 167.04,67.4 166.56,67.88 166.56,71.37 168.04,72.85 168.04,75 168.05,75.01 168.05,80.56 168.83,81.34 168.83,82.58 166.02,85.38 v3(166.02,86.26)
  BOTTOM w0.102: 165.83,87.22 165.83,87.43 166.06,87.67 R602.1 166.28,87.68 165.84,88.12 165.84,90.61 165.84,91.83 164.13,93.54 164.13,94.76 164.13,94.76 164.13,95.04 U24.V1
  BOTTOM w0.127: CN17.11 184.17,16.34 184.89,17.06 184.89,21.17 183.36,22.7 183.36,25.3 181.88,26.78 180.36,26.78 180.08,26.5 179.09,26.5 v3(178.57,27.01) ; v3(166.02,86.26) 165.83,86.45 165.83,87.22
USB_OC2#: length 108.6
  TOP w0.127: RP1.7 166.23,86.77 166,87 166,88.08 v3(165.99,88.08) 166.46,88.55 v3(166.53,88.55)
  IN2 w0.133: v3(166.53,88.55) 166.53,86.68 169.3,83.91 169.3,81.41 168.36,80.46 168.36,74.94 168.31,74.89 168.31,72.74 167.77,72.19 167.77,69.33 168.22,68.88 168.22,65.27 167.06,64.11 167.06,60.21 168.25,59.02 169.15,58.12 169.15,57.47 169.67,56.94 171.04,56.94 172.8,55.18 172.8,49.55 174.91,47.44 177.84,47.44 181.28,44.01 182.42,44.01 186.67,39.76 186.67,36.7 186.92,36.45 186.92,31.64 183.09,27.81 179.98,27.81 v3(179.22,27.05)
  BOTTOM w0.102: U24.U2 164.66,95.07 164.95,94.79 164.95,94.38 164.63,94.06 164.63,93.42 166.66,91.39 166.66,90.59 R577.1 166.45,90.21 166.68,89.98 166.68,88.7 v3(166.53,88.55)
  BOTTOM w0.127: CN17.12 184.03,15.84 185.14,16.95 185.14,21.28 183.62,22.81 183.62,25.45 181.95,27.12 179.29,27.12 v3(179.22,27.05)
USB_OC3#: length 10.8
  TOP w0.127: v3(168.5,88.25) 167.95,87.7 167.95,87.57 167.78,87.41 RP1.6
  BOTTOM w0.102: R607.1 169.02,87.64 168.5,88.16 v3(168.5,88.25) 168.44,88.31 168.44,90.45 167.95,90.94 167.95,91.57 166.07,93.45 166.07,94.72 165.86,94.93 U24.P1
USB_OC4#: length 27
  TOP w0.127: v3(168.37,81.86) 167.39,81.86 v2(166.22,83.03) 165.61,83.64 165.61,84.91 166.2,85.5 RP1.9
  BOTTOM w0.102: U24.M3 166.75,95.97 166.75,95.51 166.98,95.28 166.98,94.86 166.89,94.77 166.89,94.01 168.69,92.21 169.22,92.21 170.11,91.32 170.11,90.58 170.57,90.11 170.57,88.62 170.98,88.22 R603.1 171,87.65 171.15,87.65 171.33,87.47
  BOTTOM w0.127: v3(168.37,81.86) 168.37,81.11 168.7,80.78 169.38,80.78 169.69,81.08 169.69,81.69 171.01,83.02 171.01,86.16 171.46,86.61 171.46,87.34 171.33,87.47
USB_OC5#: length 16.4
  TOP w0.127: v3(167.1,88.24) 167.09,88.24 167.09,88.24 167.47,88.24 167.94,88.72 169.38,88.72 169.9,88.2 169.9,87.26 169.4,86.77 RP1.4
  BOTTOM w0.102: 167.3,87.41 167.3,88.04 v3(167.1,88.24) 166.94,88.4 166.94,88.78 166.88,88.83 166.88,90.53 166.91,90.56 166.91,91.65 165.46,93.1 165.46,94.35 165.15,94.65 165.15,95.04 U24.T1
  BOTTOM w0.127: 167.3,87.41 167.3,86.47 168.07,85.7 R613.1
USB_OC6#: length 14.4
  TOP w0.127: RP1.1 169.45,84.87 170.07,85.49 v3(170.07,85.78)
  BOTTOM w0.102: U24.N2 166.37,95.51 166.37,95.01 166.47,94.91 166.47,94.9 166.48,94.89 166.48,93.8 168.49,91.79 169.07,91.79 169.7,91.15 169.7,90.47 169.52,90.29 169.52,88.82 169.56,88.78 169.56,87.49 169.58,87.47
  BOTTOM w0.127: R627.1 170.1,85.75 v3(170.07,85.78) 169.58,86.27 169.58,87.47
USB_OC7#: length 12.4
  TOP w0.127: v3(170.06,86.44) 169.76,86.14 RP1.3
  BOTTOM w0.102: U24.M1 166.68,95.13 166.68,93.88 168.58,91.99 169.15,91.99 169.9,91.24 169.9,90 R586.1 170.22,89.97 170.37,89.82 170.37,88.49 170.56,88.3 170.56,87.6 170.44,87.47
  BOTTOM w0.127: 170.44,87.47 170.06,87.09 v3(170.06,86.44)
USBCOMP: length 3.1
  TOP w0.254: v3(168.12,105.22) 168.12,105.15 168.53,104.74 169.13,104.74 R122.1
  BOTTOM w0.254: U24.K24 168.12,105.08 v3(168.12,105.22) 168.12,105.4 167.79,105.73
USBON#: length 229
  TOP w0.127: v3(182.09,54.19) 182.23,54.33 U13.79 ; U33.4 24.78,42.81 26.55,41.04 v2(26.55,40.86) 26.55,39.06 23.5,36.01 v3(23.5,35.22)
  IN1 w0.133: v3(182.73,22.01) 182.83,22.01 184.89,24.07 184.89,40.35 186.03,41.49 186.03,45.87 182.7,49.2 182.7,53.59 v3(182.09,54.19)
  IN2 w0.133: v3(23.5,35.22) 24.06,34.66 26.32,34.66 26.85,34.13 26.85,33.48 28.08,32.25 30.97,32.25 31.42,32.71 36.78,32.71 41.18,28.31 41.18,27.79 50.59,18.38 68.31,18.38 70.41,20.47 147.13,20.47 149.01,22.34 150.79,22.34 154.41,25.96 167.93,25.96 169.78,24.11 169.78,21.27 171.34,19.71 180.43,19.71 v3(182.73,22.01)
  BOTTOM w0.127: CN17.9 184.2,17.34 184.63,17.77 184.63,21.07 183.94,21.76 182.99,21.76 v3(182.73,22.01)
USBP0+: length 320.3
  TOP w0.127: v3(21.92,35.78) 21.61,36.1 20.91,36.1 20.52,35.71 19.93,35.71 19.84,35.63 R344.1
  IN2 w0.133: v3(174.56,112.25) 174.75,112.44 175.49,112.44 175.9,112.85 178.19,112.85 178.36,113.02 183.51,113.02 183.63,112.91 186.99,112.91 187.37,113.29 187.98,113.29 192.03,109.24 192.03,103.34 193.12,102.24 193.12,101.32 192.43,100.63 192.43,98.27 193.12,97.58 193.12,96.14 192.51,95.53 192.51,93.37 186.07,86.93 185.09,86.93 182.84,84.68 182.84,84.01 180.36,81.53 180.36,77.17 181.05,76.48 181.05,73.45 182.99,71.51 182.99,68 183.26,67.74 183.26,65.75 183.74,65.27 184.43,65.27 184.81,64.89 184.81,63.54 186.56,61.79 187.25,61.79 187.53,61.51 187.53,60.22 194.03,53.71 194.03,27.5 191.36,24.83 191.36,19.2 184.18,12.02 177.47,12.02 176.4,13.1 172.65,13.1 172.15,13.61 168.52,13.61 168.16,13.97 136.53,13.97 132.7,17.8 70,17.8 68.4,16.2 50.86,16.2 38.71,28.34 38.71,30.02 36.56,32.17 31.9,32.17 31.45,31.72 27.88,31.72 26.21,33.39 22.84,33.39 21.24,34.99 21.24,35.88 21.44,36.09 21.85,36.09 21.92,36.01 v3(21.92,35.78)
  BOTTOM w0.102: v3(174.56,112.25) 174.56,112.51 174.48,112.59 174.28,112.59 171.73,110.04 171.39,110.04 171.2,109.85 170.94,109.85 170.65,110.14 170.55,110.14 170.39,110.31 170.26,110.31 170.18,110.22 U24.D37
USBP0+_R: length 8.4
  TOP w0.127: R344.2 18.6,35.71 17.63,35.71 17.35,35.98 17.15,35.98 v3(16.61,35.44) 16.06,36 15.33,36 v3(15.09,35.76) 14.88,35.97 13.88,35.97 13.72,35.81 CN12.3
  BOTTOM w0.127: RV4.1 16.25,36.04 15.37,36.04 v3(15.09,35.76)
USBP0-: length 320.3
  TOP w0.127: v4(21.92,36.54) 21.72,36.34 20.75,36.34 20.52,36.56 19.93,36.56 19.84,36.65 R339.1
  IN2 w0.133: v4(21.92,36.54) 21.72,36.34 21.34,36.34 20.98,35.99 20.98,34.89 22.74,33.13 26.11,33.13 27.78,31.46 31.55,31.46 32.01,31.92 36.45,31.92 38.46,29.91 38.46,28.23 50.75,15.94 68.51,15.94 70.11,17.54 132.59,17.54 136.42,13.71 168.05,13.71 168.42,13.35 172.04,13.35 172.55,12.85 176.29,12.85 177.37,11.77 184.28,11.77 191.62,19.1 191.62,24.73 194.29,27.4 194.29,53.82 187.78,60.32 187.78,61.62 187.36,62.05 186.67,62.05 185.07,63.65 185.07,64.99 184.53,65.52 183.85,65.52 183.51,65.86 183.51,67.84 183.25,68.11 183.25,71.61 181.3,73.56 181.3,76.58 180.61,77.27 180.61,81.42 183.1,83.9 183.1,84.58 185.2,86.68 186.18,86.68 192.76,93.26 192.76,95.42 193.38,96.04 193.38,97.69 192.69,98.38 192.69,100.52 193.38,101.21 193.38,102.35 192.28,103.45 192.28,109.35 188.08,113.54 187.26,113.54 186.88,113.16 183.73,113.16 183.62,113.28 178.26,113.28 178.08,113.1 175.79,113.1 175.39,112.69 174.87,112.69 v3(174.56,113.01)
  BOTTOM w0.102: U24.B37 171.14,110.24 171.64,110.24 174.2,112.79 174.34,112.79 v3(174.56,113.01)
USBP0-_R: length 8.5
  TOP w0.127: R339.2 18.6,36.56 17.69,36.56 17.35,36.23 17.15,36.23 v3(16.64,36.74) 16.15,36.25 15.31,36.25 v3(15.07,36.49) 14.79,36.22 13.87,36.22 13.72,36.37 CN12.2
  BOTTOM w0.127: v3(15.07,36.49) 15.27,36.29 16.22,36.29 RV3.1
USBP1+: length 146.1
  IN2 w0.133: v3(186.64,11.23) 186.83,11.43 187.21,11.43 192.39,16.6 192.39,24.4 195.13,27.15 195.13,54.1 189.54,59.69 189.54,60.95 186.97,63.52 186.97,69.41 182.11,74.26 182.11,78.9 181.53,79.48 181.53,81.21 186.14,85.82 187.69,85.82 193.27,91.4 193.27,92.68 193.58,92.99 193.58,94.91 194.17,95.5 194.17,98.06 193.53,98.7 193.53,100.2 194.42,101.08 194.42,108.68 193.2,109.9 192.92,109.9 188.51,114.31 186.83,114.31 186.45,113.93 184.52,113.93 183.95,114.5 178.39,114.5 178.01,114.12 175.8,114.12 175.55,114.37 175.16,114.37 v3(174.93,114.6)
  BOTTOM w0.102: v3(174.93,114.6) 174.73,114.39 174.38,114.39 173.59,113.6 173.59,112.8 171.85,111.07 171.59,111.07 171.16,110.64 170.7,110.64 U24.C38
  BOTTOM w0.127: CN17.21 185.7,11.34 185.78,11.42 186.45,11.42 v3(186.64,11.23)
USBP1-: length 146.1
  IN2 w0.133: v3(174.8,113.71) 174.8,114.01 174.91,114.12 175.44,114.12 175.7,113.86 178.11,113.86 178.5,114.24 183.85,114.24 184.42,113.67 186.56,113.67 186.94,114.06 188.4,114.06 192.81,109.64 193.09,109.64 193.27,109.47 194.16,108.57 194.16,101.19 193.27,100.3 193.27,98.6 193.92,97.95 193.92,95.61 193.32,95.02 193.32,93.09 193.02,92.79 193.02,91.5 187.59,86.07 186.03,86.07 181.28,81.32 181.28,79.37 181.86,78.79 181.86,74.16 186.71,69.31 186.71,63.42 189.28,60.85 189.28,59.58 194.87,53.99 194.87,27.25 192.13,24.51 192.13,16.71 187.1,11.68 186.75,11.68 186.64,11.79 186.64,12.21 186.64,12.21 v3(186.64,12.18)
  BOTTOM w0.102: U24.A38 171.52,110.7 171.68,110.86 171.93,110.86 173.79,112.72 173.79,113.52 174.46,114.19 174.81,114.19 174.93,114.06 174.93,113.84 174.81,113.71 v3(174.8,113.71)
  BOTTOM w0.127: v3(186.64,12.18) 186.64,11.79 186.51,11.66 185.68,11.66 185.6,11.58 184.14,11.58 184.06,11.66 184.06,11.77 183.98,11.84 CN17.20
USBP2+: length 139.7
  IN2 w0.133: v3(173.67,110.51) 173.67,110.71 173.79,110.82 174.06,110.82 174.43,111.19 175.62,111.19 175.72,111.3 178.99,111.3 179.91,112.21 182.64,112.21 183.15,111.7 187.76,111.7 191.26,108.21 191.26,102.79 191.63,102.42 191.63,94.93 187.53,90.84 187.53,89.61 185.64,87.72 184.65,87.72 181.11,84.17 181.11,83.44 179.39,81.72 179.39,75.57 180.17,74.79 180.17,72.86 182.07,70.96 182.07,66.61 182.49,66.19 182.49,65.33 183.57,64.25 183.57,63.62 186.16,61.03 186.16,60.39 190.44,56.12 190.44,53.36 193.25,50.55 193.25,27.89 190.59,25.24 190.59,19.52 184.15,13.07 182.12,13.07 181.86,13.34 181.86,13.55 182,13.68 v3(182.18,13.68)
  BOTTOM w0.102: U24.C36 170.7,109.64 171.17,109.64 171.38,109.44 171.39,109.43 171.64,109.43 171.74,109.53 171.79,109.53 173.14,110.88 173.54,110.88 173.67,110.75 v3(173.67,110.51)
  BOTTOM w0.127: v3(182.18,13.68) 181.86,14 181.86,14.14 182.17,14.45 182.43,14.45 182.54,14.34 CN17.15
USBP2-: length 139.7
  IN2 w0.133: v3(181.42,13.68) 181.61,13.5 181.61,13.23 182.02,12.82 184.25,12.82 190.85,19.42 190.85,25.13 193.5,27.78 193.5,50.65 190.69,53.47 190.69,56.22 186.41,60.5 186.41,61.13 183.82,63.73 183.82,64.36 182.74,65.43 182.74,66.3 182.32,66.72 182.32,71.06 180.42,72.96 180.42,74.89 179.64,75.67 179.64,81.61 181.36,83.33 181.36,84.07 184.76,87.46 185.75,87.46 187.79,89.5 187.79,90.73 191.88,94.83 191.88,102.52 191.51,102.89 191.51,108.31 187.87,111.96 183.26,111.96 182.75,112.47 179.8,112.47 178.89,111.55 175.61,111.55 175.51,111.45 174.32,111.45 173.95,111.08 173.86,111.08 v3(173.67,111.27)
  BOTTOM w0.102: U24.A36 171.71,109.73 173.06,111.08 173.48,111.08 v3(173.67,111.27)
  BOTTOM w0.127: v3(181.42,13.68) 181.62,13.89 181.62,14.24 182.07,14.69 182.39,14.69 182.54,14.84 CN17.14
USBP3+: length 133.9
  IN2 w0.133: v3(174.65,110.61) 174.88,110.38 174.99,110.38 175.17,110.2 175.51,110.2 176.07,110.76 179.18,110.76 180.12,111.7 182.43,111.7 182.96,111.17 183.87,111.17 184.71,110.33 186.83,110.33 190.7,106.45 190.7,97.12 190.4,96.82 190.4,94.75 186.75,91.1 186.75,89.55 185.43,88.23 184.32,88.23 180.52,84.43 180.52,83.61 178.87,81.96 178.87,75.35 179.65,74.57 179.65,72.61 181.55,70.71 181.55,66.37 181.89,66.03 181.89,64.43 184.05,62.28 184.05,56.55 185.8,54.8 185.8,52.88 190.85,47.82 190.85,43.85 192.03,42.68 192.03,32.5 192.46,32.07 192.46,27.83 190.08,25.45 190.08,21.14 186.87,17.93 186.87,16.97 v3(187.08,16.76)
  BOTTOM w0.102: v3(174.65,110.61) 174.45,110.41 174.29,110.41 173.53,109.64 172.2,109.64 171.78,109.23 171.37,109.23 171.16,109.01 170.7,109.01 U24.C34
  BOTTOM w0.127: v3(187.08,16.76) 186.87,16.55 186.87,15.97 186.14,15.24 186.14,13.4 185.57,12.84 CN17.18
USBP3-: length 133.8
  IN2 w0.133: v3(186.17,16.76) 186.49,16.76 186.62,16.88 186.62,18.04 189.83,21.25 189.83,25.55 192.21,27.93 192.21,31.97 191.77,32.4 191.77,42.57 190.6,43.75 190.6,47.72 185.55,52.77 185.55,54.69 183.8,56.44 183.8,62.17 181.64,64.33 181.64,65.93 181.3,66.27 181.3,70.61 179.4,72.51 179.4,74.47 178.62,75.25 178.62,82.07 180.27,83.72 180.27,84.53 184.22,88.49 185.32,88.49 186.49,89.66 186.49,91.21 190.14,94.85 190.14,96.92 190.45,97.23 190.45,106.35 186.72,110.08 184.61,110.08 183.77,110.91 182.85,110.91 182.32,111.45 180.23,111.45 179.29,110.51 176.17,110.51 175.61,109.95 175.06,109.95 174.88,110.13 174.63,110.13 174.5,110 174.5,109.85 v3(174.6,109.75)
  BOTTOM w0.102: v3(174.6,109.75) 174.6,109.75 174.71,109.85 174.71,110.08 174.58,110.2 174.37,110.2 173.61,109.44 172.28,109.44 171.86,109.02 171.62,109.02 U24.A34
  BOTTOM w0.127: CN17.17 184,13.34 184.05,13.29 184.05,13.15 184.12,13.08 185.47,13.08 185.89,13.5 185.89,15.34 186.63,16.07 186.63,16.77 186.52,16.88 186.29,16.88 v3(186.17,16.76)
USBP4+: length 126.5
  IN2 w0.133: v3(172.04,108.65) 172.23,108.65 172.34,108.76 172.34,111.56 173.59,112.81 173.59,113.21 174.01,113.63 174.01,114.47 171.94,116.55 171.94,117.04 171.07,117.9 171.07,120.26 171.84,121.02 171.84,128.21 167.16,132.89 167.16,138.8 160.46,145.51 160.46,152.65 159.19,153.92 159.19,160.09 155.34,163.93 155.34,167.74 152.89,170.19 152.89,171.62 149.23,175.27 149.23,176.37 144.95,180.65 127.98,180.65 126.43,182.2 126.43,184.21 125.47,185.17 124.15,186.49 117.61,186.49 117.24,186.12 117.24,185.66 119.08,183.82 119.08,182.92 118.8,182.64 118.04,182.64 117.93,182.54 v3(117.93,182.36)
  BOTTOM w0.079: U24.D33 170.62,108.51 170.94,108.83 171.18,108.83 171.45,108.57 171.96,108.57 v3(172.04,108.65)
  BOTTOM w0.127: R382.1 116.75,182.19 116.83,182.27 117.07,182.27 117.41,182.61 117.68,182.61 v3(117.93,182.36)
USBP4+_R: length 5.7
  BOTTOM w0.127: CN2.14 111.8,184.08 111.89,184.18 112.72,184.18 113.85,183.05 v2(113.85,182.61) 114.77,182.61 115.11,182.27 115.51,182.27 R382.2
USBP4-: length 126.5
  IN2 w0.133: v3(117.93,183.13) 118.16,182.9 118.7,182.9 118.83,183.03 118.83,183.72 116.99,185.55 116.99,186.22 117.51,186.74 124.26,186.74 126.08,184.91 126.69,184.31 126.69,182.3 128.09,180.9 145.05,180.9 149.48,176.47 149.48,175.38 153.14,171.72 153.14,170.3 155.6,167.84 155.6,164.04 159.44,160.19 159.44,154.02 160.71,152.75 160.71,145.61 167.42,138.91 167.42,132.99 172.09,128.32 172.09,120.92 171.33,120.15 171.33,118.01 172.19,117.14 172.19,116.66 174.27,114.58 174.27,113.53 173.84,113.1 173.84,112.7 172.6,111.46 172.6,108.83 v3(172.8,108.62)
  BOTTOM w0.079: v3(172.8,108.62) 172.57,108.62 172.2,108.25 171.87,108.25 171.72,108.4 171.2,108.4 U24.B33
  BOTTOM w0.127: R381.1 116.75,183.2 116.83,183.12 117.16,183.12 117.42,182.85 117.66,182.85 v3(117.93,183.13)
USBP4-_R: length 5.7
  BOTTOM w0.127: R381.2 115.51,183.12 115.16,183.12 114.91,182.87 114.36,182.87 113.9,183.34 v2(113.9,183.91) 113.32,183.91 112.82,184.42 111.94,184.42 111.77,184.58 CN2.13
USBP5+: length 89.2
  IN2 w0.133: v3(175.71,56.27) 175.97,56.53 175.97,58.88 174.42,60.42 174.42,65.68 175.67,66.92 175.67,67.55 175.95,67.83 175.95,69.67 176.38,70.1 176.38,70.58 175.41,71.55 175.41,76.11 175.77,76.48 175.77,79.96 176.27,80.45 176.27,82.71 176.27,83.04 177.32,84.09 177.32,85.77 177.38,85.82 177.38,86.64 178.64,87.91 179.25,87.91 180.16,88.82 181.06,88.82 183.85,91.61 183.85,93.41 185.43,94.98 185.43,96.01 187.28,97.86 187.28,100.65 187.48,100.86 187.48,106.01 185.78,107.71 176.66,107.71 176.43,107.49 175.69,107.49 174.55,106.34 173.19,106.34 172.52,105.66 170.53,105.66 170.3,105.43 169.55,105.43 168.61,106.36 168.61,107.52 168.87,107.78 168.87,107.92 v3(168.67,108.12)
  BOTTOM w0.102: U24.G31 168.99,107.9 168.76,108.12 v3(168.67,108.12)
  BOTTOM w0.127: CN10.38 170.3,58.24 170.52,58.02 170.52,57.58 171.09,57.02 175.69,57.02 175.96,56.75 175.96,56.52 v3(175.71,56.27)
USBP5-: length 89.1
  IN2 w0.133: v3(176.47,56.27) 176.22,56.52 176.22,58.98 174.68,60.52 174.68,65.57 175.92,66.82 175.92,67.45 176.2,67.73 176.2,69.56 176.64,70 176.64,70.68 175.66,71.66 175.66,76 176.03,76.37 176.03,79.85 176.52,80.35 176.52,82.61 176.52,82.61 176.52,82.93 177.58,83.99 177.58,85.66 177.63,85.72 177.63,86.54 178.75,87.66 179.36,87.66 180.26,88.56 181.16,88.56 184.11,91.51 184.11,93.3 185.68,94.88 185.68,95.9 187.53,97.75 187.53,100.55 187.74,100.75 187.74,106.11 185.88,107.97 176.56,107.97 176.33,107.74 175.59,107.74 174.45,106.6 173.09,106.6 172.41,105.92 170.43,105.92 170.19,105.68 169.65,105.68 168.87,106.46 168.87,107.41 169.13,107.67 169.13,107.94 v3(169.32,108.13)
  BOTTOM w0.102: v3(169.32,108.13) 169.58,107.87 U24.F31
  BOTTOM w0.127: CN10.36 171.1,58.32 170.77,57.98 170.77,57.68 171.19,57.26 175.79,57.26 176.2,56.85 176.2,56.54 v3(176.47,56.27)
USBP8+: length 281.1
  IN2 w0.133: v3(174.62,108.66) 174.7,108.66 175.05,109.02 175.79,109.02 176.05,109.29 179.16,109.29 180.55,110.68 182.01,110.68 183.39,109.29 186.41,109.29 189.47,106.23 189.47,98.16 189,97.69 189,94.99 185.72,91.71 185.72,91.21 179.48,84.97 179.48,84.02 177.81,82.35 177.81,79.63 177.32,79.14 177.32,75.18 177.85,74.64 177.85,71.5 179.39,69.96 179.39,63.21 182.88,59.71 182.88,56.27 184.43,54.72 184.43,52.29 185.86,50.86 185.86,48.99 187.41,47.43 188.12,47.43 189.58,45.97 189.58,43.65 190.99,42.24 190.99,29.26 186.09,24.36 186.09,21.77 182.5,18.18 182.5,17.16 181.39,16.04 168.63,16.04 167.32,14.74 139.21,14.74 134.78,19.17 69.88,19.17 67.99,17.28 52.93,17.28 v3(52.71,17.5)
  BOTTOM w0.102: U24.C32 170.7,108.02 171.17,108.02 171.39,107.8 172.75,107.8 172.94,107.61 173.82,107.61 174.43,108.22 174.43,108.47 v3(174.62,108.66)
  BOTTOM w0.127: R711.1 37.66,12.52 37.71,12.47 38.3,12.47 38.61,12.78 39.02,12.78 41.15,10.64 43.13,10.64 47.75,15.26 52.78,15.26 53.57,16.06 53.57,16.96 53.34,17.19 53.01,17.19 v3(52.71,17.5)
USBP8+_R: length 4.1
  BOTTOM w0.127: U32.3 33.61,12.94 33.66,13 34.04,13 v3(34.68,12.35) 35.16,12.83 35.31,12.83 35.67,12.47 36.42,12.47 R711.2
USBP8-: length 281.1
  IN2 w0.133: v4(52.71,16.74) 52.71,16.92 52.82,17.03 68.09,17.03 69.98,18.92 134.67,18.92 139.1,14.48 167.43,14.48 168.73,15.79 181.49,15.79 182.75,17.05 182.75,18.08 186.34,21.67 186.34,24.25 191.24,29.15 191.24,42.35 189.83,43.76 189.83,46.07 188.22,47.68 187.52,47.68 186.11,49.09 186.11,50.96 184.68,52.39 184.68,54.83 183.14,56.37 183.14,59.82 179.64,63.31 179.64,70.07 178.11,71.6 178.11,74.75 177.57,75.28 177.57,79.03 178.06,79.52 178.06,82.24 179.73,83.91 179.73,84.86 185.98,91.11 185.98,91.6 189.26,94.88 189.26,97.58 189.73,98.05 189.73,106.34 186.52,109.54 183.5,109.54 182.11,110.93 180.44,110.93 179.06,109.54 175.95,109.54 175.68,109.28 174.95,109.28 174.82,109.15 174.34,109.15 173.86,108.66 v3(173.86,108.66)
  BOTTOM w0.102: U24.A32 171.62,108.01 172.84,108.01 173.03,107.82 173.74,107.82 174.22,108.3 174.22,108.59 174.15,108.66 v3(173.86,108.66)
  BOTTOM w0.127: v4(52.71,16.74) 52.93,16.95 53.24,16.95 53.33,16.86 53.33,16.16 52.68,15.51 47.65,15.51 43.03,10.89 41.25,10.89 39.12,13.02 38.61,13.02 38.3,13.32 37.71,13.32 37.5,13.53 R710.1
USBP8-_R: length 4.1
  BOTTOM w0.127: U32.2 33.61,13.44 33.82,13.24 34.3,13.24 v3(34.68,13.62) 35.23,13.07 35.31,13.07 35.56,13.32 36.26,13.32 R710.2
USBP9+: length 164.6
  IN2 w0.133: v3(146.11,16.57) 146.48,16.21 146.65,16.21 146.79,16.35 146.79,17.04 146.51,17.32 146.51,18.26 149.89,21.63 153.06,21.63 155.5,19.2 180.71,19.2 184.21,22.7 184.21,23.57 190.17,29.53 190.17,41.93 188.57,43.53 188.57,44.87 185.06,48.38 185.06,50.31 182.96,52.42 182.96,55.03 182.07,55.92 182.07,59.44 178.62,62.89 178.62,69.64 176.31,71.95 176.31,75.79 176.54,76.03 176.54,79.51 177.04,80 177.04,82.72 178.11,83.79 178.11,85.52 180.49,87.91 181.23,87.91 184.86,91.53 184.86,91.93 188.07,95.14 188.07,100.33 188.27,100.53 188.27,106.31 186.08,108.5 181.89,108.5 181.17,109.22 180.18,109.22 179.46,108.5 176.36,108.5 176.11,108.25 175.37,108.25 174.66,107.54 172.87,107.54 172.82,107.48 v3(172.82,107.19)
  BOTTOM w0.102: v3(172.82,107.19) 172.41,107.6 171.39,107.6 171.08,107.3 U24.C30
  BOTTOM w0.127: CN16.4 144.68,17.06 144.56,16.93 144.56,16.73 144.97,16.31 145.85,16.31 v3(146.11,16.57)
USBP9-: length 164.6
  IN2 w0.133: v3(172.06,107.19) 172.66,107.79 174.55,107.79 175.27,108.51 176,108.51 176.25,108.76 179.35,108.76 180.08,109.48 181.28,109.48 182,108.76 186.19,108.76 188.52,106.42 188.52,100.42 188.32,100.22 188.32,95.03 185.11,91.82 185.11,91.42 181.34,87.65 180.59,87.65 178.36,85.42 178.36,83.68 177.29,82.61 177.29,79.9 176.8,79.4 176.8,75.93 176.56,75.69 176.56,72.06 178.87,69.75 178.87,63 182.32,59.54 182.32,56.03 183.21,55.14 183.21,52.52 185.32,50.42 185.32,48.49 188.83,44.98 188.83,43.64 190.43,42.04 190.43,29.43 184.46,23.46 184.46,22.6 180.81,18.94 155.4,18.94 152.96,21.38 150,21.38 146.77,18.15 146.77,17.42 147.04,17.14 147.04,16.25 146.75,15.95 146.25,15.95 v3(146.11,15.81)
  BOTTOM w0.102: v3(172.06,107.19) 171.85,107.4 171.62,107.4 U24.A30
  BOTTOM w0.127: v3(146.11,15.81) 145.85,16.07 144.87,16.07 144.31,16.63 144.31,16.91 144.18,17.04 CN16.5
USBP10+: length 121.7
  IN2 w0.133: v3(119.12,185.9) 118.91,185.69 118.91,185.5 119.15,185.26 120.35,185.26 121.06,185.97 123.91,185.97 125.92,183.96 125.92,181.98 127.77,180.13 144.73,180.13 147.02,177.84 148.65,176.22 148.65,175.1 152.28,171.47 152.28,169.97 153.93,168.32 153.93,164.56 158.65,159.84 158.65,145.28 166.6,137.33 166.6,132.72 170.64,128.68 170.64,123.24 171.3,122.58 171.3,121.33 169.96,119.98 169.96,117.04 171.66,115.33 171.66,111.38 171.5,111.22 171.5,107.61 170.55,106.66 170.37,106.66 v3(169.9,106.19)
  BOTTOM w0.079: v3(169.9,106.19) 170.18,106.47 U24.D29
  BOTTOM w0.127: v3(119.12,185.9) 118.9,185.68 118.9,185.23 118.54,184.86 117.73,184.86 117.43,184.56 116.83,184.56 116.75,184.47 R380.1
USBP10+_R: length 5.8
  BOTTOM w0.127: R380.2 115.51,184.56 115.11,184.56 114.8,184.87 114.33,184.87 113.45,185.74 113.22,185.74 113.06,185.58 v2(113.06,185.17) 112.57,185.66 111.73,185.66 111.65,185.58 CN2.11
USBP10-: length 121.7
  IN2 w0.133: v3(118.35,185.9) 118.53,185.9 118.66,185.77 118.66,185.4 119.05,185.01 120.46,185.01 121.17,185.72 123.8,185.72 125.66,183.85 125.66,181.88 127.66,179.88 144.63,179.88 146.77,177.74 148.39,176.11 148.39,175 152.02,171.36 152.02,169.86 153.67,168.21 153.67,164.45 158.4,159.73 158.4,145.18 166.35,137.23 166.35,132.61 170.39,128.57 170.39,123.14 171.05,122.48 171.05,121.43 169.7,120.09 169.7,116.93 171.41,115.23 171.41,111.49 171.25,111.32 171.25,107.71 170.45,106.91 170.14,106.91 169.98,107.08 v3(169.98,107.37)
  BOTTOM w0.079: U24.B29 170.57,106.91 170.12,107.37 v3(169.98,107.37)
  BOTTOM w0.127: R379.1 116.75,185.49 116.83,185.41 117.43,185.41 117.73,185.1 118.44,185.1 118.66,185.33 118.66,185.77 118.53,185.9 v3(118.35,185.9)
USBP10-_R: length 5.8
  BOTTOM w0.127: CN2.10 111.65,186.08 111.84,185.9 112.49,185.9 v2(113.06,186.46) 113.06,186.1 113.18,185.98 113.55,185.98 114.43,185.11 114.84,185.11 115.14,185.41 115.51,185.41 R379.2
USBPWR1:
  vias: v2(18.67,41.09) v3(15.63,44.67) v3(15.65,43.99) v3(16.46,44.67) v3(16.51,43.96) v3(16.59,43.2) v3(16.92,39.95) v3(20.09,44.47) v3(20.1,43.78) v3(20.1,43.07) v3(20.07,42.41) v3(21.09,45.64)
V_BLIGHT:
  vias: v2(112.35,169.72)
VA1:
  vias: v2(187.68,177.72)
VA2: length 1.3
  TOP w0.127: v3(188.02,188.82) 187.89,188.69 187.89,187.6
VGA_ALERT#: length 15.9
  BOTTOM w0.127: R433.1 v2(162.16,157.98) 160.56,157.98 157.28,161.26 155.5,161.26 155.37,161.38 155.37,161.97 155.27,162.07 153.95,162.07 153.8,162.22 153.8,163.43 153.48,163.75 152.35,163.75 152.08,164.02 152.08,164.02 152.05,164.05 152.05,164.61 U19.F8
VGA_OVT#: length 19.2
  TOP w0.127: v3(160.18,177.89) 159.62,177.34 Q1.1
  BOTTOM w0.127: U19.A6 153.72,169.04 156.02,171.34 159.11,171.34 160.66,172.89 R399.1 160.17,175.33 160.17,175.86 161.13,176.82 161.13,178.03 v2(160.91,178.25) 160.53,178.25 v3(160.18,177.89)
VGA_VCCSENSE: length 40.7
  IN2 w0.254: v3(159.54,163.55) 159.58,163.51 159.75,163.51 159.86,163.39 160.7,163.39 161.15,162.93 161.15,160.04 163.16,158.03 165.36,158.03 166.37,157.02 166.37,153.36 172.09,147.64 172.09,143.66 175.19,140.56 175.19,139.53 176.48,138.24 176.48,136.82 176.28,136.62 175.9,136.62 v3(175.8,136.72)
  BOTTOM w0.127: U19.F2 156.82,164.94 157.23,164.53 158.04,164.53 158.36,164.21 158.77,163.8 159.29,163.8 v3(159.54,163.55)
  BOTTOM w0.254: PR186.1 v3(175.8,136.72)
VGA_VSSSENSE: length 41.8
  IN2 w0.254: v3(175.77,135.83) 176.05,136.11 176.49,136.11 176.99,136.61 176.99,138.45 175.7,139.74 175.7,140.77 172.6,143.87 172.6,147.85 166.88,153.57 166.88,157.23 165.57,158.54 163.37,158.54 161.66,160.25 161.66,163.14 160.91,163.9 160.07,163.9 159.7,164.27 v3(159.56,164.27)
  BOTTOM w0.127: U19.F1 157.54,164.79 158.12,164.79 158.87,164.04 159.36,164.04 159.56,164.24 v3(159.56,164.27)
  BOTTOM w0.254: PR187.1 176.29,135.83 v3(175.77,135.83)
VGPU_EN: length 109.8
  TOP w0.127: R179.1 155.88,92.61 156.62,93.35 156.62,94.96 156.8,95.15 156.8,96.49 157.5,97.19 v3(157.5,97.25) ; v3(144.61,127.2) 144.61,127.22 v2(145.95,128.57) 146.64,129.25 165.13,129.25 165.79,129.91 170.45,129.91 170.46,129.91 171.3,129.91 171.3,129.91 173.36,129.91 181.16,137.71 188.85,137.71 189.77,138.63 PR121.1
  IN1 w0.133: v3(157.5,97.25) 155.69,95.45 153.1,95.45 152.46,96.08 147.37,96.08 146.7,95.42 143.79,95.42 141.15,98.05 141.15,100.45 138.02,103.58 138.02,108.75 140.64,111.37 140.64,124.25 141.15,124.76 142.55,124.76 144.23,126.43 144.23,126.82 v3(144.61,127.2)
  BOTTOM w0.102: U24.AN6 157.82,97.24 157.51,97.24 v3(157.5,97.25)
VL: length 106.8
  TOP w0.203: PC32.2 44.76,60.22 44.4,59.86 PU3.13
  TOP w0.508: v3(59.95,104.29) 59.95,106.7 v2(58.3,108.35) 57.97,108.35 56.7,109.62 56.7,110.27 56.39,110.57 PR153.1 PR154.1 ; PC32.2 46.61,59.45 47.1,59.45 47.63,58.92 47.63,57.19 46.54,56.1 44.23,56.1 43.24,55.11 41.94,55.11 40.7,53.87 39.4,53.87 v3(36.5,50.97)
  IN1 w0.508: v3(59.95,104.29) 59.95,103.96 58.39,102.39 41.78,102.39 39.6,100.21 38.61,100.21 37.87,99.47 37.87,95.67 36.28,94.07 36.28,87.14 38.43,84.98 38.43,81.23 37.49,80.29 37.49,71.9 36.67,71.08 36.67,63.33 35.16,61.82 35.16,57.29 36.5,55.95 v3(36.5,50.97)
VMA_CLK0: length 58.8
  TOP w0.127: v3(121.08,169.75) 121.3,169.53 121.48,169.53 121.84,169.16 121.84,168.92 122.2,168.56 122.2,167.84 122.38,167.66 122.46,167.66 VRAM1.J7
  IN2 w0.133: v3(115.15,167.97) 115.39,167.73 117.56,167.73 118.09,168.27 119.32,168.27 119.74,168.68 120.14,168.68 120.62,169.16 120.62,169.28 120.66,169.33 120.66,169.34 v3(121.08,169.75) 121.22,169.61 121.58,169.61 121.89,169.3 121.89,168.76 122.69,167.96 122.69,167.32 122.94,167.07 125.72,167.07 126.81,168.16 128.33,168.16 128.71,168.54 128.71,169.58 128.51,169.78 127.42,169.78 127.13,170.07 127.13,170.48 127.42,170.77 128.57,170.77 128.71,170.91 128.71,171.11 128.57,171.25 127.41,171.25 127.13,171.53 127.13,171.92 127.41,172.19 133.65,172.19 133.93,171.91 133.93,170.53 134.09,170.37 134.31,170.37 134.46,170.53 134.46,171.88 134.77,172.19 135.21,172.19 135.52,171.88 135.52,170.33 136.5,169.35 137.34,169.35 137.56,169.58 137.56,170.16 137.84,170.44 138.23,170.44 138.51,170.16 138.51,169.33 139.26,168.58 140.55,168.58 140.82,168.31 140.82,167.93 140.55,167.67 138.87,167.67 138.16,168.37 137.88,168.37 137.55,168.03 137.55,167.62 137.73,167.44 137.73,167.31 v3(137.99,167.04)
  BOTTOM w0.127: VRAM3.J7 119.55,167.83 119.66,167.71 119.79,167.71 120.06,167.98 120.06,168.15 119.94,168.27 119.94,168.54 120.19,168.79 120.41,168.79 120.53,168.91 120.53,169.21 v3(121.08,169.75) ; R409.2 114.76,167.67 114.85,167.67 v3(115.15,167.97) ; U19.D24 v3(137.99,167.04)
VMA_CLK0#: length 58.6
  TOP w0.127: v3(121.08,169.09) 121.3,169.31 121.39,169.31 121.63,169.07 121.63,168.83 121.99,168.47 121.99,167.75 122.29,167.44 122.45,167.44 VRAM1.K7
  IN2 w0.133: v3(137.19,167.04) 137.36,167.04 137.5,167.18 137.5,167.35 137.32,167.53 137.32,168.13 137.79,168.6 138.26,168.6 138.96,167.89 140.45,167.89 140.59,168.03 140.59,168.22 140.45,168.35 139.17,168.35 138.28,169.23 138.28,170.06 138.14,170.21 137.94,170.21 137.79,170.06 137.79,169.48 137.44,169.13 136.4,169.13 135.3,170.23 135.3,171.79 135.12,171.96 134.87,171.96 134.69,171.79 134.69,170.43 134.4,170.14 133.99,170.14 133.7,170.43 133.7,171.82 133.56,171.96 127.5,171.96 127.36,171.82 127.36,171.62 127.5,171.48 128.66,171.48 128.94,171.21 128.94,170.82 128.66,170.54 127.52,170.54 127.36,170.39 127.36,170.17 127.52,170.01 128.6,170.01 128.94,169.67 128.94,168.45 128.42,167.93 126.91,167.93 125.81,166.84 122.84,166.84 122.46,167.22 122.46,167.87 121.66,168.67 121.66,169.21 121.49,169.38 121.37,169.38 v3(121.08,169.09) 120.86,169.09 120.23,168.46 119.83,168.46 119.42,168.04 118.19,168.04 117.65,167.51 115.44,167.51 v3(115.13,167.19)
  BOTTOM w0.127: v3(137.19,167.04) 137.19,166.64 137.32,166.51 137.46,166.51 U19.D25 ; VRAM3.K7 119.55,167.42 119.62,167.49 119.88,167.49 120.27,167.89 120.27,168.24 120.16,168.36 120.16,168.45 120.28,168.57 120.5,168.57 120.75,168.82 120.75,169.06 120.88,169.18 120.98,169.18 v3(121.08,169.09) ; v3(115.13,167.19) 114.87,167.46 114.72,167.46 R409.1
VMA_CLK1: length 65
  TOP w0.127: v3(121.05,146.76) 121.05,146.79 119.97,147.87 119.97,148.15 120.16,148.34 120.16,148.49 119.91,148.74 119.64,148.74 119.55,148.64 VRAM2.J7 ; v3(115.21,147.89) 114.94,148.16 114.46,148.16 R43.2
  IN2 w0.133: v3(115.21,147.89) 115.5,148.18 116.05,148.18 116.82,148.94 117.7,148.94 118.21,149.45 119.24,149.45 119.76,148.92 119.76,148.11 120.55,147.32 120.55,147.26 v3(121.05,146.76) 121.3,147 121.46,147 124.59,150.13 124.59,150.95 125.18,151.53 125.58,151.53 128.58,154.53 128.58,155.02 128.06,155.54 128.06,155.76 128.22,155.92 128.44,155.92 129.02,155.34 129.39,155.34 129.72,155.66 129.72,156.04 129.14,156.62 129.14,156.84 129.29,157 129.51,157 130.09,156.42 130.47,156.42 130.79,156.74 130.79,157.12 130.22,157.7 130.22,157.92 130.37,158.08 130.59,158.08 131.17,157.5 131.55,157.5 131.87,157.82 131.87,158.2 131.29,158.78 131.29,159 131.45,159.15 131.67,159.15 132.25,158.58 132.63,158.58 132.95,158.9 132.95,159.28 131.61,160.62 131.61,162.75 131.77,162.91 132,162.91 132.16,162.75 132.16,160.82 133.61,159.37 134.08,159.37 134.4,159.7 134.4,160.16 133.19,161.37 133.19,162.72 133.35,162.88 133.58,162.88 133.74,162.72 133.74,161.67 136,159.4 138.79,159.4 139.34,158.84 139.9,158.84 140.08,159.02 140.21,159.02 v3(140.44,158.79)
  BOTTOM w0.127: v3(121.05,146.76) 121.25,146.96 121.72,146.96 121.94,147.17 121.94,147.43 122.33,147.82 122.33,148.53 122.49,148.68 122.64,148.68 122.75,148.57 VRAM4.J7 ; U19.N22 140.05,159.18 v3(140.44,158.79)
VMA_CLK1#: length 64.8
  TOP w0.127: v3(115.21,148.67) 114.93,148.38 114.48,148.38 R43.1 ; v3(121.05,147.42) 121.05,147.35 120.94,147.23 120.91,147.23 120.18,147.96 120.18,148.06 120.37,148.25 120.37,148.58 120,148.95 119.65,148.95 119.55,149.06 VRAM2.K7
  IN2 w0.133: v3(140.43,159.58) 140.1,159.25 139.98,159.25 139.8,159.07 139.44,159.07 138.88,159.63 136.1,159.63 133.96,161.77 133.96,162.82 133.67,163.11 133.26,163.11 132.96,162.82 132.96,161.28 134.17,160.06 134.17,159.79 133.98,159.6 133.71,159.6 132.39,160.92 132.39,162.84 132.09,163.14 131.68,163.14 131.38,162.84 131.38,160.52 132.72,159.18 132.72,158.99 132.53,158.8 132.35,158.8 131.77,159.38 131.36,159.38 131.07,159.09 131.07,158.68 131.64,158.1 131.64,157.91 131.46,157.73 131.27,157.73 130.69,158.3 130.28,158.3 129.99,158.01 129.99,157.6 130.57,157.03 130.57,156.84 130.38,156.65 130.19,156.65 129.61,157.23 129.2,157.23 128.91,156.94 128.91,156.53 129.49,155.95 129.49,155.76 129.3,155.57 129.11,155.57 128.53,156.15 128.12,156.15 127.83,155.86 127.83,155.45 128.35,154.93 128.35,154.62 125.49,151.76 125.08,151.76 124.36,151.04 124.36,150.23 121.36,147.23 121.24,147.23 v3(121.05,147.42) 120.77,147.42 119.99,148.2 119.99,149.01 119.33,149.68 118.12,149.68 117.61,149.17 116.72,149.17 115.96,148.41 115.48,148.41 v3(115.21,148.67)
  BOTTOM w0.127: v3(140.43,159.58) 140.03,159.98 U19.M22 ; VRAM4.K7 122.11,148.62 122.11,147.91 121.72,147.52 121.72,147.26 121.63,147.17 121.3,147.17 v3(121.05,147.42)
VMA_DM0: length 37.8
  TOP w0.152: VRAM1.D3 119.78,172.17 120.87,172.17 121.04,172.33 121.04,172.56 120.87,172.73 120.2,172.73 120.04,172.89 120.04,173.11 120.2,173.27 120.55,173.27 120.77,173.49 120.77,174.93 122.46,176.62 139.81,176.62 143.75,172.68 143.75,171.18 143.07,170.5 v3(143.07,170.49) 143.07,167.9 142.22,167.06 v3(142.16,167.06)
  BOTTOM w0.152: U19.D19 v3(142.16,167.06)
VMA_DM1: length 46.5
  TOP w0.152: VRAM1.E7 122.75,171.24 v3(122.19,171.79)
  IN1 w0.102: v3(146.27,166.24) 145.86,166.65 145.21,166.65
  IN1 w0.165: 145.21,166.65 144.93,166.92 144.93,168.01 145.34,168.42 145.34,169.64 146.58,170.88 146.58,171.15 146.39,171.34 146.13,171.34 144.75,169.96 144.11,169.96 140.02,174.05 137.13,174.05 136.83,173.75 128.34,173.75 127.08,172.5 126.84,172.5 126.66,172.68 126.66,172.93 127.33,173.6 127.33,173.87 127.15,174.05 126.88,174.05 126.01,173.17 125.73,173.17 125.54,173.37 125.54,173.64 126.14,174.25 126.14,174.52 125.95,174.71 125.68,174.71 125.18,174.22 124.91,174.22 124.72,174.41 124.72,174.69 125.22,175.19 125.22,175.44 125.04,175.62 124.78,175.62 124.59,175.43 124.26,175.43 123.91,175.79 122.79,175.79 121.84,174.84 121.84,172.15 v3(122.19,171.79)
  BOTTOM w0.152: v3(146.27,166.24) 146.67,166.64 U19.D14
VMA_DM2: length 42.3
  BOTTOM w0.152: VRAM3.D3 122.75,172.25 122.54,172.45 122.32,172.45 122.08,172.22 121.93,172.22 121.81,172.34 121.81,172.52 122.13,172.84 122.13,172.97 121.59,173.5 121.59,174.26 123.35,176.01 125.99,176.01 125.99,176.02 128.53,176.02 128.84,176.32 128.84,177.49 129.02,177.68 129.29,177.68 129.47,177.49 129.47,176.2 129.65,176.02 129.9,176.02 130.08,176.2 130.08,177.41 130.34,177.68 v3(137.51,177.68) 137.66,177.68 142.96,172.38 142.96,171.37 143.36,170.96 143.36,170.63 143.57,170.43 144,170.43 144.12,170.31 144.12,170.14 144,170.02 143.56,170.02 143.44,169.9 143.44,169.73 143.56,169.61 144.2,169.61 144.3,169.51 144.3,169.36 144.2,169.26 143.87,169.26 143.74,169.13 143.74,167.22 143.9,167.07 144.5,167.07 144.63,167.2 144.63,167.78 144.53,167.89 144.3,167.89 144.21,167.79 U19.C17
VMA_DM3: length 41.7
  IN2 w0.165: v3(120.85,171.74) 120.75,171.65 120.57,171.65 120.4,171.81 120.4,172.05 119.75,172.7 119.75,172.87 119.9,173.01 120.41,173.01 120.57,172.85 120.57,172.55 120.73,172.38 120.96,172.38 121.08,172.5 121.08,174.33 122.73,175.98 123.42,175.98 123.58,176.14 123.58,176.57 123.72,176.72 136.05,176.72 140.21,172.56 140.21,171.19 139.73,170.71 139.73,170.43 139.97,170.19 139.97,169.79 140.42,169.34 140.42,169.08 140.31,168.98 139.6,168.98 139.45,169.13 139.45,169.95 139.17,170.22 v3(139.02,170.22)
  BOTTOM w0.152: U19.C22 139.77,167.44 139.5,167.71 139.5,167.89 139.72,168.11 139.72,168.43 139.4,168.75 139.4,169.49 139.55,169.64 139.55,170.35 139.44,170.47 139.17,170.47 139.02,170.31 v3(139.02,170.22) ; VRAM3.E7 119.78,171.14 119.9,171.03 119.9,170.4 120.05,170.26 120.25,170.26 120.39,170.4 120.39,171.43 120.7,171.74 v3(120.85,171.74)
VMA_DM4: length 37.8
  TOP w0.152: v3(138.79,157.92) 138.79,158.16 138.6,158.35 137.4,158.35 137.38,158.33 137.01,158.33 135.44,156.76 135.28,156.76 134.9,157.14 134.73,157.14 134.52,156.93 134.52,156.52 134.33,156.32 134.06,156.32 133.86,156.52 133.86,156.74 133.67,156.93 133.4,156.93 133.2,156.74 133.2,155.8 131.92,154.51 131.92,151.72 132.07,151.57 132.44,151.57 132.6,151.41 132.6,151.18 132.44,151.02 132.03,151.02 131.92,150.91 v3(131.92,146.8) 131.92,146.03 125.93,140.04 122.6,140.04 121.45,141.2 121.45,142.86 122.75,144.16 VRAM2.D3
  BOTTOM w0.127: v3(138.79,157.92) 138.39,158.32 U19.P24
VMA_DM5: length 36
  TOP w0.152: VRAM2.E7 119.9,144.89 119.9,144.63 120.16,144.37 121.19,144.37 v3(121.71,143.86)
  IN1 w0.165: v3(137.99,153.8) 137.99,153.69 136.92,152.62 136.2,152.62 136.05,152.47 136.05,152.16 136.63,151.58 136.63,151.32 136.45,151.13 136.19,151.13 135.5,151.82 135.25,151.82 135.07,151.64 135.07,151.39 135.65,150.81 135.65,150.42 128.88,143.65 128.88,143.42 129.25,143.05 129.25,142.78 129.05,142.58 128.78,142.58 128.41,142.95 128.18,142.95 127.95,142.72 127.95,142.48 128.31,142.12 128.31,141.84 128.12,141.65 127.85,141.65 127.48,142.02 127.25,142.02 126.43,141.2 123.57,141.2 122.94,141.83 122.3,141.83 122.1,142.02 122.1,142.29 122.3,142.49 122.81,142.49 123.02,142.69 123.02,143.58 122.84,143.76 122.53,143.76 122.38,143.6 122.38,143.27 122.18,143.07 121.9,143.07 121.71,143.27 v3(121.71,143.86)
  BOTTOM w0.152: U19.W24 138.39,154.2 v3(137.99,153.8)
VMA_DM6: length 33.6
  BOTTOM w0.127: U19.AA25 137.29,152.54 137.19,152.44 137.19,151.5 136.99,151.3 136.61,151.3 136.42,151.11 134.94,151.11 134.73,150.89
  BOTTOM w0.152: VRAM4.D3 119.62,144.37 121.23,144.37 121.35,144.26 121.35,144.1 121.23,143.99 120.07,143.99 119.9,143.82 119.9,142.98 120.52,142.37 120.52,141.72 123.39,138.85 v3(124.72,138.85) 128.13,138.85 132.16,142.89 132.16,146.35 133.54,147.73 133.54,149.71 134.62,150.79 134.62,150.79 134.73,150.89
VMA_DM7: length 34.6
  IN2 w0.165: v3(121.7,144.67) 121.7,144.53 121.09,143.91 121.09,143.53 121.9,142.72 121.9,141.93 122.08,141.76 122.33,141.76 122.51,141.93 122.51,143.59 122.7,143.78 122.98,143.78 123.17,143.59 123.17,142.18 123.37,141.97 124.41,141.97 124.66,141.72 125.72,141.72 131.59,147.6 131.59,154.88 133.2,156.5 134.6,156.5 134.73,156.37 137.08,156.37 v3(137.16,156.28)
  BOTTOM w0.127: v3(137.16,156.28) 137.19,156.3 137.19,156.28 137.59,155.88 U19.U25
  BOTTOM w0.152: v3(121.7,144.67) 121.89,144.86 122.35,144.86 VRAM4.E7
VMA_DQ0: length 37.7
  TOP w0.152: VRAM1.A3 119.59,174.39 119.59,175.05 122.08,177.53 140.19,177.53 144.67,173.06 144.67,168.25 143.99,167.58 143.99,167.09 143.23,166.33 143.23,165.98 v3(143.8,165.42)
  BOTTOM w0.127: U19.E18 143.38,165.84 v3(143.8,165.42)
VMA_DQ1: length 39.7
  TOP w0.152: v3(142.95,167.04) v3(143.51,167.61) 143.54,167.64 143.54,169.11 143.72,169.28 144.05,169.28 144.21,169.45 144.21,169.69 144.05,169.85 143.68,169.85 143.53,170 143.53,170.31 143.68,170.46 144.05,170.46 144.21,170.62 144.21,172.87 140,177.08 122.27,177.08 120.02,174.83 120.02,174.28 119.72,173.98 119.23,173.98 119.1,173.85 119.1,172.89 119.25,172.74 VRAM1.C3
  BOTTOM w0.127: v3(142.95,167.04) 142.95,165.43 U19.F18
VMA_DQ2: length 44
  TOP w0.152: VRAM1.C2 118.35,173.14 117.72,173.14 117.06,173.8 117.06,174.16 120.08,177.18 120.43,177.18 121.7,178.45 140.57,178.45 145.65,173.37 v3(145.65,172.43) 145.65,167.91 144.99,167.26 144.99,165.86 v3(145.45,165.4)
  BOTTOM w0.152: v3(145.45,165.4) 145.45,165.43 145.05,165.83 U19.E16
VMA_DQ3: length 39.6
  TOP w0.152: v3(144.61,165.4) 144.46,165.4 144.25,165.6 144.25,166.49 144.5,166.74 144.5,167.43 145.19,168.12 v3(145.19,170.89) 145.19,173.18 140.38,177.99 121.89,177.99 120.55,176.65 120.22,176.65 119.18,175.61 119.18,174.49 119.03,174.34 VRAM1.A2
  BOTTOM w0.152: U19.F17 144.22,165 v3(144.61,165.4)
VMA_DQ4: length 35.9
  TOP w0.152: v3(141.32,166.23) 141.24,166.31 141.24,167.3 140.59,167.94 140.59,168.17 140.73,168.3 141.22,168.3 141.36,168.44 141.36,168.64 141.22,168.78 140.92,168.78 140.77,168.93 140.77,169.15 140.92,169.31 141.15,169.31 141.28,169.44 141.28,169.85 141.81,170.38 141.81,170.81 141.38,171.24 141.38,171.52 141.51,171.65 142.32,171.65 142.5,171.83 142.5,172.08 142.32,172.26 141.55,172.26 141.4,172.41 141.4,173.25 139.29,175.36 128.71,175.36 128.53,175.18 128.53,174.42 128.35,174.24 128.1,174.24 127.92,174.42 127.92,175.16 127.75,175.33 127.51,175.33 127.34,175.16 127.34,174.44 127.14,174.24 125.53,174.24 124.41,175.36 123.45,175.36 123.04,174.95 122.88,174.95 122.69,175.15 122.53,175.15 122.25,174.87 122.25,174.6 122.51,174.34 VRAM1.A7
  BOTTOM w0.152: U19.D20 v3(141.32,166.23)
VMA_DQ5: length 33
  TOP w0.152: v3(140.52,167.04) 140.52,167.29 139.9,167.91 139.9,170.27 140.34,170.7 140.34,171.7 140.49,171.85 140.49,172.87 140.19,173.17 v3(140.19,173.17) 139.58,173.78 138.69,173.78 138.56,173.91 138.56,174.28 138.39,174.45 138.16,174.45 137.99,174.28 137.99,173.93 137.81,173.75 137.56,173.75 137.38,173.93 137.38,174.27 137.2,174.45 136.95,174.45 136.77,174.27 136.77,173.12 136.59,172.94 136.34,172.94 136.16,173.12 136.16,174.27 135.98,174.45 135.73,174.45 135.55,174.27 135.55,173.51 135.36,173.32 126.34,173.32 126.14,173.12 126.14,172.56 125.96,172.38 125.71,172.38 125.53,172.56 125.53,172.91 125.33,173.12 123.27,173.12 123.1,172.95 123.1,172.61 123.31,172.4 123.31,172.26 123.21,172.15 123.06,172.15 122.83,172.39 122.67,172.39 122.57,172.28 122.57,172.13 VRAM1.D7
  BOTTOM w0.152: v3(140.52,167.04) 140.89,166.67 U19.D21
VMA_DQ6: length 37.4
  TOP w0.152: v3(142.14,164.58) 142.14,164.89 142.01,165.02 141.13,165.02 140.06,166.08 140.06,167.39 139.54,167.91 139.54,170.49 139.88,170.83 139.88,171.09 139.73,171.24 139.47,171.24 139.32,171.39 139.32,171.59 139.47,171.74 139.73,171.74 140.03,172.04 140.03,172.67 139.4,173.3 137.44,173.3 137.27,173.12 137.27,172.16 137.01,171.91 136.8,171.91 136.64,172.07 136.64,172.32 136.47,172.48 136.24,172.48 136.07,172.32 136.07,171.5 135.9,171.33 135.67,171.33 135.5,171.5 135.5,172.7 135.33,172.87 135.09,172.87 134.92,172.7 134.92,170.55 134.74,170.37 134.49,170.37 134.31,170.55 134.31,172.66 134.1,172.87 127.18,172.87 126.24,171.92 124.87,171.92 124.41,172.39 123.65,172.39 123.55,172.49 VRAM1.C8
  BOTTOM w0.152: v3(142.14,164.58) 142.14,164.84 141.98,165 U19.F20
VMA_DQ7: length 36.9
  TOP w0.152: VRAM1.B8 123.55,173.78 123.72,173.96 124.6,173.96 124.84,174.19 125.18,174.19 125.59,173.78 128.73,173.78 128.99,174.04 128.99,174.73 129.17,174.91 129.42,174.91 129.6,174.73 129.6,173.96 129.78,173.78 130.03,173.78 130.21,173.96 130.21,174.73 130.39,174.91 130.64,174.91 130.82,174.73 130.82,173.96 130.99,173.78 131.25,173.78 131.43,173.96 131.43,174.73 131.6,174.91 131.86,174.91 132.04,174.73 132.04,173.96 132.21,173.78 132.47,173.78 132.64,173.96 132.64,174.73 132.82,174.91 133.07,174.91 133.24,174.73 133.24,173.96 133.42,173.78 133.67,173.78 133.85,173.96 133.85,174.72 134.03,174.91 134.3,174.91 134.48,174.72 134.48,173.96 134.66,173.78 134.91,173.78 135.09,173.96 135.09,174.73 135.27,174.91 139.1,174.91 140.94,173.06 140.94,171.66 140.79,171.51 140.79,170.68 140.34,170.22 v3(140.34,169.04) 140.34,167.83 140.95,167.22 140.95,167.2 140.95,167.2 140.95,166.66 140.52,166.23 140.52,166.24 v3(140.52,166.24)
  BOTTOM w0.152: v3(140.52,166.24) 140.52,166.24 140.52,166.23 140.89,165.87 U19.E21
VMA_DQ8: length 48.5
  TOP w0.152: VRAM1.F8 123.95,169.94 125.67,169.94 v3(126.25,170.53)
  IN1 w0.102: v3(146.27,165.42) 146.27,165.74 146.18,165.83 145.27,165.83
  IN1 w0.165: 145.27,165.83 144.93,165.83 144.05,166.71 144.05,167.33 143.62,167.76 143.62,169.41 143.43,169.6 143.1,169.6 142.94,169.43 142.94,168.1 142.74,167.9 142.47,167.9 142.27,168.1 142.27,169.74 142.6,170.07 142.6,170.43 141.03,172 140.74,172 140.53,171.79 140.53,171.5 140.92,171.11 140.92,170.86 140.75,170.68 140.49,170.68 139.64,171.52 139.64,171.8 140.29,172.45 140.29,172.73 139.71,173.32 137.48,173.32 136.71,172.55 136.71,172.13 136.28,171.71 135.9,171.71 135.67,171.47 135.67,170.83 135.48,170.64 135.22,170.64 135.03,170.83 135.03,171.51 134.85,171.68 134.6,171.68 134.42,171.51 134.42,170.8 134.26,170.64 134.03,170.64 133.87,170.8 133.87,171.49 133.68,171.68 133.41,171.68 133.21,171.49 133.21,170.84 133.02,170.64 132.75,170.64 132.55,170.84 132.55,171.49 132.36,171.68 132.09,171.68 131.89,171.49 131.89,170.84 131.69,170.64 131.41,170.64 131.21,170.84 131.21,171.52 131.01,171.71 130.74,171.71 130.55,171.52 130.55,170.81 130.38,170.64 130.05,170.64 129.89,170.81 129.89,171.52 129.69,171.71 129.42,171.71 129.23,171.52 129.23,170.81 129.06,170.64 128.73,170.64 128.57,170.81 128.57,171.42 128.37,171.61 128.1,171.61 127.91,171.42 127.91,170.81 127.74,170.64 127.42,170.64 126.88,170.1 126.48,170.1 126.25,170.33 v3(126.25,170.53)
  BOTTOM w0.152: U19.E15 v3(146.27,165.42)
VMA_DQ9: length 48.2
  TOP w0.127: v3(123.13,169.97) 123.08,169.97 122.75,170.3 VRAM1.F7
  IN1 w0.165: v3(123.13,169.97) 123.39,169.71 125.14,169.71 125.78,170.34 125.78,170.85 125.94,171.01 127.28,171.01 127.45,171.18 127.45,171.42 127.28,171.6 125.71,171.6 125.56,171.75 125.56,171.98 125.71,172.13 127.24,172.13 127.42,172.31 127.65,172.31 127.98,171.98 128.25,171.98 128.44,172.18 128.44,172.45 128.12,172.78 128.12,173.01 128.43,173.32 128.9,173.32 129.06,173.16 129.06,172.27 129.26,172.08 129.53,172.08 129.72,172.27 129.72,173.16 129.89,173.32 130.22,173.32 130.38,173.16 130.38,172.27 130.58,172.08 130.85,172.08 131.04,172.27 131.04,173.16 131.21,173.32 131.54,173.32 131.7,173.16 131.7,172.25 131.9,172.05 132.17,172.05 132.36,172.25 132.36,173.19 132.56,173.39 132.83,173.39 133.02,173.19 133.02,172.25 133.22,172.05 133.49,172.05 133.68,172.25 133.68,173.19 133.88,173.39 134.15,173.39 134.34,173.19 134.34,172.25 134.54,172.05 134.81,172.05 135,172.25 135,173.13 135.2,173.32 135.47,173.32 135.66,173.13 135.66,172.27 135.86,172.08 136.13,172.08 136.33,172.27 136.33,173.09 136.55,173.32 136.96,173.32 137.32,173.68 139.86,173.68 144.25,169.3 144.41,169.3 144.69,169.02 144.69,168.42 144.48,168.22 144.48,166.79 145.03,166.24 v3(145.45,166.24)
  BOTTOM w0.152: U19.D15 v3(145.45,166.24)
VMA_DQ10: length 49.5
  TOP w0.152: VRAM1.H8 123.72,168.74 124.15,168.31 124.66,168.31 v3(125.14,167.83)
  IN1 w0.102: 144.35,164.99 145.88,164.99 v3(146.27,164.6)
  IN1 w0.165: v3(125.14,167.83) 125.14,168.51 125.34,168.71 125.54,168.71 125.86,168.39 126.1,168.39 126.27,168.56 126.27,168.96 127.59,170.27 129.04,170.27 129.29,170.02 129.29,169.45 129.48,169.26 129.76,169.26 129.95,169.45 129.95,170.11 130.11,170.27 130.44,170.27 130.61,170.11 130.61,169.12 130.8,168.93 131.08,168.93 131.27,169.12 131.27,170.11 131.44,170.27 131.77,170.27 131.93,170.11 131.93,169.15 132.12,168.95 132.4,168.95 132.59,169.15 132.59,170.11 132.76,170.27 133.09,170.27 133.25,170.11 133.25,169.2 133.44,169 133.72,169 133.91,169.2 133.91,170.11 134.08,170.27 134.41,170.27 134.57,170.11 134.57,169.15 134.77,168.95 135.04,168.95 135.23,169.15 135.23,169.96 135.4,170.12 135.61,170.12 136.01,169.73 136.29,169.73 136.48,169.92 136.48,170.2 136.07,170.6 136.07,170.97 137.15,172.05 138.26,172.05 138.38,171.94 138.71,171.94 139.56,171.09 139.56,170.6 139.75,170.41 140.17,170.41 140.36,170.22 140.36,169.95 140.17,169.75 139.75,169.75 139.56,169.56 139.56,167.68 139.74,167.5 140,167.5 140.19,167.68 140.19,169.09 140.38,169.28 140.64,169.28 140.84,169.09 140.84,167.43 141.15,167.13 141.56,167.13 141.96,167.53 143.13,167.53 143.46,167.2 143.46,166.71 143.26,166.51 143.26,165.21 143.56,164.91 144.01,164.91 144.09,164.99 144.35,164.99
  BOTTOM w0.152: v3(146.27,164.6) 145.87,165 U19.F15
VMA_DQ11: length 51.5
  TOP w0.152: v3(119.19,171.54) 119.55,171.19 VRAM1.E3
  IN1 w0.102: v3(147.94,164.62) 147.54,165.01 146.79,165.01 146.68,165.13 146.68,166.68 146.73,166.73
  IN1 w0.165: v3(119.19,171.54) 119.19,172.11 119.79,172.71 119.79,174.11 120.28,174.61 120.28,175.47 122.1,177.28 125.38,177.28 127.18,175.48 136.43,175.48 136.63,175.68 136.63,176.37 136.82,176.56 137.1,176.56 137.29,176.37 137.29,175.7 137.48,175.51 137.76,175.51 137.95,175.7 137.95,176.37 138.14,176.56 138.42,176.56 138.61,176.37 138.61,175.7 138.8,175.51 139.08,175.51 139.27,175.7 139.27,176.37 139.46,176.56 139.74,176.56 139.93,176.37 139.93,175.65 140.12,175.46 140.4,175.46 140.59,175.65 140.59,176.19 140.77,176.37 141.02,176.37 141.2,176.19 141.2,175.62 141.33,175.48 141.83,175.48 141.97,175.34 144.46,175.34 148.2,171.6 148.2,169.78 146.73,168.31 146.73,166.73
  BOTTOM w0.152: U19.F13 147.91,164.62 v3(147.94,164.62)
