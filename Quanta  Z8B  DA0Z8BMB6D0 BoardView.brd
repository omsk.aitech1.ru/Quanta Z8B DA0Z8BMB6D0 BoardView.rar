# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Nets (continued)
PEG_TX#3: C398.1 U19.AG10
PEG_TX#4: C400.1 U19.AE10
PEG_TX#5: C403.1 U19.AF12
PEG_TX#6: C404.1 U19.AG13
PEG_TX#7: C410.1 U19.AE13
PEGX_RST#: R434.1 R435.2 R436.1 U19.AC7 U21.4
PEX_CLKREQ#: Q10.1 R36.1 R39.1 U19.AC6
PEX_PLLVDD: C84.1 C95.2 C100.1 R45.1 U19.AA14 U19.AA15
PEX_TERMP: R450.2 U19.AF25
PEX_TSTCLK: R449.2 U19.AF22
PEX_TSTCLK#: R449.1 U19.AE22
PLL_ODVR_EN: R155.1 U24.AD11
PLTRST#: R239.1 R549.1 R673.2 R683.2 R698.2 U5.2 U7.19 U13.22 U20.2 U28.4
PLTRST#_TPM: R239.2 R240.1 U11.16
PM_DRAM_PWRGD: R257.2 R265.2 TP123.1 U12.2 U24.H3
PM_DRAM_PWRGD_Q: R255.2 R256.1 R257.1 R258.2 R264.2 U12.4
PM_DRAM_PWRGD_R: R256.2 U27.AC10
PM_EXTTS#0: JDIM1.198 JDIM2.198 R333.2 R334.2 U1.6
PM_EXTTS#0_EC: R2.1 U1.4
PM_SYNC: R500.1 R623.2
PM_SYNC_R: R500.2 U27.AT28
PM_TEST_RST#: R211.1 TP58.1
PM_THRMTRIP#: Q60.1 R459.2 R594.2 R742.1 U27.AM35
PROCHOT_EC: Q53.2 R329.2 U13.17
PWM-VID: PR167.1 U19.E7
PWR_DEBUG: R87.1 R88.1
PWR_DEBUG_R: R88.2 R89.1 R90.2 U27.H27
PWRLED#: R722.1 R726.1 U13.24
R_SPK+: R374.2 U15.45
R_SPK+_1: C564.1 CN19.4 R374.1
R_SPK-: R373.2 U15.44
R_SPK-_1: C565.1 CN19.3 R373.1
REGOUT: L24.1 U7.24
RF_EN: CN10.20 U13.66
RING2: L18.1 Q44.3 U15.17
RING2_R: C371.1 CN15.3 D20.1 L18.2 R283.2
ROM_CS: R15.1 U19.D12
ROM_SCLK: R7.2 R9.1 U19.C12
ROM_SI: R394.1 R400.1 U19.B12
ROM_SO: R386.2 R393.1 U19.A12
RSET: R164.2 U7.31
RSMRST#: R625.1 R639.2 TP143.1 U13.112
RSTZ: C540.2 R698.1 R707.1 R708.1 U32.22
RSVD30: R126.2 U27.G26
RSVD38: TP14.1 U27.W30
RSVD39: TP12.1 U27.W31
RTC_RST#: C211.1 J2.1 R183.2 U24.D9
RTC_X1: C495.2 R554.1 U24.B5 Y4.1
RTC_X2: C497.2 R554.2 U24.B4 Y4.2
S5_ON: PQ18.2 PQ29.2 PQ35.2 PR68.2 R315.1 U13.100
S5D: PC49.2 PQ14.4 PQ17.2 PQ21.3 PR64.2 PR65.2
SATA_IREF: R166.1 U24.BD4
SATA_RCOMP: R161.2 U24.AY5
SATA_RXN0: C496.2 U24.BC8
SATA_RXN0_C: C496.1 CN6.5
SATA_RXN1: TP107.1 U24.BC10
SATA_RXN2: TP116.1 U24.BB9
SATA_RXN4: TP108.1 U24.BD13
SATA_RXN5: C311.2 C312.2 U24.BC14
SATA_RXN5_C: C311.1 CN11.5
SATA_RXN5_CN: C312.1 CN13.5
SATA_RXP0: C494.2 U24.BE8
SATA_RXP0_C: C494.1 CN6.6
SATA_RXP1: TP112.1 U24.BE10
SATA_RXP2: TP115.1 U24.BD9
SATA_RXP4: TP111.1 U24.BB13
SATA_RXP5: C309.2 C310.2 U24.BE14
SATA_RXP5_C: C310.1 CN11.6
SATA_RXP5_CN: C309.1 CN13.6
SATA_TXN0: C498.2 U24.AW8
SATA_TXN0_C: C498.1 CN6.3
SATA_TXN1: TP119.1 U24.AV10
SATA_TXN2: TP42.1 U24.AY13
SATA_TXN4: TP43.1 U24.AV15
SATA_TXN5: C314.2 C315.2 U24.AP15
SATA_TXN5_C: C315.1 CN11.3
SATA_TXN5_CN: C314.1 CN13.3
SATA_TXP0: C499.2 U24.AY8
SATA_TXP0_C: C499.1 CN6.2
SATA_TXP1: TP118.1 U24.AW10
SATA_TXP2: TP44.1 U24.AW13
SATA_TXP4: TP40.1 U24.AW15
SATA_TXP5: C317.2 C320.2 U24.AR15
SATA_TXP5_C: C317.1 CN11.2
SATA_TXP5_CN: C320.1 CN13.2
SB_ACDC: PR18.1 U13.21
SD_CD#_R: CN1.10 R703.2
SD_CDZ: C542.1 R703.1 U32.21
SD_CLK: C556.1 R706.1 U32.14
SD_CLK_R: CN1.5 R706.2
SD_CMD: R700.1 U32.15
SD_CMD_R: CN1.2 R700.2
SD_D0/MS_D6: C561.1 R705.1 U32.13
SD_D1/MS_D7: C562.1 R704.1 TP173.1 U32.12
SD_D2/MS_D5: C553.1 R701.1 U32.17
SD_D3/MS_D4: C555.1 R699.1 U32.16
SD_D4/MS_D0: TP175.1 U32.9
SD_D5/MS_D2: TP170.1 U32.8
SD_D6/MS_D3: TP171.1 U32.7
SD_D7/MS_CLK: TP172.1 U32.6
SD_DATA0_R: CN1.7 R705.2
SD_DATA1_R: CN1.8 R704.2
SD_DATA2_R: CN1.9 R701.2
SD_DATA3_R: CN1.1 R699.2
SD_GPIO0: TP165.1 U32.20
SD_WP/MS_D1: R702.1 TP174.1 U32.10
SD_WP_R: CN1.11 R702.2
SENSEA: R352.1 U15.13
SGPIO: R153.1 R157.1 R162.1
SIO_EXT_SCI#: R551.1 U13.23 U24.G15
SIO_EXT_SMI#: R559.1 U13.15 U24.F13
SKTOCC#: TP16.1 U27.AP32
SLEEVE: L17.1 Q44.6 U15.18
SLEEVE_R: C344.1 CN15.4 D16.1 L17.2 R355.2
SLP_A#: R583.2 TP130.1 U13.98
SLP_S5#: R212.2 TP57.1 U13.99
SLP_SUS#: Q48.2 Q50.2 R588.2 U13.71
SM_INTRUDER#: R158.2 U24.A8
SM_RCOMP_0: R252.1 U27.AP3
SM_RCOMP_1: R253.1 U27.AR3
SM_RCOMP_2: R251.1 U27.AP2
SMB_ME0_CLK: R186.2 U24.U8
SMB_ME0_DAT: R187.2 U24.R7
SMB_ME1_CLK: Q27.3 R224.2 U24.K6
SMB_ME1_DAT: Q29.3 R230.2 U24.N11
SMB_PCH_CLK: Q22.3 Q55.3 R196.2 U24.R10
SMB_PCH_DAT: Q23.3 Q54.3 R180.2 U24.U11
SMB_RUN_CLK: JDIM1.202 JDIM2.202 Q22.1 R199.1 R672.2
SMB_RUN_DAT: JDIM1.200 JDIM2.200 Q23.1 R198.1 R671.2
SMB_XDP_CLK: Q55.1 R678.1 TP161.1 TP162.1
SMB_XDP_DAT: Q54.1 R677.1 TP158.1 TP160.1
SMBALERT#: R188.2 U24.N7
SMDDR_VREF_DQ0_M1: R312.1 R313.2 R318.2 R319.2
SMDDR_VREF_DQ1_M1: R285.2 R287.2 R292.1 R293.1
SP_PLLVDD: C41.2 C47.2 C57.2 C62.2 L1.2 U19.M6 U19.N6
SPI_CLK: R645.2 R648.2 U30.6
SPI_CS0#: R660.2 R661.2 U30.1
SPI_CS0#_UR_ME: R661.1 U13.101
SPI_HD#: R644.2 R649.1 U30.7
SPI_SI: R646.2 R647.2 U30.5
SPI_SO: R658.2 R659.2 U30.2
SPI_WP#: R657.2 R663.2 U30.3
SPKR: D12.2 R209.1 U24.AL10
SRTC_RST#: C204.1 R173.2 U24.B9
STP_A16OVR: R167.2 U24.AL6
STRAP0: R415.1 R418.1 U19.D1
STRAP1: R420.1 R421.1 U19.D2
STRAP2: R429.2 R430.2 U19.E4
STRAP3: R422.1 R423.1 U19.E3
STRAP4: R410.2 R411.1 U19.D3
SUS_PWR_ACK: R281.1 R605.2 U13.128
SUS_STAT#: TP47.1 U24.U7
SUSACK#: R624.1 U13.2
SUSACK#_R: R581.1 R624.2 U24.R6
SUSB#: R582.2 TP133.1 U13.82
SUSC#: R548.2 TP127.1 U13.83
SUSCLK: R213.2 R221.1
SUSD: PC163.2 PQ42.2 PQ52.3 PR215.2 PR216.2
SUSLED#: R721.1 R725.1 U13.28
SUSON: PQ51.2 PR78.2 R282.1 U13.123
SV_DET: R536.1 R538.1 U24.D13
SYS_HWPG: D6.1 PR46.2
SYS_PEX_RST_MON#: R437.1 R439.1 U19.E9 U21.2
SYS_PWROK: R201.1 R235.1 R277.2 TP61.1 U8.4 U12.1 U24.AD7
SYS_RESET#: R617.2 R618.1 U24.AM1
SYS_SHDN#: PQ34.3 PR44.2 PR45.2 PU3.6 Q60.3
SYSTEM_AGND: PR54.2 PR55.2 PR57.1 PR58.1 PR59.2
TD_IREF: R469.1 U24.AY43
TEMP_MBAT: PR30.2 PR35.1 PU2.3 U13.73
TESTLO: R46.2 U27.W34
TESTMODE: R44.2 U19.AD9
TH_FAN_POWER: C438.2 C448.2 CN3.1 U26.3
THERM+: TP8.1 U19.F12
THERM-: TP5.1 U19.E12
TP_INT: CN2.5 TP3.1
TP_PWR: CN2.30 CN2.31 R5.1
TP_RST#: CN2.4 TP2.1
TP_VSS_NCTF2: R592.2 U24.BE5
TP_VSS_NCTF8: R483.1 R484.1 U24.A44
TP_VSS_NCTF12: R478.1 R479.1 U24.B45
TP_VSS_NCTF15: R616.1 U24.BD1
TPCLK: R712.1 R713.2 U13.89
TPCLK_R: C554.2 CN18.3 R712.2
TPD_EN: TP70.1 U13.87
TPDATA: R715.1 R716.2 U13.90
TPDATA_R: C560.2 CN18.4 R715.2
TS_EN: R1.1 U13.35
USB3_RXN0: R349.1 U24.AR26
USB3_RXN0_R: CN12.5 R349.2 RV6.1
USB3_RXP0: R347.1 U24.AP26
USB3_RXP0_R: CN12.6 R347.2 RV5.1
USB3_TXN0: C300.1 U24.BE24
USB3_TXN0_C: C300.2 R336.1
USB3_TXN0_R: CN12.8 R336.2 RV2.1
USB3_TXP0: C289.1 U24.BD23
USB3_TXP0_C: C289.2 R328.1
USB3_TXP0_R: CN12.9 R328.2 RV1.1
USB_OC0#: R591.1 RP1.2 U24.P3 U33.3
USB_OC1#: CN17.11 R602.1 RP1.8 U24.V1
USB_OC2#: CN17.12 R577.1 RP1.7 U24.U2
USB_OC3#: R607.1 RP1.6 U24.P1
USB_OC4#: R603.1 RP1.9 U24.M3
USB_OC5#: R613.1 RP1.4 U24.T1
USB_OC6#: R627.1 RP1.1 U24.N2
USB_OC7#: R586.1 RP1.3 U24.M1
USBCOMP: R122.1 U24.K24 U24.K26
USBON#: CN17.9 U13.79 U33.4
USBP0+: R344.1 U24.D37
USBP0+_R: CN12.3 R344.2 RV4.1
USBP0-: R339.1 U24.B37
USBP0-_R: CN12.2 R339.2 RV3.1
USBP1+: CN17.21 U24.C38
USBP1-: CN17.20 U24.A38
USBP2+: CN17.15 U24.C36
USBP2-: CN17.14 U24.A36
USBP3+: CN17.18 U24.C34
USBP3-: CN17.17 U24.A34
USBP4+: R382.1 U24.D33
USBP4+_R: CN2.14 R382.2
USBP4-: R381.1 U24.B33
USBP4-_R: CN2.13 R381.2
USBP5+: CN10.38 U24.G31
USBP5-: CN10.36 U24.F31
USBP8+: R711.1 U24.C32
USBP8+_R: R711.2 U32.3
USBP8-: R710.1 U24.A32
USBP8-_R: R710.2 U32.2
USBP9+: CN16.4 U24.C30
USBP9-: CN16.5 U24.A30
USBP10+: R380.1 U24.D29
USBP10+_R: CN2.11 R380.2
USBP10-: R379.1 U24.B29
USBP10-_R: CN2.10 R379.2
USBPWR1: C528.2 C529.2 C569.1 C570.2 CN12.1 U33.1 VC2.2
V_BLIGHT: CN2.39 CN2.40 R416.1 R417.1
VA1: C729.2 C730.1 PC1.2 PC2.2 PC3.2 PC4.1 PD2.1 PD3.2 PJ1.1 PJ1.2 PQ1.1 PQ1.2 PQ1.3 PQ3.1 PR3.1
VA2: PD1.1 PD1.2 PQ1.5
VGA_ALERT#: R433.1 U19.F8
VGA_OVT#: Q1.1 R399.1 U19.A6
VGA_VCCSENSE: PR186.1 U19.F2
VGA_VSSSENSE: PR187.1 U19.F1
VGPU_EN: PR121.1 R179.1 U24.AN6
VL: PC32.2 PR153.1 PR154.1 PU3.13
VMA_CLK0: R409.2 U19.D24 VRAM1.J7 VRAM3.J7
VMA_CLK0#: R409.1 U19.D25 VRAM1.K7 VRAM3.K7
VMA_CLK1: R43.2 U19.N22 VRAM2.J7 VRAM4.J7
VMA_CLK1#: R43.1 U19.M22 VRAM2.K7 VRAM4.K7
VMA_DM0: U19.D19 VRAM1.D3
VMA_DM1: U19.D14 VRAM1.E7
VMA_DM2: U19.C17 VRAM3.D3
VMA_DM3: U19.C22 VRAM3.E7
VMA_DM4: U19.P24 VRAM2.D3
VMA_DM5: U19.W24 VRAM2.E7
VMA_DM6: U19.AA25 VRAM4.D3
VMA_DM7: U19.U25 VRAM4.E7
VMA_DQ0: U19.E18 VRAM1.A3
VMA_DQ1: U19.F18 VRAM1.C3
VMA_DQ2: U19.E16 VRAM1.C2
VMA_DQ3: U19.F17 VRAM1.A2
VMA_DQ4: U19.D20 VRAM1.A7
VMA_DQ5: U19.D21 VRAM1.D7
VMA_DQ6: U19.F20 VRAM1.C8
VMA_DQ7: U19.E21 VRAM1.B8
VMA_DQ8: U19.E15 VRAM1.F8
VMA_DQ9: U19.D15 VRAM1.F7
VMA_DQ10: U19.F15 VRAM1.H8
VMA_DQ11: U19.F13 VRAM1.E3
VMA_DQ12: U19.C13 VRAM1.H3
VMA_DQ13: U19.B13 VRAM1.H7
VMA_DQ14: U19.E13 VRAM1.F2
VMA_DQ15: U19.D13 VRAM1.G2
VMA_DQ16: U19.B15 VRAM3.D7
VMA_DQ17: U19.C16 VRAM3.B8
VMA_DQ18: U19.A13 VRAM3.C8
VMA_DQ19: U19.A15 VRAM3.A7
VMA_DQ20: U19.B18 VRAM3.A3
VMA_DQ21: U19.A18 VRAM3.C2
VMA_DQ22: U19.A19 VRAM3.A2
VMA_DQ23: U19.C19 VRAM3.C3
VMA_DQ24: U19.B24 VRAM3.G2
VMA_DQ25: U19.C23 VRAM3.E3
VMA_DQ26: U19.A25 VRAM3.H3
VMA_DQ27: U19.A24 VRAM3.F2
VMA_DQ28: U19.A21 VRAM3.F7
VMA_DQ29: U19.B21 VRAM3.F8
VMA_DQ30: U19.C20 VRAM3.H7
VMA_DQ31: U19.C21 VRAM3.H8
VMA_DQ32: U19.R22 VRAM2.C8
VMA_DQ33: U19.R24 VRAM2.A7
VMA_DQ34: U19.T22 VRAM2.D7
VMA_DQ35: U19.R23 VRAM2.B8
VMA_DQ36: U19.N25 VRAM2.C3
VMA_DQ37: U19.N26 VRAM2.A2
VMA_DQ38: U19.N23 VRAM2.C2
VMA_DQ39: U19.N24 VRAM2.A3
VMA_DQ40: U19.V23 VRAM2.E3
VMA_DQ41: U19.V22 VRAM2.G2
VMA_DQ42: U19.T23 VRAM2.F2
VMA_DQ43: U19.U22 VRAM2.H3
VMA_DQ44: U19.Y24 VRAM2.H7
VMA_DQ45: U19.AA24 VRAM2.F7
VMA_DQ46: U19.Y22 VRAM2.F8
VMA_DQ47: U19.AA23 VRAM2.H8
VMA_DQ48: U19.AD27 VRAM4.C3
VMA_DQ49: U19.AB25 VRAM4.A3
VMA_DQ50: U19.AD26 VRAM4.A2
VMA_DQ51: U19.AC25 VRAM4.C2
VMA_DQ52: U19.AA27 VRAM4.B8
VMA_DQ53: U19.AA26 VRAM4.A7
VMA_DQ54: U19.W26 VRAM4.D7
VMA_DQ55: U19.Y25 VRAM4.C8
VMA_DQ56: U19.R26 VRAM4.F8
VMA_DQ57: U19.T25 VRAM4.H7
VMA_DQ58: U19.N27 VRAM4.H8
VMA_DQ59: U19.R27 VRAM4.F7
VMA_DQ60: U19.V26 VRAM4.F2
VMA_DQ61: U19.V27 VRAM4.H3
VMA_DQ62: U19.W27 VRAM4.E3
VMA_DQ63: U19.W25 VRAM4.G2
VMA_RDQS0: U19.F19 VRAM1.B7
VMA_RDQS1: U19.C14 VRAM1.G3
VMA_RDQS2: U19.A16 VRAM3.B7
VMA_RDQS3: U19.A22 VRAM3.G3
VMA_RDQS4: U19.P25 VRAM2.B7
VMA_RDQS5: U19.W22 VRAM2.G3
VMA_RDQS6: U19.AB27 VRAM4.B7
VMA_RDQS7: U19.T27 VRAM4.G3
VMA_WDQS0: U19.E19 VRAM1.C7
VMA_WDQS1: U19.C15 VRAM1.F3
VMA_WDQS2: U19.B16 VRAM3.C7
VMA_WDQS3: U19.B22 VRAM3.F3
VMA_WDQS4: U19.R25 VRAM2.C7
VMA_WDQS5: U19.W23 VRAM2.F3
VMA_WDQS6: U19.AB26 VRAM4.C7
VMA_WDQS7: U19.T26 VRAM4.F3
VMA_ZQ1: R22.2 VRAM1.L8
VMA_ZQ2: R419.2 VRAM3.L8
VMA_ZQ3: R41.2 VRAM2.L8
VMA_ZQ4: R443.2 VRAM4.L8
VR_SVID_ALERT#: PR111.2 PR116.2 R520.2 R521.2
VR_SVID_CLK: PR112.2 PR115.2 R524.2
VR_SVID_DATA: PR110.2 PR117.2 R534.2
VREFC_VMA1: C364.1 R424.2 R428.1 VRAM1.M8 VRAM3.M8
VREFC_VMA3: C70.1 R37.1 R40.2 VRAM2.M8 VRAM4.M8
VREFD_VMA1: C19.1 R13.2 R18.1 VRAM1.H1 VRAM3.H1
VREFD_VMA3: C376.1 R442.2 R447.1 VRAM2.H1 VRAM4.H1
VRON: PR131.2 R681.1 U13.69
VSYNC: R472.1 U22.2
WLAN#: CN10.42 CN10.44 TP156.1
WLAN_CLK_SCLK: CN10.30 R672.1
WLAN_CLK_SDATA: CN10.32 R671.1
WRST#: C245.1 D11.2 R317.1 U13.14
XDP_BPM#0: R491.2 U27.AR30
XDP_BPM#1: R487.2 U27.AN31
XDP_BPM#2: TP29.1 U27.AN29
XDP_BPM#3: TP22.1 U27.AP31
XDP_BPM#4: TP23.1 U27.AP30
XDP_BPM#5: TP26.1 U27.AN28
XDP_BPM#6: TP24.1 U27.AP29
XDP_BPM#7: TP28.1 U27.AP28
XDP_DBRST#: R485.1 R486.1 R617.1 U27.AP33
XDP_FN0: R591.2 TP142.1
XDP_FN1: R602.2 TP138.1
XDP_FN2: R577.2 TP134.1
XDP_FN3: R607.2 TP148.1
XDP_FN4: R603.2 TP152.1
XDP_FN5: R613.2 TP145.1
XDP_FN6: R627.2 TP147.1
XDP_FN7: R586.2 TP131.1
XDP_FN8: R610.2 TP139.1
XDP_FN9: R571.2 TP132.1
XDP_FN10: R595.1 TP136.1
XDP_FN11: R619.1 TP146.1
XDP_FN12: R597.1 TP135.1
XDP_FN13: R228.1 TP60.1
XDP_FN14: R632.2 TP151.1
XDP_FN15: R630.2 TP150.1
XDP_FN_CLK1: R621.1 TP141.1
XDP_FN_CLK2: R569.1 TP128.1
XDP_PRDY#: TP93.1 U27.AR29
XDP_PREQ#: TP94.1 U27.AT29
XDP_TCLK: R57.2 TP17.1 U27.AM34
XDP_TDI: TP90.1 U27.AM31
XDP_TDO: R71.2 TP20.1 U27.AL33
XDP_TMS: TP88.1 U27.AN33
XDP_TRST#: R56.2 TP18.1 U27.AM33
XTAL25_IN: C417.1 R475.1 U24.AM43 Y3.1
XTAL25_OUT: C418.1 R475.2 U24.AL44 Y3.3
XTAL_SSIN: R390.1 U19.A10
N35804879: TP56.1 U27.AC7
N35804889: R191.2 U27.R10
N35805453: R192.2 U27.V10
N35805455: TP54.1 U27.AG8
N35812272: R59.2 U27.AP34
N35813632: Q33.3 R245.2
N35830956: Q25.2 Q28.3 R217.1
N35831177: TP46.1 U24.AB10
N35840776: R211.2 U24.AB6
N35841298: R165.2 U24.F8
N35866291: Q47.2 Q48.3 R480.2
N35866556: C213.1 R210.1
N35875147: R326.1 TP72.1
N35875453: R639.1 TP153.1
N35918456: R436.2 R437.2 U20.4
N35932869: C361.2 R412.2 R743.1 U18.2
N35932875: R16.2 U19.F22
N35932877: R29.2 U19.J22
N35934097: R414.2 R425.2 U18.1
N35947971: Q5.3 R11.1 R324.2
N35947984: C13.2 C17.1 Q4.2 R11.2
N35948037: C51.1 Q11.2 Q12.3 R82.1
N35948066: C64.1 Q12.2 R85.1
N35952197: R432.2 U19.F6
N35952201: TP6.1 U19.E10
N35952203: TP7.1 U19.F10
N35955659: Q1.2 R434.2
N35957470: Q24.3 R383.1 R384.2 R387.1 R401.2
N35957513: Q26.3 R402.1 R404.2 R441.1 R445.1
N35977598: C502.1 C503.2 R250.2 R259.2 R262.2 U11.5
N35977677: R270.1 U11.6
N35977835: R240.2 R249.2 U11.9
N35977847: R238.1 R247.2 U11.7
N35977878: R273.2 U11.27
N35978170: R271.1 U11.15
N35990640: C20.2 C21.1 CN2.34 CN2.35 CN2.36 R17.2
N35991360: CN2.6 R1.2
N35997304: Q42.3 R305.2 R307.2 R310.2 R314.2 R316.2 R321.2 R674.2 R676.2
N35997342: D4.1 R294.2
N35997479: D7.1 R298.2
N36000287: CN10.22 R673.1
N36002123: CN6.11 R94.2 R97.1 R104.1
N36002705: Q20.3 R150.2
N36003009: LED1.4 R725.2
N36003015: LED1.3 R726.2
N36003040: LED2.3 R724.2
N36003063: LED2.4 R723.2
N36013518: CN7.10 R272.1
N36013572: C180.1 TP36.1 U7.27
N36013590: C175.1 TP32.1 U7.25
N36013594: TP33.1 U7.26
N36013609: C500.1 R560.1 R564.1
N36013670: C504.2 U29.3 U29.4 U29.9 U29.10
N36013751: CN7.9 R225.1
N36025352: C567.1 C568.1 R727.2 U17.6
N36025378: D12.1 D14.1 R338.2
N36026429: C324.2 U15.39
N36026435: C533.2 U15.35
N36026441: C533.1 U15.37
N36026464: C326.1 U15.34
N36026466: C319.1 U15.19
N36026531: TP73.1 U15.48
N36026741: C307.1 U15.7
N36026853: R696.2 R697.2 U31.5
N36027219: Q44.2 Q44.5 Q57.3 R695.1
N36027308: C531.2 Q57.2 R351.1 R694.2
N36030100: Q51.3 Q52.2 R664.2
N36030646: R378.2 U16.7
N36036971: C244.2 R303.1
N36037219: C243.1 U13.12
N36042425: PC26.1 PJ2.6 PR38.1
N36042480: PD1.3 PR1.1 PR5.1
N36042482: PR209.2 PU1.13
N36042487: PD3.1 PR9.1 PR10.1
N36042489: PR9.2 PR13.1
N36042495: PR210.2 PU1.12
N36042531: PJ2.3 PR37.1
N36042540: PJ2.4 PR30.1
N36042544: PC168.1 PC169.1 PL1.1 PR20.1 PR23.2
N36042603: PC4.2 PQ1.4 PQ3.6 PR3.2 PR6.1
N36042641: PQ2.4 PR4.2 PR8.1
N36042643: PQ4.3 PR8.2
N36042645: PQ8.3 PR33.1
N36042712: PQ3.2 PQ3.3
N36042725: PQ3.5 PQ4.2 PR7.1
N36042869: PC22.1 PR22.2
N36042962: PC15.2 PD4.1 PR16.1
N36043036: PC27.1 PJ2.5 PR39.1
N36043075: PQ6.2 PQ6.5 PR15.1 PU1.5
N36043093: PQ6.6 PR14.1 PR17.2
N36043210: PR19.2 PU1.8
N36043795: PR21.2 PU1.9
N36047353: PQ18.3 PQ19.2 PQ20.2 PQ21.2 PR61.2 PR66.1
N36047359: PQ51.3 PQ52.2 PQ53.2 PR213.2 PR214.1
N36047418: PQ53.3 PR217.2
N36047494: PC47.2 PD5.1 PD6.2
N36048419: PQ19.3 PR62.2
N36048427: PQ20.3 PR63.2
N36048469: PC37.2 PR48.2
N36048510: PC43.1 PR51.2
N36048553: PR46.1 PR47.2 PU3.7
N36048614: PC46.1 PD6.3
N36048618: PC45.2 PC46.2 PR56.2
N36048690: PC45.1 PD5.3
N36048698: PC44.1 PR53.2
N36048743: PC38.1 PR49.1
N36052805: PC53.1 PR69.1
N36052894: PC56.1 PR73.2
N36054655: PC67.1 PR82.2
N36054782: PC64.1 PR79.2
N36062145: PR138.2 PU8.13
N36062147: PC97.2 PL7.1 PU8.10 PU8.11 PU8.12
N36062169: PC102.2 PR141.1 PU8.7
N36062186: PC97.1 PR138.1
N36062192: PC104.1 PU8.9
N36062196: PR142.1 PU8.8
N36062202: PC103.1 PR141.2
N36062254: PC101.2 PR139.2 PU8.15
N36062279: PC106.2 PR151.2 PR155.1 PU9.8
N36062283: PD7.1 PQ27.1 PR144.1
N36062320: PQ27.3 PR151.1
N36062324: PQ27.2 PQ29.3 PR144.2
N36062358: PC107.2 PQ34.2 PR155.2 PU9.1
N36062370: PQ35.3 PR156.1
N36062990: PQ31.3 PR146.2
N36062996: PQ32.3 PR147.2
N36063064: PQ28.3 PR148.2
N36065296: PC130.2 PR180.1 PR185.1 PR186.2
N36065304: PR181.1 PR187.2 PR188.2
N36065323: PC136.1 PQ40.2
N36065338: PC113.2 PR163.2 PR165.1
N36065388: PR178.2 PR182.1
N36065397: PC122.1 PR170.2 PR172.2 PR174.1 PR179.1
N36065404: PC114.1 PR160.1
N36065475: PC120.1 PR168.2
N36065515: PC123.2 PR177.1
N36065632: PC135.1 PR183.2
N36065662: PC125.1 PR175.1
N36065747: PQ40.3 PR179.2
N36067680: PC146.2 PQ45.2 PR200.2 PR202.1
N36067690: PQ44.2 PQ45.3 PQ46.2 PR197.2 PR201.1
N36067708: PC138.1 PR29.1
N36067805: PC152.1 PR190.2
N36067912: PQ48.3 PQ49.2 PQ50.2 PR203.2 PR207.1
N36068493: PQ44.3 PR198.2
N36068503: PC148.2 PQ48.2 PR206.2 PR208.1
N36068517: PQ49.3 PR204.2
N36137819: Q30.2 R241.2 R244.1
N36209502: Q49.2 Q50.3 R492.2
N36508370: PC141.2 PR126.1
N36508396: PL12.4 PR184.1
N36508398: PL12.3 PR127.1
N36508411: PR196.2 PR212.2
N36508780: PR118.1 PR122.1 PU7.3
N36509488: PC160.1 PR194.2
N36509518: PC93.2 PR132.2
N36510057: PC84.2 PR105.1
N36510083: PL6.4 PR107.1
N36510087: PL6.3 PR106.1
N36510102: PR108.2 PR114.2
N36510197: PC85.1 PR104.2
N36763285: R713.1 R714.2 R716.1 R717.2 R746.2
N37442043: CN11.9 R523.2
N38261008: D23.1 R730.2 R731.2
N38647309: Q59.1 R741.2
N38647316: Q60.2 R741.1
N357965030: Q34.3 R264.1
N360299253: TP75.1 U16.9
N360378000: SW1.4 TP67.1
N360382040: SW1.1 TP65.1

Pads without a net: CN2 1 29 37 38; CN3 4 5; CN5 4; CN8 2; CN9 13 14; CN10 3 5 17 19 46; CN11 8 10 18 20 21 22; CN13 7; CN16 2; HOLE10 1; HOLE11 1; JDIM1 77 122 125; JDIM2 77 122 125; NOREF#2 1; NOREF#4 1; NOREF#5 1; NOREF#7 1; NOREF#9 1; NOREF#10 1; PU2 1; PU9 7; RP7 3 4 6; U3 1; U5 1; U11 1 2 3 8 12 13 14 28; U13 16 31 32 48 96 97; U15 14 16 20; U16 2 3; U19 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB18 AB19 AB21 AC3 AC4 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B2 B3 B6 B19 C1 C2 C3 C5 C7 C18 D4 D5 D6 D10 D11 D16 D17 D18 D23 E6 F4 F5 F7 F9 F11 G1 G2 G3 G4 G5 G6 G7 H3 H4 H6 J1 J2 J3 J4 J5 J6 J7 K1 K2 K3 K4 K5 K6 K7 L3 L4 M1 M2 M3 M4 M5 M7 N1 N2 N3 N4 N5 N7 P3 P4 P6 R1 R2 R3 R4 R5 R6 R7 T1 T2 T3 T4 T5 T6 T7 T24 U3 U4 U6 U24 V1 V2 V3 V4 V5 V6 V7 V24 V25 W1 W2 W3 W4 W5 W6 W7 Y3 Y4 Y6; U24 A28 AA42 AA44 AB39 AB40 AD38 AD39 AE42 AE44 AF43 AF45 AJ10 AJ42 AJ44 AL7 AN38 AN39 AP3 AP29 AR13 AR29 AR31 AT13 AT31 AT39 AT40 AU42 AU44 AV17 AV26 AV29 AV36 AV43 AV45 AW17 AW26 AW29 AW31 AW36 AW38 AW44 AY31 AY38 AY45 BA2 BA45 BB2 BB29 BB33 BB37 BC12 BC24 BC26 BC30 BC32 BC38 BC40 BC45 BD25 BD27 BD33 BD37 BD41 BD42 BE12 BE26 BE28 BE32 BE38 BE40 BE43 BE44 C26 C28 F22 F24 F26 G22 G24 G26 G29 H29 H39 H43 H45 J42 J44 K22 K31 K38 K43 K45 L31 L33 M33 N38 N40 R35 R36 Y38 Y39 Y43 Y45; U27 A2 A24 A26 A28 A30 A34 A35 AA1 AA2 AC8 AD8 AD10 AF9 AG9 AK27 AK33 AL13 AL16 AL25 AL26 AL27 AL29 AL30 AL31 AL32 AM2 AM26 AM27 AR1 AR32 AR33 AR35 AT1 AT2 AT35 B1 B23 B24 B25 B26 B27 B28 B29 B30 B31 B35 C23 C25 C27 C29 C31 C35 D23 D24 D28 D30 D32 D34 E17 E18 E20 E21 E28 E29 E30 E31 E32 E33 E34 E35 F5 F29 F31 F33 F35 G6 J27 K6 K27 L8 L10 L27 M9 M10 N26 N28 N30 P1 P2 P3 P10 P28 P29 P30 P31 R1 R27 R29 R31 T27 T32 T34 U1 U2 U10 U32 U33 U34 U35 V1 V2 V27 V33 V35 W28 W29 W32 Y1 Y2; VRAM1 J1 J9 L1 L9; VRAM2 J1 J9 L1 L9; VRAM3 J1 J9 L1 L9; VRAM4 J1 J9 L1 L9

## Via types
v1: diameter 0.61, hole 0.356, TOP to BOTTOM, 680 vias
v2: diameter 0.66, hole 0.33, TOP to BOTTOM, 520 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 4811 vias
v4: diameter 0.66, hole 0.254, TOP to BOTTOM, 51 vias
v5: diameter 0.457, hole 0.254, TOP to BOTTOM, 49 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.5V_VSNS: length 4.3
  BOTTOM w0.127: PR140.2 164.9,141.67 v3(164.77,141.55)
  BOTTOM w0.254: PR140.2 PR143.1 165.04,139.82 PU8.6
2.469V: length 6.1
  TOP w0.127: v2(58.35,110.97) 57.92,110.97 PR157.1
  TOP w0.508: PU9.3 55.08,111.58 55.37,111.86 55.37,112.43 55.8,112.85 PR154.2 56.37,112.85 57.43,111.79 PR157.1
3V_LDO: length 8.7
  TOP w0.203: PU3.3 39.37,59.86
  TOP w0.254: 39.37,59.86 36.73,59.86 36.35,59.48 36.35,58.62 v2(36.73,58.24) 38.05,56.91 PR44.1 38.4,55.71 PC34.1
3V_MAIN_EN: length 18.9
  TOP w0.127: v3(166.07,170.76) v2(167.77,169.06) 167.92,168.9 169.8,168.9 170.67,169.77 Q5.2
  BOTTOM w0.127: U19.A3 155.79,169.35 156.21,169.77 157.89,169.77 158.9,168.75 163.04,168.75 R407.1 R406.2 164.03,170.76 v3(166.07,170.76)
3V_MAIN_PWGD: length 119.2
  TOP w0.127: R84.1 R83.2 170.03,173.66 Q11.3 170.03,171.42 v3(170.29,171.16) ; v3(139.78,137.1) 139.32,136.64 139.32,134.94 135.28,130.9 v2(126.09,130.9) 117.59,130.9 PR200.1 ; v3(164.32,136.57) 167.44,139.69 167.95,139.69 168.58,140.33 171.15,140.33 v3(171.53,140.71)
  IN1 w0.133: v3(189.89,139.92) 188.73,138.75 181.35,138.75 180.74,139.37 180.04,139.37 178.8,140.61 176.09,140.61 176.04,140.55 171.69,140.55 v3(171.53,140.71) 170.72,141.52 170.72,157.37 170.95,157.6 170.95,170.5 v3(170.29,171.16) ; v3(164.32,136.57) 163.7,137.18 139.86,137.18 v3(139.78,137.1)
  BOTTOM w0.127: PR162.2 PR164.1 189.77,139.8 v3(189.89,139.92)
51211V_DRVH: length 5.9
  IN2 w0.762: v1(190.3,126.18) 190.3,127.93 189.54,128.69 v1(186.44,128.69)
51211V_DRVL:
  vias: v1(187.99,125.52) v2(186.72,125.8)
51211V_EN: length 3.4
  TOP w0.127: v3(189.56,121) 189.1,120.54 PR68.1
  BOTTOM w0.127: PU4.3 189.64,121.07 v3(189.56,121) 189.1,120.54 PR68.1
51211V_FB: length 3.8
  TOP w0.254: v3(188.6,121.05) 187.91,120.36 PR74.2
  BOTTOM w0.254: PU4.4 189.14,121.59 v3(188.6,121.05) 187.96,120.41 PR75.1
51211V_SW:
  vias: v1(181.81,131.31) v1(182.75,131.29) v1(183.64,131.29) v1(184.61,131.29) v1(185.63,131.26) v1(189.39,126.79) v2(186.8,131.13)
51211V_TRIP: length 2.8
  BOTTOM w0.127: PU4.2 190.14,120.91 190.07,120.85 v3(190.07,120.47) 190.61,120.47 PR70.2
51211V_TST: length 3.9
  BOTTOM w0.127: PU4.5 188.64,121.82 187.02,120.2 PR72.2 186.02,120.2 v3(185.91,120.31)
51211V_VBST:
  vias: v2(193.07,125.16)
+1.05V: length 396.4
  TOP w0.279: U3.5 C716.2
  TOP w0.305: R144.1 172.11,100.08 173.55,100.08 173.82,100.36 175.37,100.36 R139.1 176.35,101.11 177.52,99.94 v3(178.84,99.94)
  TOP w0.381: v3(169.06,115.82) 169.06,115.6 168.4,114.94 R73.1 168.24,114.94 167.23,115.95 R67.2 166.79,115.95 165.62,114.78 R70.2 ; v3(152.05,88.55) 152.05,88.29 151.42,87.66 149.6,87.66 144.71,92.55 142.85,92.55 139.25,96.16 v3(139.25,97.43) ; 47.78,99.23 PC88.1
  TOP w0.508: v3(182.33,118.23) 182.33,118.26 182.86,118.79 186.08,118.79 187.68,117.19 188.93,117.19 190.86,119.12 190.86,120.08 190.48,120.47 190.48,121.06 190.85,121.43 192.21,121.43 196.32,125.55 v3(196.32,125.7) ; R89.2 133.53,112.23 134.42,113.12 136.1,113.12 138.68,115.7 v3(138.99,115.7) ; v3(173.18,171.33) R742.2 174.98,170.68 176.37,170.68 176.66,170.38 C716.2 177.4,170.7 177.4,171.1 178.9,172.6 Q59.3 ; R113.1 86.47,107.28 84.64,107.28 84.22,107.7 ; PR148.1 33.3,64.24 31.65,65.88 31.65,66.62 35.78,70.74 35.78,77.15 34.98,77.95 34.98,84.46 37.54,87.01 37.54,93.79 43.72,99.97 45.26,99.97 45.61,100.32 46.14,100.32 46.52,99.94 v3(46.52,99.91) 47.93,99.91 v3(47.96,99.94) 47.96,99.41 47.78,99.23 48.75,98.27 v3(50.83,98.27) 56.37,98.27 61.47,103.37 62.92,103.37 62.92,103.47 64.49,105.05 71.23,105.05 72.9,103.37 79.23,103.37 83.55,107.7 84.22,107.7 ; 84.22,107.7 84.22,108.4 90.39,114.57 R71.1 91.13,117.75 v3(90.89,118)
  TOP w1.016: 166.6,127.76 166.9,128.06 173,128.06 174.52,126.55 174.52,121.32 177.02,118.81 180.9,118.81
  IN1 w0.508: v3(188.35,177.26) 187.1,177.26 183.11,173.27 178.36,173.27 177.8,173.83 175.42,173.83 173.18,171.6 v3(173.18,171.33)
  IN1 w0.762: 103.84,121.05 113.75,121.05 115.9,123.21 132.81,123.21 135.84,120.18 135.84,118.81 138.23,116.43 ; 101.83,121.08 v3(101.83,121.02) ; 101.83,121.28 100.06,123.05 v3(96.79,123.05) 95.95,123.05 v3(90.89,118)
  IN1 w1.016: 182.51,106.11 183.06,106.66 183.06,107.13 184.79,108.86 184.79,111.12 184.37,111.54 184.37,114.13 182.38,116.13 182.38,117.32
  IN2 w0.508: v3(196.32,125.7) 196.27,125.75 196.27,165.28 196.36,165.37 196.36,166.55 196.36,166.56 196.36,167.2 196.33,167.22 196.33,167.87 195.56,168.64 195.56,173.87 193.97,175.47 192.83,175.47 191.04,177.26 v3(188.35,177.26) 174.55,177.26 172.7,179.11 168.41,179.11 167.67,179.85 164.45,179.85 163.23,181.06 155.49,181.06 155.26,180.83 149.42,180.83 v3(149.42,180.83)
  BOTTOM w0.381: v3(50.83,98.27) 51.35,97.75 PR110.1 ; v3(47.96,99.94) 48.02,99.88 PR111.1 ; v3(152.05,88.55) 152.56,89.06 R570.2 ; R525.1 180.19,103.4 180.45,103.4 180.85,103.8 v3(181.03,103.8) ; PR113.1 45.79,100.64 v3(46.52,99.91) PR112.1
  BOTTOM w0.508: v3(149.42,180.83) 149.43,180.81 149.43,179.62 148.72,178.91 148.72,177.63 PR40.2 ; R459.1 97.17,122.68 v3(96.79,123.05)
  vias: v3(90.45,117.19) v3(102.77,120.97) v3(137.98,99.28) v3(138.13,98.06) v3(138.62,99.28) v3(138.61,97.61) v3(138.99,115.05) v3(139.09,98.06) v3(139.27,99.28) v3(146.69,111.83) v3(147.25,111.42) v3(148.41,115.89) v3(149.07,115.89) v3(162.26,127.24) v3(162.94,127.23) v3(163.33,126.69) v3(163.66,127.3) v3(163.99,126.69) v3(164.13,117.22) v3(164.32,127.27) v3(164.67,126.69) v3(165,127.25) v3(165.36,126.69) v3(165.69,127.25) v3(166.3,117.52) v3(169.65,122.32) v3(169.65,121.64) v3(181.08,103.14) v3(181.54,118.18)
+1.5V: length 282
  TOP w0.254: v3(158.91,143.05) 157.89,142.03 157.89,139.16 157.31,138.58 157.31,135.53 v1(156.69,134.92)
  TOP w0.381: R138.2 153.46,100.74 153.2,101.01 153.2,101.45 153.02,101.62 151.29,101.62 150.64,100.97 R142.1 149.61,101.68 148.79,101.68 v3(148.04,102.43) ; v3(157.08,115.51) 157.59,116.02 158.75,116.02 159.12,115.66 R66.2 ; R161.1 152.48,95.92 152.35,95.79 R166.2 151.91,95.3 v3(151.34,94.74)
  TOP w0.508: L4.2 169.65,118.77 v3(170.52,119.64) ; v3(47.83,33.96) 43.97,33.96 38.36,28.35 C321.2 38.35,27.84 R354.1
  IN1 w0.381: v3(151.34,94.74) 150.42,95.65 147.49,95.65 146.87,95.02 143.38,95.02 v3(143.26,95.14)
  IN1 w0.508: v3(154.51,68.96) 153.37,67.82 153.37,62.14 150.09,58.85 150.09,57.52 146.78,54.22 146.78,52.63 140.26,46.1 139.89,46.1 136.67,42.88 136.67,42.04 131.45,36.82 124.31,36.82 122.39,34.89 112.03,34.89 111.38,34.25 96.56,34.25 95.76,35.04 85.55,35.04 84.7,35.9 76.8,35.9 71.02,30.12 68.53,30.12 65.45,27.03 55.97,27.03 53.83,24.89 51.15,24.89 50.67,25.38 50.67,32.17 49.29,33.55 48.24,33.55 v3(47.83,33.96)
  IN2 w0.508: v3(154.51,68.96) 153.99,68.96 152.69,70.25 152.69,72.06 147.34,77.41 147.34,89.63 145.78,91.19 145.78,92.13 143.26,94.65 v3(143.26,95.14)
  BOTTOM w0.254: R499.1 R503.2 147.34,107.84 v3(147.83,107.36) ; v3(158.91,143.05) 159.39,143.53 159.39,143.86 160.77,145.24 164.93,145.24 165.99,144.17 165.99,142.78 166.53,142.24 PR140.1
  BOTTOM w0.305: R471.1 151.72,119.02 v3(151.07,119.67) 150.71,119.31 R470.2
  BOTTOM w0.508: v3(148.04,102.43) 148.28,102.19 R531.1 148.2,101.49 145.13,98.41 145.13,95.74 144.53,95.14 v3(143.26,95.14) ; R692.2 29.24,35.75 31.53,38.04 41.42,38.04 44.09,35.38 46.41,35.38 v3(47.83,33.96) ; v3(154.51,68.96) 160.73,68.96 162.08,67.61 162.08,66.07 163.42,64.73 166.1,64.73 166.46,64.37 167.24,64.37 167.42,64.55 168.71,64.55 R666.1
  vias: v2(152.66,128.72) v3(138.99,106.75) v3(139.65,106.72) v3(148.49,107.33) v3(150.5,116.59) v3(155.4,126.65) v3(156.11,126.7) v3(156.6,115.94) v3(156.77,126.72) v3(157.48,126.7) v3(158.14,126.7) v3(158.79,126.71)
+1.05V_GFX:
  vias: v2(150.5,152.93) v3(131.17,132.65) v3(131.83,132.66) v3(132.77,139.67) v3(132.8,139.01) v3(133.07,140.33) v3(133.48,139.74) v3(136.1,147.8) v3(136.5,138.75) v3(136.53,138.09) v3(136.88,139.29) v3(137.27,138.75) v3(137.27,138.09) v3(137.8,139.62) v3(140.46,152.16) v3(140.59,153.05) v3(142.98,153.03) v3(144.4,153.08) v3(146.2,153.03) v3(147.96,152.95) v3(148.77,152.11) v3(148.97,152.85)
+1.05V_S5: length 10.7
  TOP w0.254: 178.31,121.94 179.07,121.18 182.53,121.18 183.88,119.83 186.6,119.83 187.03,119.39 PR74.1
  vias: v1(179.2,130.45) v1(179.22,129.23) v1(179.25,128.06) v1(179.17,126.76) v2(173.74,128.31) v3(132.69,133.57) v3(132.67,132.91) v3(133.35,133.6) v3(133.38,132.89) v3(134.01,133.6) v3(134.07,132.89) v3(168.53,125.26) v3(169.02,124.76) v3(169.19,125.39) v3(169.68,124.76) v3(169.85,125.39)
+1.5V_WLAN: length 50.2
  TOP w0.508: v3(180.8,54.11) 178.38,51.69 175.49,51.69 v3(174.69,52.49) ; v3(173.89,61.56) 172.26,59.94 169.18,59.94 168.82,60.29 168.82,61.31 168.35,61.79 v3(168.3,61.79) ; v3(186.79,62.61) 186.79,63.73 186.13,64.38 C231.1
  IN1 w0.508: v3(173.89,61.56) 173.89,60.73 174.9,59.72 174.9,52.7 v3(174.69,52.49)
  BOTTOM w0.508: v3(180.8,54.11) 181.11,54.11 182.08,55.08 184.69,55.08 186.3,56.68 CN10.6 186.3,61.52 186.33,61.56 186.33,61.57 186.79,62.03 v3(186.79,62.61) ; R666.2 168.71,62.19 v3(168.3,61.79) 168.3,62.05 C513.1 167.45,61.93 167.45,61.36 166.3,60.21 CN10.48 ; CN10.28 174.3,60.68 174.67,61.05 C514.1 174.62,62.29 v3(173.89,61.56)
+1.5VA: length 3.4
  TOP w0.203: v3(35.32,27.07) 34.59,27.07 33.64,28.03 U15.40
  BOTTOM w0.508: v2(34.55,27.09) 35.3,27.09 v3(35.32,27.07)
+1.35V_GFX: length 120
  TOP w0.203: v3(123.95,167.54) 123.95,168.1 123.7,168.34 123.38,168.34 123.15,168.58 v3(123.15,169.11)
  TOP w0.254: PR97.1 118.52,187.51 v3(118.52,187.88)
  TOP w0.305: VRAM1.K2 v3(118.35,167.54) ; VRAM1.N9 124.46,164.64 125.05,164.64 v3(125.56,165.14) ; VRAM1.H2 118.75,168.74 v3(119.14,169.13) ; v3(120.37,146.78) 120.32,146.73 119.67,146.73 VRAM2.G7 ; VRAM1.D2 VRAM1.C1 117.91,172.74 v3(117.46,172.3) ; VRAM1.C9 124.95,172.74 v3(125.02,172.68) ; VRAM1.R9 125.16,163.14 125.62,163.6 v3(125.62,163.9) ; v3(125.52,169.18) 125,168.65 124.44,168.65 VRAM1.H9 ; VRAM1.D9 v3(123.95,171.54) VRAM1.E9 ; VRAM2.A1 v3(123.95,142.45) VRAM2.B2 ; VRAM1.B2 VRAM1.A1 117.95,174.45 118.37,174.88 v3(118.71,174.88) ; v3(117.42,152.02) 117.8,151.65 VRAM2.N9 ; v3(123.15,169.11) 122.75,169.52 VRAM1.G7 ; VRAM2.A8 118.75,141.61 v3(118.99,141.37) ; v3(123.59,174.89) 123.55,174.85 VRAM1.A8 ; VRAM1.K8 v3(123.95,167.54) ; v3(117.35,153.25) VRAM2.R9
  TOP w0.381: VRAM2.H2 v3(123.15,147.25)
  TOP w0.508: v3(138.75,166.21) 138.76,166.22 R20.1 ; R16.1 135.38,169.6 135.54,169.76 136.17,169.76 C18.1 136.45,169.48 136.45,168.75 v3(136.37,168.67) ; C22.2 R18.2 113.56,167.67 v3(113.78,167.45)
  IN1 w0.254: v3(120.37,146.78) 120.5,146.91 120.5,147.7 119.66,148.54 119.66,149.07 119.37,149.36 118.85,149.36 v3(118.33,148.83)
  IN1 w0.508: v3(118.99,141.37) 118.99,143.37 v3(118.33,144.03) ; v3(125.07,170.48) 125.07,170.61 124.13,171.54 v3(123.95,171.54) 125.02,172.62 v3(125.02,172.68) 124.66,173.03 124.06,173.03 v3(123.15,173.94) 123.15,174.45 v3(123.59,174.89) ; v3(118.71,174.88) 118.48,174.65 118.48,174.04 117.62,173.18 v3(117.03,173.18) ; v3(123.95,142.45) 124.57,143.07 125,143.07 125.53,143.6 v3(125.53,143.66)
  IN2 w0.254: v3(118.52,187.88) 119.46,187.88 122.7,191.11 128.66,191.11 129.19,190.58 136.39,190.58 137.88,189.1 v3(137.88,185.9)
  IN2 w0.508: v3(125.53,143.66) 124.81,143.66 123.95,144.53 v3(123.95,144.85) ; v3(125.52,169.18) 125.52,169 124.99,168.47 123.56,168.47 123.15,168.88 v3(123.15,169.11)
  BOTTOM w0.152: VRAM2.K2 123.95,148.85 124.49,148.85
  BOTTOM w0.203: 124.61,167.54 v3(123.95,167.54) ; 124.49,148.85 124.66,148.85 ; v3(119.14,169.13) 119.14,168.58 118.9,168.34 118.56,168.34 118.35,168.14
  BOTTOM w0.229: 119.14,142.25 119.14,141.78
  BOTTOM w0.254: 119.14,142.25 119.14,142.46 VRAM4.B2 ; v3(123.59,174.89) 123.59,174.88 124.13,174.34 VRAM3.A1 ; v3(118.99,141.37) 119.14,141.52 119.14,141.78 ; 125.56,166.6 124.61,167.54
  BOTTOM w0.305: VRAM1.N1 117.41,164.74 v3(116.59,163.92) ; v3(117.36,141.4) 117.95,141.99 VRAM4.A1 ; VRAM3.A8 118.75,174.71 118.71,174.75 v3(118.71,174.88) ; VRAM4.E9 v3(123.95,144.85) VRAM4.D9 ; U19.E23 138.82,166.21 v3(138.75,166.21) ; VRAM2.C1 125.52,143.65 v3(125.53,143.66) ; VRAM2.C9 v3(118.33,144.03) VRAM4.D2 ; v3(125.53,152.46) 125.53,152.57 124.85,153.25 VRAM2.R1 ; v3(117.34,163.14) 117.35,163.14 VRAM1.R1 ; v3(124.77,148.05) 124.37,147.65 VRAM4.H9 ; VRAM4.A8 v3(123.95,142.45) ; v3(117.42,152.02) 117.8,151.65 VRAM2.N9 ; U19.H24 138.39,163.32 138.77,163.7 v3(138.77,163.7) ; VRAM3.H2 123.52,168.74 v3(123.15,169.11) ; VRAM2.R9 v3(117.35,153.25) ; VRAM3.D2 v3(123.95,171.54) ; U19.C25 U19.B26 v3(136.37,168.67) ; v3(136.25,160.85) 136.27,160.82 U19.L26 ; v3(118.37,148.05) 118.75,147.67 VRAM4.H2 ; v3(125.71,151.05) 125.1,151.65 VRAM2.N1 ; v3(123.95,167.54) VRAM1.K8 ; 125.48,164.56 124.53,164.56 VRAM1.N9 ; v3(126.18,148.13) 125.46,148.85 124.66,148.85 ; v3(125.07,170.48) 124.93,170.34 VRAM3.F1 ; v3(125.02,172.68) 124.95,172.74 VRAM1.C9 ; v3(137.99,160.4) 138.39,160.8 U19.L24 ; v3(116.56,145.53) 117.07,146.05 VRAM4.F1 ; U19.H26 136.79,163.28 v3(136.39,162.88) ; VRAM4.G7 122.75,146.85 v3(123.15,147.25) ; VRAM2.K8 v3(118.33,148.83) ; U19.E26 v3(136.2,165.79) ; VRAM3.B2 v3(123.15,173.94)
  BOTTOM w0.508: v3(125.07,170.48) 125.2,170.48 125.91,171.19 127,171.19 127.72,170.48 ; R447.2 v3(113.56,147.25) ; 127.11,168.5 126.2,168.5 v3(125.52,169.18) ; C350.2 146.91,175.1 C352.2 ; R428.2 113.56,160.5 114.34,159.72 C365.2
  vias: v2(142.42,179.52) v3(115.22,163.87) v3(115.19,163.21) v3(115.35,175.56) v3(115.34,159.81) v3(115.34,157.8) v3(115.38,173.69) v3(115.38,172.98) v3(115.38,172.22) v3(115.36,171.53) v3(115.36,170.79) v3(115.37,159.15) v3(115.37,158.49) v3(115.37,145.33) v3(115.37,144.62) v3(115.37,143.96) v3(115.37,143.27) v3(115.37,142.61) v3(115.37,141.93) v3(115.47,156.38) v3(115.5,155.64) v3(115.52,154.96) v3(115.55,154.25) v3(115.93,168.39) v3(115.95,167.02) v3(116.03,143.96) v3(116.11,146.12) v3(116.61,168.46) v3(116.61,167.02) v3(116.59,146.78) v3(117.02,156.1) v3(117.02,155.44) v3(117.02,154.76) v3(117.31,170.91) v3(117.27,167.02) v3(123.98,154.83) v3(124.39,156.03) v3(124.36,155.36) v3(125.53,155.26) v3(126.9,164.85) v3(127.35,165.31) v3(127.31,164.29) v3(127.51,169.03) v3(127.78,165.8) v3(127.77,164.78) v3(128.09,169.32) v3(128.14,168.67) v3(128.22,165.26) v3(141.29,164.55) v3(141.33,162.76) v3(141.33,162.07) v3(141.3,160.55) v3(141.34,159.55) v3(141.34,158.79) v3(141.38,163.57) v3(141.35,161.28) v3(141.4,157.02) v3(142.24,163.57) v3(142.3,177.72) v3(142.96,177.72) v3(143.03,177.06) v3(142.97,164.6) v3(143.64,177.7) v3(143.82,177.06) v3(144.38,177.72) v3(144.53,177.08) v3(144.53,163.7) v3(145.04,177.72) v3(145.06,163.26) v3(145.19,177.08) v3(145.45,164.58) v3(145.55,163.75) v3(146.26,163.82) v3(146.92,163.59) v3(147.11,164.6) v3(147.51,163.16) v3(147.86,163.75)
+1.35V_SUS: length 52.8
  TOP w0.381: R255.1 82.96,74.04 82.23,73.31 v3(82.23,72.85) ; v3(79.1,67.73) 80,66.84 C225.2 C226.2 R278.1 ; v3(71.35,62.74) 71.78,62.32 R293.2
  TOP w0.508: v1(55.15,28.19) 55.15,28.19 55.22,28.11 PC60.2 ; R318.1 69.99,48.71 v3(69.37,49.32)
  IN2 w0.133: v1(67.11,31.03) 64.95,28.87 56.52,28.87 56.16,28.52 56.16,27.91 55.76,27.5 53.24,27.5 51.36,29.38 51.36,31.16 v3(51.57,31.36)
  IN2 w0.508: v1(55.15,28.19) 55.15,28.64 57.1,30.6 59.31,30.6 60.05,29.86 64.72,29.86 v1(65.91,31.06)
  BOTTOM w0.102: U27.AE8 105.36,89.73
  BOTTOM w0.305: U27.AB5 v3(107.93,87.16) ; v3(104.93,87.16) U27.AE5 ; U27.W5 111.46,86.69 v3(111.93,87.16) ; U27.T5 v3(114.93,86.16) ; v3(107.93,83.16) 107.93,83.22 U27.AB2 ; U27.T8 v3(114.93,89.16) ; U27.W8 111.46,89.69 v3(111.96,90.19) ; v3(104.93,84.16) U27.AE2 ; U27.AB8 v3(107.93,90.16) ; U27.T2 v3(114.93,83.16) ; U27.N8 v3(117.93,89.16) ; 105.36,89.73 v3(104.93,90.16)
  BOTTOM w0.381: U27.W2 111.46,83.69 v3(111.93,84.16)
  vias: v1(93.92,26.3) v1(94.69,26.29) v1(95.51,26.29) v1(96.3,26.28) v1(97.16,26.28) v1(97.96,26.28) v1(98.76,26.27) v1(99.6,26.27) v1(100.4,26.26) v1(101.17,26.29) v1(102.03,26.29) v1(102.85,26.26) v1(103.67,26.28) v2(117.78,64) v3(97.05,51.62) v3(97.05,50.95) v3(97.05,50.29) v3(98.3,35.38) v3(99.14,35.36) v3(99.93,35.35) v3(100.33,50.27) v3(100.72,35.36) v3(100.8,49.82) v3(101.26,49.35) v3(101.63,35.32) v3(101.71,48.86) v3(101.93,62.31) v3(102.4,97.82) v3(102.4,97.05) v3(102.39,93.31) v3(102.48,95.58) v3(102.48,94.82) v3(102.52,35.35) v3(103.31,35.35) v3(104.1,35.36) v3(104.24,97.77) v3(104.26,97.1) v3(104.26,95.58) v3(104.26,94.82) v3(104.96,35.35) v3(105.8,35.38) v3(106.03,97.86) v3(106.03,97.1) v3(106.04,95.58) v3(106.04,94.82) v3(105.98,92.14) v3(106.48,35.35) v3(107.22,35.38) v3(107.38,50.28) v3(107.4,49.63) v3(107.41,48.97) v3(107.81,97.86) v3(107.81,97.1) v3(107.81,95.58) v3(107.81,94.82) v3(107.83,93.22) v3(107.78,62.62) v3(107.89,92.07) v3(108.01,35.4) v3(109.59,97.86) v3(109.59,97.1) v3(109.59,95.58) v3(109.59,94.82) v3(110.85,49.7) v3(110.85,49.01) v3(110.9,92) v3(111.37,97.86) v3(111.37,97.1) v3(111.37,95.58) v3(111.37,94.82) v3(111.39,93.44) v3(112.31,61.41) v3(112.73,61.9) v3(113.15,97.86) v3(113.15,97.09) v3(113.15,95.58) v3(113.15,94.82) v3(113.31,50.06) v3(113.33,49.36) v3(113.33,48.7) v3(114.92,97.86) v3(114.92,97.1) v3(114.92,95.58) v3(114.92,94.82) v3(114.96,93.26) v3(116.7,97.86) v3(116.7,97.1) v3(116.7,95.55) v3(116.7,94.82) v3(117.88,92.05) v3(118.48,97.86) v3(118.48,97.1) v3(118.48,95.58) v3(118.48,94.82) v3(118.6,93.3) v3(119.93,92.06) v3(120.4,93.27)
+3V: length 1228.3
  TOP w0.254: U5.5 83.76,104.47 84.69,105.4 C144.2
  TOP w0.279: v3(27.08,113.47) C124.2 23.72,113.47 23.22,112.97 Q58.2 ; Q58.5 19.21,112.97
  TOP w0.305: v3(161.25,90.85) 161.35,90.95 R181.1 ; R206.1 153.88,89.25 154.67,89.25 R207.2 ; R206.1 R205.2 ; R206.1 153.5,89.23 v3(153.5,88.65) ; 135.18,54.86 R302.2
  TOP w0.381: R34.2 v3(105.51,157.3) ; R119.1 24.35,105.34 v3(25.06,106.05) ; v3(50.3,91.03) 49.84,91.48 PR119.2 ; v3(117.86,187.55) 117.86,188.71 118.77,189.63 118.77,189.71 119.54,190.47 119.54,190.85 120.02,191.33 PR27.2 ; R143.1 179.61,100.68 v3(180.19,101.26) ; v3(151.03,84.02) 151.03,85.01 152.5,86.48 152.5,87.65 v3(153.5,88.65) ; R198.2 186.06,90.23 Q23.2 185.08,92.55 183.63,92.55 183.3,92.21 v3(183.3,91.71) 182.39,91.71 Q22.2 182.25,90.9 R199.2
  TOP w0.508: 175.7,11.47 174.07,13.1 171.96,13.1 170.34,14.72 155.75,14.72 155.34,14.32 149.26,14.32 146.23,17.35 146.23,20.69 ; 175.7,11.47 v3(175.7,11.45) ; 175.7,11.47 175.7,14.19 v3(174.83,15.06) ; Q37.2 21.52,69.26 22.28,68.5 v3(22.69,68.5) ; v3(18.55,109.44) R729.2 19.21,112.97 ; v3(25.07,55.14) 25.07,55.41 Q43.2 24.28,56.61 24.74,57.07 25.08,57.07 25.54,57.52 25.54,59.5 25.02,60.01 Q41.2 24.28,60.32 25.89,61.92 25.89,65.73 24.41,67.2 23.35,67.2 22.69,67.86 v3(22.69,68.5) ; 172.04,122.37 172.04,120.12 171.54,119.63 R55.1 171.3,118.76 171.88,118.18 171.88,116.71 170.92,115.75 170.92,115.04 ; R5.2 116.26,176.19 114.65,177.8 R4.1 ; R137.2 197.49,101.11 v3(198.2,100.4) ; v3(188.59,56.58) 188.13,56.58 187.43,55.88 R300.2 ; R109.1 179.54,107.29 180.35,108.1 180.65,108.1 181,108.45 v3(181.28,108.45) 181.36,108.53 182.42,108.53 182.58,108.36 R106.1 182.58,107.67 182.55,107.64 R111.1 182.58,106.7 182.58,106.02 ; PR146.1 v3(34.19,50.62) ; R728.2 24.45,111.28 26.56,111.28 26.88,110.97 26.88,107.87 v3(25.06,106.05) ; v3(51.35,93.26) 50.83,93.78 50.83,94.81 51.82,95.8 53.19,95.8 53.73,96.34 65.92,96.34 70.62,101.03 78.9,101.03 83.74,105.88 C144.2 ; R740.2 v3(183.01,174.09) ; R3.1 R4.1 ; R4.1 114.22,177.77 111.89,177.77 111.41,177.28 R6.2 ; R351.2 21.4,31.95 24.16,34.71 v3(24.16,35.6) ; R190.2 158.17,91.57 v3(158.8,90.94) ; 182.58,106.02 181.16,106.02 v3(180.67,106.51) ; 182.58,106.02 R121.1 ; PR76.2 60.24,27.87 v3(60.35,27.76) ; v3(22.69,68.5) 23.07,68.5 23.74,69.17 R63.1 ; v3(175.86,134.73) 176.72,135.58 176.72,137.02 175.28,138.46 175.28,139.53 176.33,140.58 178.66,140.58 PR169.2 ; 167.84,177.06 167.84,179.44 168.56,180.16 v3(168.86,180.16) 169.5,179.52 R2.2 ; v3(178.71,86.79) 178.19,86.28 177.64,86.28 Q27.2 177.45,86.28 176.64,85.46 176.64,85.22 176.63,85.21 176.63,83.11 177.22,82.52 Q29.2 ; v3(153.39,54.85) 153.39,54.9 156.95,58.46 161.89,58.46 R295.1 ; R104.2 195.67,108.2 193.3,108.2 v3(193.1,107.99) 192.71,107.99 192.18,108.53 192.18,110.18 192.63,110.63 v3(193.26,110.63) ; R35.2 170.82,157.02 171.43,157.63 171.43,164.08 171.68,164.33 171.68,165.75 v3(171.43,166.01) 171.4,165.98 168.71,165.98 166.41,168.28 R82.2
  TOP w0.762: R95.1 153.19,110.84 151.92,110.84 150.93,111.83 148.87,111.83 147.5,113.2 142.19,113.2 141.66,113.73 ; R365.1 112.32,17.24 115.09,20.01 v3(116.74,20.01) v3(117.94,20.01) 143.84,20.01 144.63,20.8
  TOP w1.016: 139.93,114.39 139.93,116.95 145.76,122.77 145.76,124.28 v3(147.68,126.21) 149.89,126.21 ; 149.89,126.21 149.89,126.21 ; 149.89,126.21 153.68,126.21 155.11,124.78 165.69,124.78 166.64,125.73 167.09,125.73 167.64,126.28 171.2,126.28
  IN1 w0.508: v3(183.01,174.09) 182.54,174.57 174.48,174.57 173.22,175.82 v3(170.31,175.82) ; v3(141.03,188.23) 141.81,188.23 145.45,184.6 151.57,184.6 153.95,182.21 155.78,182.21 156.85,181.14 159.09,181.14 159.44,180.79 168.23,180.79 v3(168.86,180.16) ; 187.63,64.41 187.63,62.65 189.95,60.34 189.95,57.93 v3(188.59,56.58) ; 27.16,108.84 26.79,108.84 25.06,107.11 v3(25.06,106.05) ; 27.16,108.84 27.08,108.92 v3(27.08,113.47) 23.05,109.44 v3(18.55,109.44) ; 27.16,108.84 v3(60.61,108.84) ; 168.43,44.34 168.81,44.34 169.53,43.62 171.11,43.62 172.43,44.94 180.61,44.94 180.75,44.8 184.66,44.8 185.25,45.39 185.25,46 181.65,49.59 181.65,51.53 181.65,51.91 181.44,52.13 181.44,53.84 181.44,53.84 181.44,54.58 183.47,56.6 183.47,62.33 186.27,65.12 ; v3(40.02,83.38) 42.66,86.02 44,86.02 44.28,86.31 45.19,86.31 46.13,87.24 47.02,87.24 48.01,88.23 48.01,89.07 49.97,91.03 v3(50.3,91.03) 50.86,91.03 52.05,92.22 52.05,92.86 51.64,93.26 v3(51.35,93.26) ; v3(25.07,55.14) v3(25.07,50.54) 25.07,44.75 25.84,43.99 25.84,38.91 24.16,37.23 v3(24.16,35.6) ; 186.49,65.8 186.85,66.16 186.85,68.35 185.31,69.89 184.45,69.89 184.03,70.31 v3(184.03,70.51) ; v3(181.28,108.45) 181.28,108.86 180.38,109.76 180.38,112.17 177.86,114.7 v3(177.6,114.7) ; v3(180.19,101.26) 180.19,104.24 181.06,105.1 181.06,106.12 v3(180.67,106.51)
  IN1 w1.016: 166.91,44.37 165.69,43.15 157.84,43.15 ; 137.14,113.45 135.97,112.29 135.97,98.63 142.21,92.39 147.05,92.39 147.83,91.61 149.58,91.61 ; 151.64,54.34 149.6,52.29 149.22,52.29 147.17,50.25 147.17,49.01 143.76,45.61 143.76,45.53 138.51,40.28 136.92,40.28 132.04,35.4 127.26,35.4 ; 154.07,56.04 157.4,59.37 157.4,62.06 158.19,62.86 158.19,80.68 157.02,81.85 157.02,82.67
  IN2 w0.381: v3(117.86,187.55) 117.23,187.55 114.05,184.37 111.51,184.37 110.7,183.56 104.17,183.56 101.76,181.15 101.76,178 102.62,177.13 103.91,177.13 104.97,178.2 105.44,178.2 v3(105.54,178.1)
  IN2 w0.508: 178.09,115.2 184.53,115.2 185.09,114.63 186.16,114.63 186.68,115.15 188.71,115.15 193.23,110.63 v3(193.26,110.63) ; v3(25.06,106.05) 24.79,105.78 24.79,98.93 24.25,98.38 24.25,91.68 25.3,90.62 25.3,86.96 26.27,86 26.27,83.01 26.96,82.32 26.96,75.59 25.63,74.26 25.63,71.44 v3(22.69,68.5) ; v3(171.43,166.01) 171.43,171.06 170.18,172.31 170.18,175.69 v3(170.31,175.82) ; v3(184.95,103.74) 182.47,101.26 v3(180.19,101.26) ; v3(31.73,37.08) 31.7,37.1 25.18,37.1 24.16,36.09 v3(24.16,35.6) ; v3(45.51,33.05) 47.67,30.89 47.67,29.85 52.54,24.97 53.5,24.97 55.42,26.89 59.49,26.89 v3(60.35,27.76) 61.12,26.99 65.89,26.99 69.35,30.45 74.86,30.45 74.88,30.47
  IN2 w0.762: 108.67,16.17 101.88,16.17 v3(99.27,13.56) 96.65,16.17 71.33,16.17 67.49,12.33 60.81,12.33 57.33,8.86 45.32,8.86 v3(42.24,11.93)
  IN2 w1.016: 117.25,29.03 118.27,29.03 123.63,34.38 ; 173.77,123.82 173.77,131.56 175.86,133.66 v3(175.86,134.73) 175.46,134.73 169.6,140.58 169.6,146.02 ; 60.48,46.17 61.89,44.76 65.09,44.76 67.53,42.32 67.53,37.83 76.29,29.06 115.71,29.06
  BOTTOM w0.254: RP7.10 181.03,99.84 180.19,100.67 v3(180.19,101.26) ; RP7.5 183.57,102.58 184.72,103.74 v3(184.95,103.74)
  BOTTOM w0.305: v3(158.66,86.21) 158.66,86.34 159.04,86.72 R599.1 ; C367.2 168.87,158.53 168.29,159.12 168.29,160.33 168.59,160.64 U18.5 ; R620.2 158.9,84.73 v3(158.4,84.23) ; v3(156.37,84.1) 156.75,84.48 R618.2 ; R600.1 v3(160.56,86.26) ; R631.1 v3(158.28,82.07) ; v3(135.42,58.41) 135.6,58.41 135.85,58.65 JDIM1.199 ; R598.2 156.65,86.77 v3(156.24,86.36)
  BOTTOM w0.356: v3(135.52,48.43) 135.57,48.38 135.58,48.38 135.85,48.1 JDIM2.199
  BOTTOM w0.381: R622.1 v3(151.03,84.02) 152.61,82.44 153.37,82.44 154.35,83.42 R628.2 ; v3(184.95,103.74) 185.5,104.29 186.14,104.29 187.1,105.25 187.1,106.11 186.62,106.6 R508.2 186.4,106.48 185.93,106.01 185.07,106.01 184.31,105.25 R515.2 ; R727.1 102.97,5.31 99.27,9.01 v3(99.27,13.56) ; v3(51.35,93.26) 51.16,93.26 50.74,93.68 PR118.2 ; R596.2 154.28,86.89 v3(153.9,87.27) ; v3(157.72,88.93) 158.02,89.23 R568.2 ; R536.2 178.13,100.3 178.41,100.58 179.51,100.58 v3(180.19,101.26) ; PR120.2 49.98,90.71 v3(50.3,91.03) ; v3(105.54,178.1) 105.49,178.15 104.57,178.15 104.18,177.75 104.18,158.63 v3(105.51,157.3)
  BOTTOM w0.508: R677.2 155.09,53.46 R678.2 ; R677.2 154.77,53.48 v3(153.39,54.85) ; R677.2 155.82,53.48 Q54.2 157.24,54.42 157.78,53.88 157.78,51.5 Q55.2 ; v3(141.03,188.23) 141.03,189.4 140.03,190.39 138.83,190.39 138.5,190.06 129.67,190.06 127.61,188 127.61,185.92 127.33,185.64 125.45,185.64 124.13,186.96 118.44,186.96 v3(117.86,187.55) ; R510.1 60.14,105.8 60.61,106.27 v3(60.61,108.84) 62.14,107.31 R513.1 ; v3(180.67,106.51) 180.71,106.47 R509.2 R514.2 180.3,104.33 R517.2 ; v3(25.07,50.54) 34.12,50.54 v3(34.19,50.62) ; R693.2 30.84,35 31.14,34.71 R690.2 32.5,36.31 v3(31.73,37.08) 32.06,37.41 40.65,37.41 45.01,33.05 v3(45.51,33.05) ; v3(147.68,126.21) 149.43,127.96 149.43,131.49 150.3,132.35 150.3,134.36 151.95,136.01 154.02,136.01 157.35,139.34 PR137.2 ; v3(40.02,83.38) 40.02,83.04 38.26,81.27 38.26,75 31.75,68.5 v3(22.69,68.5) ; v3(184.95,103.74) 184.95,98.87 187.37,96.45 187.37,95.47 186.91,95.02 186.91,94.39 186.66,94.15 R551.2 186.26,92.97 R559.2 185.79,92.28 185.16,91.65 183.36,91.65 v3(183.3,91.71) 183.3,93.88 R555.2 183.65,93.88 183.94,93.59 184.41,93.59 184.68,93.86 R556.2 ; R746.1 v3(175.7,11.45) ; L33.1 169.93,19.04 174.53,19.04 175.19,18.38 175.19,15.49 174.83,15.13 v3(174.83,15.06) ; v3(193.1,107.99) 193.1,107.61 192.11,106.62 192.11,103.37 193.83,101.65 193.83,101.09 194.64,100.29 198.09,100.29 v3(198.2,100.4) ; R656.1 181.72,69.98 182.25,70.51 v3(184.03,70.51) ; PR67.2 191.95,116 193.25,114.7 193.25,110.64 v3(193.26,110.63)
  BOTTOM w1.016: 154.07,43.87 151.59,46.35 151.59,52.54 152.92,53.86
  vias: v2(169.62,153.51) v3(41.37,12.13) v3(58.78,46.86) v3(58.83,46.17) v3(109.61,16.66) v3(110.29,16.71) v3(115.6,27.83) v3(116.46,27.83) v3(124.77,34.89) v3(125.53,34.87) v3(138.21,113.89) v3(138.74,114.45) v3(145.59,21.41) v3(146.36,21.41) v3(152.15,91.9) v3(152.15,91.23) v3(152.79,55.38) v3(155.66,43.5) v3(155.86,88.48) v3(156.32,43.5) v3(165.61,156.15) v3(165.58,155.47) v3(167.57,45.98) v3(168.26,45.98) v3(168.81,156.25) v3(169.5,156.38) v3(169.96,147.9) v3(169.96,147.24) v3(172.67,123.65) v3(172.7,123.01) v3(176.89,114.67)
+3V_BG: length 2.8
  TOP w0.127: R72.1 v2(178.79,113.61)
  TOP w0.508: R72.1 179.99,113.81 Q14.1
+3V_DS3: length 151.5
  TOP w0.381: R203.2 169.54,89.45 170.21,88.78 v3(171.03,88.78)
  TOP w0.508: v3(137.42,115.54) 137.42,115.69 140.95,119.22 144.87,123.14 144.87,124.86 147.31,127.3 153.85,127.3 155.43,125.72 165.36,125.72 166.25,126.62 166.71,126.62 167.26,127.17 172.64,127.17 173.63,126.18 173.63,120.88 176.59,117.93 180.63,117.93 181.19,117.37 183.16,117.37 183.37,117.16 v3(185.73,117.16) ; v3(150.09,75.61) 151.29,76.81 158.59,76.81 v2(158.93,77.16) 159.35,77.57 160.22,77.57 163.01,80.36 168.12,80.36 169.93,82.16 169.93,84.26 170.99,85.31 170.99,88.74 v3(171.03,88.78)
  IN1 w0.508: v3(146.88,91.29) 146.68,91.49 141.83,91.49 135.07,98.25 135.07,112.9 136.86,114.69 v3(137.42,115.54)
  IN2 w0.508: v3(150.09,75.61) 148.64,77.06 148.64,82.74 148.04,83.35 148.04,90.13 v3(146.88,91.29)
  BOTTOM w0.305: v3(171.03,88.78) 170.98,88.83 R579.2
  BOTTOM w0.508: Q49.3 189.54,114.32 188.61,115.24 R481.2 188.61,117.06 C419.2 188.51,117.16 v3(185.73,117.16)
+3V_DSW: length 33.1
  TOP w0.254: R151.1 177.33,97.91 178.08,97.91 178.16,97.99 v2(178.85,97.99) 178.97,97.86 180.01,97.86 ; 180.01,97.86 180.49,98.34 180.49,100.49 180.72,100.73 180.72,101.52 180.27,101.97 R136.1 ; 180.01,97.86 180.29,97.58 v3(180.29,97.1) 180.15,96.95 R160.2 ; R197.2 v3(180.41,90.41) 181.35,89.48 182.07,89.48 182.5,89.05 182.5,87.8 182.86,87.44 183.35,87.44 184.54,86.25 Q28.2 188.1,86.25 189.17,87.32 D3.1 189.17,89.33 R216.2
  BOTTOM w0.254: v3(180.41,90.41) 181.69,91.69 181.69,96.22 181.14,96.76 180.63,96.76 v3(180.29,97.1)
+3V_EC: length 1.1
  TOP w0.203: U13.11 166.44,57.13
  vias: v2(164.52,58.26)
+3V_GFX: length 213.1
  TOP w0.508: v3(149,163.95) 149.47,164.42 v3(149.47,164.5) 149.43,164.54 149.43,169.59 149.04,169.98 R15.2 148.7,170.96 ; v3(152.03,186.6) 150.25,184.82 149.87,184.82 C719.2 149.06,183.64 148.08,182.67 148.08,181.26 148.16,181.19 148.16,179.73 147.73,179.3 147.73,175.64 147.27,175.17 147.27,172.39 148.7,170.96 ; 148.7,170.96 v3(150.18,172.45) ; v3(148.4,50.2) 148.4,50.2 151.04,52.85 161.27,52.85 R308.2
  IN1 w0.508: v3(150.98,170.81) 150.18,171.61 v3(150.18,172.45) ; v3(152.03,186.6) 152.13,186.49 154.49,186.49 154.63,186.63 156.62,186.63 158.53,184.72 160.83,184.72 161.42,184.13 v3(161.42,183.63) ; v3(152.07,152.11) 152.38,152.11 154.97,149.52 154.97,144.04 v3(155.96,143.05)
  BOTTOM w0.508: Q45.2 168.4,175.77 R402.2 165.71,174.26 v3(164.67,173.22) ; R423.2 166.15,162.52 166.7,161.97 166.7,160.74 R430.1 166.1,159.38 164.7,157.98 R433.2 ; Q26.2 166.78,169.92 v3(164.72,169.92) R406.1 R407.2 R408.2 ; R439.2 R440.2 167.12,149.1 R444.2 ; R444.2 167.12,147.4 167.13,147.39 PQ47.1 166.56,145.79 165.64,146.7 164.34,146.7 163.66,146.02 158.93,146.02 v3(155.96,143.05) 155.96,141.53 154.15,139.72 R451.2 153.25,138.57 146.07,131.39 146.07,126.06 145.57,125.56 145.57,122.88 142.7,120.01 142.7,116.57 137.1,110.97 136.84,110.97 134.27,108.4 134.27,69.6 147.58,56.29 147.58,53.68 148.4,52.86 v3(148.4,50.2) ; R444.2 167.52,148.2 167.71,148.4 R733.2 ; R399.2 v3(161.38,175.62)
  vias: v2(162.08,161.46) v3(151.26,152.11) v3(161.4,182.97) v3(163.83,172.33) v3(163.99,172.99) v3(166.88,165.27) v3(166.86,164.61) v3(166.86,163.95) v3(166.86,163.04)
+3V_MAIN: length 3.1
  BOTTOM w0.305: v3(151.12,163.74) 151.25,163.74 U19.G8 ; U19.G9 150.81,164.19 v3(150.36,163.74)
  BOTTOM w0.381: v3(150.65,176.09) 150.12,176.09 R394.2 ; R386.1 150.71,178.77 150.42,179.06 v3(150.05,179.06)
  vias: v2(151.67,179.77)
+3V_PCH_ME: length 17.8
  BOTTOM w0.127: R652.1 151.31,77.92 151.64,77.59 v2(151.64,77.41)
  BOTTOM w0.508: R644.1 C501.1 150.73,78.95 R652.1 149.38,77.92 149.13,77.67 U30.8 149.13,76.06 144.33,71.26 R657.1
+3V_RTC: length 71.7
  TOP w0.203: U13.3 166.59,60.33
  TOP w0.508: v3(166.3,75.93) 175.39,75.93 175.92,76.47 v2(175.92,77.26) 175.92,79.57 175.42,80.08 v3(175.19,80.08) ; R183.1 175.87,92.38 176.25,92.76 176.25,93.14 176.57,93.46 R173.1 176.57,94.27 176.19,94.64 R171.1 176.19,95.18 176.79,95.78 177.01,95.78 177.63,96.39 R158.1 177.76,97.27 v3(179.3,97.27) ; 166.59,60.33 166.36,60.33 165.82,60.86 C237.1 165.17,62.57 162.97,64.77 v3(162.97,66.3)
  IN1 w0.508: v3(166.3,75.93) 165.55,75.93 163.4,73.78 163.4,66.71 162.99,66.3 v3(162.97,66.3)
  BOTTOM w0.254: U24.A6 171.73,97.62 172.32,97.03 173.02,97.03
  BOTTOM w0.508: 179.86,87.8 179.86,88.64 181.88,90.66 D22.3 182.35,90.71 182.35,96.58 C475.2 180.99,97.3 180.56,97.73 179.99,97.73 179.53,97.27 v3(179.3,97.27) ; v3(179.3,97.27) 179.21,97.18 C481.1 177.4,97.16 C483.1 C482.2 174.76,97.03 173.02,97.03 ; v3(179.3,97.27) 179.18,97.39 179.18,98.6 R542.2 ; 178.19,85.01 178.19,84.8 177.09,83.7 177.09,82.05 175.19,80.15 v3(175.19,80.08)
