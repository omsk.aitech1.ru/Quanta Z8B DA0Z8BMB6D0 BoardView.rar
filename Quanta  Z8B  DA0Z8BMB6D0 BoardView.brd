# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDI_0+: length 19
  TOP w0.102: v3(26.26,93.95) 26.46,93.95 26.71,94.21 26.71,95.5 26.64,95.57 26.57,95.57 26.52,95.62 U7.1
  BOTTOM w0.127: v3(26.26,93.95) 26.49,93.95 26.59,93.85 26.59,92.97 27.39,92.17 28.22,92.17 28.76,92.7 28.76,93.19 28.96,93.39 29.52,93.39 29.72,93.19 29.72,91.66 32.31,89.07 32.31,85.24 31.61,84.54 31.42,84.54 31.28,84.68 R626.1
MDI_0+_C: length 7
  TOP w0.127: U9.6 31.84,82.98 31.57,83.25 31.57,83.47 30.32,84.72 29.55,84.72 v3(29.36,84.91)
  BOTTOM w0.127: R626.2 30.2,84.63 29.64,84.63 v3(29.36,84.91) 29.17,84.72 28.79,84.72 28.5,85.01 U29.1
MDI_0-: length 19
  TOP w0.102: v4(27.09,93.91) 26.92,94.08 U7.2
  BOTTOM w0.127: v4(27.09,93.91) 27.1,93.91 27.1,93.18 27.6,92.68 28.01,92.68 28.25,92.91 28.25,93.4 28.75,93.9 29.73,93.9 30.23,93.4 30.23,91.87 32.82,89.28 32.82,85.03 31.82,84.03 31.52,84.03 R629.1
MDI_0-_C: length 6.9
  TOP w0.127: v3(29.36,84.02) 29.55,84.21 30.11,84.21 31.07,83.26 31.07,83.08 30.97,82.98 U9.1
  BOTTOM w0.127: R629.2 30.16,84.12 29.47,84.12 v3(29.36,84.02) 29.17,84.21 28.82,84.21 28.35,83.74 U29.2
MDI_1+: length 27.2
  TOP w0.102: 28.05,94.35 28.05,94.38 28.2,94.53 28.2,94.65 27.91,94.93 27.91,95.53 27.72,95.72 U7.4
  TOP w0.127: 28.05,94.35 28.05,93.79 29.77,92.07 31.93,92.07 32.04,91.96 v3(32.04,91.84)
  BOTTOM w0.127: R643.1 30.7,79.49 30.81,79.37 31.58,79.37 31.79,79.57 31.79,80.54 31.58,80.74 30.4,80.74 29.9,81.24 29.9,82.17 30.4,82.67 32.23,82.67 33.71,84.15 33.71,90.92 32.43,92.19 32.24,92.19 32.04,92 v3(32.04,91.84)
MDI_1+_C: length 7.8
  TOP w0.127: U9.3 30.75,81.08 30.95,80.88 30.95,79.63 30.68,79.37 29.23,79.37 v3(28.87,79.72)
  BOTTOM w0.127: U29.5 28.09,79.93 28.48,79.54 28.69,79.54 v3(28.87,79.72) 29.2,79.39 29.65,79.39 29.92,79.66 R643.2
MDI_1-: length 27.2
  TOP w0.102: U7.5 28.12,95.02 28.4,94.73 28.4,94.53 28.55,94.38 28.55,94.35
  TOP w0.127: v4(32.07,92.7) 31.94,92.58 29.98,92.58 28.55,94 28.55,94.35
  BOTTOM w0.127: v4(32.07,92.7) 32.64,92.7 34.22,91.13 34.22,83.93 32.45,82.16 30.61,82.16 30.41,81.96 30.41,81.45 30.61,81.25 31.79,81.25 32.29,80.75 32.29,79.36 31.79,78.86 30.88,78.86 R650.1
MDI_1-_C: length 8.1
  TOP w0.127: U9.4 31.85,81.08 31.46,80.69 31.46,79.42 30.9,78.86 29.29,78.86 v3(28.88,78.45)
  BOTTOM w0.127: R650.2 29.7,78.89 29.31,78.89 v3(28.88,78.45) 28.65,78.69 28.65,78.88 28.49,79.03 28.44,79.03 28.07,78.66 U29.6
MDI_2+: length 33.9
  TOP w0.102: U7.6 28.52,95.68 28.57,95.63 28.66,95.63 28.71,95.58 28.71,95.26 28.97,95 29.33,94.65 29.71,94.65 29.87,94.5 29.89,94.5
  TOP w0.127: v3(31.56,93.47) 31.31,93.71 30.81,93.71 30.02,94.5 29.89,94.5
  BOTTOM w0.127: v3(31.56,93.47) 31.56,93.59 31.64,93.67 32.94,93.67 35.11,91.5 35.11,83.57 34.9,83.36 34.9,82.58 34.64,82.31 33.86,82.31 33.41,81.86 33.41,80.78 33.86,80.33 34.9,80.33 35.11,80.12 35.11,79.64 34.9,79.44 33.58,79.44 33.08,78.94 33.08,78.01 33.58,77.51 34.26,77.51 34.46,77.31 34.46,76.82 34.26,76.61 30.71,76.61 30.44,76.88 30.44,77.12 R651.1
MDI_2+_C: length 6.2
  TOP w0.127: v3(28.81,77.17) 29.07,76.9 30.31,76.9 30.69,76.52 31.07,76.52 31.31,76.76 U10.6
  BOTTOM w0.127: R651.2 29.54,77 28.97,77 v3(28.81,77.17) 28.63,76.99 28.46,76.99 28.07,77.39 U29.7
MDI_2-: length 33.9
  TOP w0.102: 29.89,95.01 29.87,95.01 29.71,94.85 29.41,94.85 29.12,95.15 28.92,95.35 U7.7
  TOP w0.127: v4(31.56,94.22) 31.02,94.22 30.23,95.01 29.89,95.01
  BOTTOM w0.127: v4(31.56,94.22) 31.6,94.18 33.15,94.18 35.62,91.71 35.62,83.36 35.41,83.15 35.41,82.37 34.85,81.81 34.07,81.81 33.91,81.65 33.91,80.99 34.07,80.83 35.11,80.83 35.62,80.33 35.62,79.43 35.11,78.93 33.79,78.93 33.58,78.73 33.58,78.22 33.79,78.02 34.47,78.02 34.97,77.52 34.97,76.61 34.47,76.11 R653.1
MDI_2-_C: length 6.2
  TOP w0.127: U10.1 31.31,75.82 31.11,76.02 30.48,76.02 30.1,76.4 28.92,76.4 v3(28.81,76.28)
  BOTTOM w0.127: U29.8 28.04,76.12 28.41,76.48 28.6,76.48 v3(28.81,76.28) 29.01,76.49 29.53,76.49 R653.2
MDI_3+: length 34
  TOP w0.102: 30.79,96.23 30.79,96.26 30.94,96.41 30.94,96.94 30.84,97.04 30.74,97.04 30.64,96.94 U7.9
  TOP w0.127: v3(32.08,95.08) 31.96,95.2 31.44,95.2 30.79,95.85 30.79,96.23
  BOTTOM w0.127: v3(32.08,95.08) 32.25,95.24 33.35,95.24 36.59,92 36.59,76.97 31.19,71.57 30.58,71.57 30.37,71.78 30.37,71.98 R654.1
MDI_3+_C: length 11.9
  TOP w0.127: v3(28.86,72.09) 29.03,71.91 31.25,71.91 34.19,74.86 34.19,75.64 33.89,75.94 33.51,75.94 33.21,75.64 U10.3
  BOTTOM w0.127: U29.11 28.04,72.31 28.44,71.91 28.68,71.91 v3(28.86,72.09) 29.02,71.93 29.53,71.93 R654.2
MDI_3-: length 34
  TOP w0.102: 31.3,96.23 31.3,96.26 31.14,96.41 31.14,97.02 30.92,97.24 30.74,97.24 30.64,97.34 U7.10
  TOP w0.127: v4(32.08,95.84) 31.96,95.71 31.65,95.71 31.3,96.06 31.3,96.23
  BOTTOM w0.127: v4(32.08,95.84) 32.17,95.75 33.57,95.75 37.1,92.21 37.1,76.76 31.4,71.06 R655.1
MDI_3-_C: length 13.8
  TOP w0.127: v3(28.86,71.21) 29.05,71.4 31.46,71.4 34.7,74.64 34.7,75.85 34.1,76.45 33.38,76.45 33.21,76.62 U10.4
  BOTTOM w0.127: 28.86,71.2 29.07,71.42 29.58,71.42 R655.2 ; 28.86,71.2 v3(28.86,71.21) ; 28.86,71.2 28.65,71.4 28.39,71.4 28.02,71.04 U29.12
MFG_MODE: length 11.9
  TOP w0.127: v3(153.03,90.79) 152.56,90.32 R205.1 R204.1 150.66,90.21 v2(150.63,90.24)
  IN2 w0.133: v3(156.55,97.92) 155.51,96.88 155.51,94.77 154.29,93.55 154.29,92.05 v3(153.03,90.79)
  BOTTOM w0.102: U24.AT7 156.76,97.92 v3(156.55,97.92)
MIC2-VREFO: length 40.7
  TOP w0.102: R283.1 5.74,11.46 v3(5.74,11.19) v2(5.74,10.51)
  TOP w0.381: v3(18.73,26.53) 19.09,26.89 R355.1
  IN1 w0.381: 18.73,24.53 20.13,23.13 24.63,23.13 25.51,24.01 28.25,24.01 v3(29.05,24.81) ; 18.73,24.53 17.29,23.09 17.29,13.64 14.89,11.24 13.18,11.24 12.98,11.05 11.23,11.05 10.19,12.08 6.63,12.08 v3(5.74,11.19) ; 18.73,24.53 v3(18.73,26.53)
MOD_EN_5V: length 10
  TOP w0.508: Q19.3 195.13,97.56 194.34,96.77 R159.1 194.12,96.39 193.65,95.93 190.94,95.93 190.25,95.25 190.25,94.48 192.04,92.69
  vias: v2(192.05,92.88)
MS_BS: length 1.3
  BOTTOM w0.127: U32.11 30.14,9.37 TP169.1
MS_INS: length 2.2
  BOTTOM w0.127: TP166.1 34.32,11.07 33.44,11.94 U32.5
MX0: length 54.3
  TOP w0.127: v3(178.13,24.35) 177.5,24.35 176.94,23.79 RP2.4 176.94,20.24 176.61,19.91 175.97,19.91 175.8,19.73 175.8,18 176.4,17.4 C333.2 176.77,17.24 178.72,17.24 179.63,18.15 179.63,20.18 v2(180.37,20.92) 181,21.56 181,21.69 182.17,22.85 184.1,22.85 186.18,24.93 186.18,28.24 184.92,29.51 184.92,43.33 183.01,45.23 182.78,45.23 182.07,45.95 182.07,47.85 181.89,48.03 179.33,48.03 179.23,47.93 U13.58
  BOTTOM w0.127: CN14.26 179,23.21 178.3,23.91 178.3,24.19 v3(178.13,24.35)
MX1: length 45.5
  TOP w0.127: U13.59 179.63,43.42 179.07,42.87 177.98,42.87 v3(177.6,43.25) ; v3(176.86,26) v2(176.86,25.14) 176.53,24.81 176.53,21.73 176.3,21.5 RP2.5 176.3,20.28 176.18,20.16 175.87,20.16 175.54,19.83 175.54,17.48 C332.2
  IN1 w0.133: v3(177.6,43.25) 177.6,43.02 178.64,41.98 181.41,41.98 182.96,40.42 182.96,28.39 182.1,27.53 178.39,27.53 v3(176.86,26)
  BOTTOM w0.127: CN14.25 178.01,22.21 178.01,23.82 176.86,24.96 v3(176.86,26)
MX2: length 88.3
  TOP w0.127: v3(177.45,23.61) 177.57,23.49 RP2.3 ; v3(175.54,26.05) 175.54,23.49 v2(174.43,22.37) 173.92,21.86 CP6.6 ; v3(176.94,43.12) 177.45,42.61 179.2,42.61 180.03,43.44 U13.60
  IN1 w0.133: v3(176.94,43.12) 176.36,42.54 166.73,42.54 165.76,41.57 151.42,41.57 149.18,39.33 149.18,28.54 149.38,28.34 173.26,28.34 v3(175.54,26.05)
  IN2 w0.133: v3(175.54,26.05) 175.54,25.52 v3(177.45,23.61)
  BOTTOM w0.127: CN14.24 177,23.17 v3(177.45,23.61)
MX3: length 45.4
  TOP w0.127: v3(176,23.64) 176,22.72 v2(175.8,22.52) 174.7,21.43 CP6.8 ; U13.61 180.43,46.06 182.35,44.14 182.6,44.14 183.9,42.84 183.9,29.03 185.17,27.76 185.17,25.44 184.08,24.35 v3(179.61,24.35) 179.61,22.53 178.84,21.77 RP2.1
  BOTTOM w0.127: CN14.23 v3(176,23.64) 176,25.9 176.61,26.51 177.45,26.51 v3(179.61,24.35)
MX4: length 55.8
  TOP w0.127: U13.62 180.83,46.04 182.48,44.39 182.73,44.39 184.15,42.97 184.15,29.13 185.42,27.86 185.42,25.29 183.76,23.63 181.06,23.63 179.33,21.9 179.33,20.31 179.12,20.11 178.49,20.11 178.21,19.83 RP2.9 178.21,17.71 v3(178.23,17.68) ; CP5.2 168.25,22.11 171.2,25.06 173.99,25.06 v2(174.35,24.71) 174.91,24.15 v3(174.92,24.15)
  IN1 w0.133: v3(178.23,17.68) 178.23,20.37 174.92,23.68 v3(174.92,24.15)
  BOTTOM w0.127: CN14.22 175,24.07 v3(174.92,24.15)
MX5: length 55.4
  TOP w0.127: RP2.7 176.94,18.27 v3(177,18.2) ; U13.63 181.23,46.02 182.53,44.72 182.78,44.72 184.41,43.09 184.41,29.25 185.68,27.98 185.68,25.16 183.87,23.36 181.15,23.36 180.45,22.65 v3(180.45,22.09) ; CP5.4 169.04,22.01 v2(169.04,22.01) 169.04,22.02 169.04,22.49 171.35,24.81 173.33,24.81 174.12,24.03 v3(174.12,23.55)
  IN1 w0.133: v3(174.12,23.55) 174.12,23.34 176.99,20.47 176.99,18.22 v3(177,18.2)
  BOTTOM w0.127: v3(174.12,23.55) 174,23.43 CN14.21 ; v3(177,18.2) 178.34,18.2 178.81,17.73 179.18,17.73 179.44,18 179.44,18.58 180.15,19.29 180.15,21.79 180.45,22.09 v3(180.45,22.09)
MX6: length 56.3
  TOP w0.127: U13.64 181.63,46.02 182.68,44.98 182.91,44.98 184.66,43.22 184.66,29.38 185.93,28.11 185.93,25.04 184,23.11 181.56,23.11 v3(181,22.55) ; v3(173.47,23.84) 172.78,24.53 171.58,24.53 170.24,23.18 v2(170.24,22.85) 169.85,22.47 CP5.6 ; RP2.8 v3(177.57,17.72)
  IN1 w0.133: v3(177.57,17.72) 177.57,20.62 174.64,23.55 174.64,23.75 174.27,24.12 173.75,24.12 v3(173.47,23.84)
  BOTTOM w0.127: v3(173.47,23.84) 173.47,23.5 173.01,23.04 173,23.04 CN14.20 ; v3(181,22.55) 181,21.76 180.41,21.16 180.41,19.18 179.69,18.47 179.69,17.89 179.04,17.24 178.05,17.24 v3(177.57,17.72)
MX7: length 55.9
  TOP w0.127: v3(181.51,21.56) 182.55,22.6 184.23,22.6 186.44,24.81 186.44,28.39 185.17,29.66 185.17,43.45 183.28,45.34 183.28,47.4 184.13,48.25 184.13,48.61 184.01,48.73 U13.65 ; v3(171.34,23.48) 171.34,22.13 v2(171.3,22.09) 170.64,21.43 CP5.8 ; RP2.6 v3(176.3,18.18)
  IN1 w0.133: v3(171.34,23.48) 171.87,22.95 173.97,22.95 176.3,20.62 v3(176.3,18.18)
  BOTTOM w0.127: CN14.19 172,22.99 171.51,23.48 v3(171.34,23.48) ; v3(181.51,21.56) 181.18,21.56 180.66,21.04 180.66,19.08 179.95,18.37 179.95,17.78 179.15,16.99 177.63,16.99 177.06,17.56 176.93,17.56 v3(176.3,18.18)
MY0: length 60.4
  TOP w0.127: U13.36 170.43,46.33 170.74,46.02 170.74,45.43 169.7,44.38 165.82,44.38 164.89,45.31 149.47,45.31 146.92,42.76 146.92,26.48 148.77,24.63 v2(149.2,24.63) 151.52,24.63 152.48,23.67 CP1.2 152.48,22.62 152.35,22.5 152.1,22.5 151.08,21.48 v3(151.08,20.59)
  BOTTOM w0.127: v3(151.08,20.59) 151.38,20.29 152.03,20.29 152.24,20.5 152.24,21.98 153.52,23.26 153.88,23.26 154,23.14 CN14.1
MY1: length 61.5
  TOP w0.127: v3(151.74,20.77) 151.74,21.74 152.19,22.18 152.9,22.18 153.27,22.55 CP1.4 153.27,23.69 v2(152.12,24.83) 151.77,25.19 148.64,25.19 147.17,26.66 147.17,42.65 149.57,45.05 158.12,45.05 158.98,44.19 163.78,44.19 164.37,44.77 165.07,44.77 165.71,44.13 169.81,44.13 171,45.33 171,46.17 170.83,46.34 U13.37
  BOTTOM w0.127: CN14.2 155,23.2 154.66,23.54 153.39,23.54 151.74,21.89 v3(151.74,20.77)
MY2: length 61.2
  TOP w0.127: U13.38 171.23,45.19 169.89,43.86 158.94,43.86 158.02,44.78 149.66,44.78 147.43,42.55 147.43,26.76 148.68,25.51 152.39,25.51 v2(153.65,24.25) 154.08,23.82 CP1.6 154.08,22.4 154.18,22.29 155.2,22.29 155.64,22.74 155.64,23.98 156.08,24.42 156.08,24.85 v3(155.5,25.42)
  BOTTOM w0.127: CN14.3 156,22.87 155.13,23.73 155.13,25.05 v3(155.5,25.42)
MY3: length 57.9
  TOP w0.127: U13.39 171.63,45.23 170,43.6 158.8,43.6 157.93,44.47 149.71,44.47 147.68,42.44 147.68,26.92 148.85,25.76 153.08,25.76 v2(153.32,25.52) 154.87,23.97 CP1.8 155.16,23.04 155.3,23.18 155.3,24.28 v3(155.58,24.55)
  BOTTOM w0.127: v3(155.58,24.55) 155.58,23.67 156,23.24 156.87,23.24 157,23.11 CN14.4
MY4: length 63.2
  TOP w0.127: v3(156.74,23.74) 156.74,22.23 156.31,21.81 CP2.2 156.56,20.81 156.7,20.95 156.7,21.5 157.18,21.98 157.18,24.48 v2(156.62,25.04) 155.58,26.08 148.89,26.08 147.94,27.03 147.94,42.33 149.8,44.2 157.84,44.2 158.7,43.35 170.1,43.35 172.03,45.28 U13.40
  BOTTOM w0.127: v3(156.74,23.74) 157.41,23.74 158,23.15 CN14.5
MY5: length 68
  TOP w0.127: U13.41 172.43,45.32 170.21,43.09 158.59,43.09 157.74,43.95 149.91,43.95 148.19,42.23 148.19,27.14 148.99,26.33 156.06,26.33 157.43,24.96 157.43,21.79 157.1,21.45 CP2.4 157.1,20.21 156.87,19.98 155.91,19.98 155.55,20.34 155.55,21.86 v2(156.01,22.32) 156.09,22.4 v3(156.09,23.79)
  BOTTOM w0.127: CN14.6 159,23.04 157.81,24.22 156.52,24.22 v3(156.09,23.79)
MY6: length 64.2
  TOP w0.127: U13.42 172.83,45.36 170.31,42.84 149.17,42.84 148.44,42.12 148.44,27.24 149.1,26.59 156.19,26.59 157.91,24.86 CP2.6 157.91,20.14 158.1,19.94 159.32,19.94 159.72,20.34 159.72,22.55 v2(159.85,22.68) 159.95,22.78 v3(159.95,23.51)
  BOTTOM w0.127: CN14.7 160,23.46 v3(159.95,23.51)
MY7: length 63.7
  TOP w0.127: v3(159.21,23.46) 159.21,20.96 159.06,20.81 CP2.8 158.7,24.09 v2(158.7,24.1) 158.7,24.48 156.34,26.84 149.2,26.84 148.7,27.35 148.7,42.01 149.27,42.59 170.42,42.59 173.23,45.4 U13.43
  BOTTOM w0.127: CN14.8 161,23.5 160.51,24 159.74,24 v3(159.21,23.46)
MY8: length 60.2
  TOP w0.127: v3(161.75,23.59) 161.75,23.1 v2(161.24,22.6) 160.25,21.61 CP3.2 ; U13.44 173.63,45.44 173.28,45.09 173.28,44.08 v3(173.15,43.96)
  IN1 w0.133: v3(161.75,23.59) 157.27,28.07 149.27,28.07 148.91,28.43 148.91,39.45 151.31,41.85 165.65,41.85 166.62,42.81 172,42.81 v3(173.15,43.96)
  BOTTOM w0.127: CN14.9 162,23.34 v3(161.75,23.59)
MY9: length 63.9
  TOP w0.127: U13.45 174,47.05 174,44.1 172.24,42.33 149.38,42.33 148.95,41.91 148.95,27.45 149.31,27.09 159.16,27.09 v2(160.89,25.37) v3(162.31,23.95) 162.31,22.7 161.04,21.43 CP3.4
  BOTTOM w0.127: v3(162.31,23.95) 163,23.26 CN14.10
MY10: length 65.5
  TOP w0.127: U13.46 174.43,45.74 174.26,45.57 174.26,43.99 172.34,42.08 149.48,42.08 149.21,41.8 149.21,27.56 149.41,27.35 160.65,27.35 v2(161.07,26.93) v3(164,24) 164,23.7 161.85,21.55 CP3.6
  BOTTOM w0.127: v3(164,24) CN14.11
MY11: length 67.8
  TOP w0.127: v3(175.29,43.45) 175.34,43.5 175.34,44.14 175.58,44.37 175.58,45.47 176.43,46.32 U13.51 ; CP3.8 162.64,21.48 v2(164.11,22.95) 165,23.84 v3(165,24)
  BOTTOM w0.127: v3(175.29,43.45) 174.08,42.25 150.83,42.25 149.31,40.73 149.31,28.76 150.64,27.43 163.19,27.43 165,25.62 v3(165,24) CN14.12
MY12: length 68.4
  TOP w0.127: v3(175.8,43.96) 175.8,44.09 176.05,44.34 176.05,45.08 176.83,45.86 U13.52 ; v3(166,24) 166,23.52 v2(165.76,23.28) 164.31,21.83 CP4.2
  BOTTOM w0.127: v3(175.8,43.96) 175.75,43.91 175.75,43.25 174.49,41.99 150.93,41.99 149.56,40.62 149.56,28.87 150.74,27.68 163.94,27.68 166,25.62 v3(166,24) CN14.13
MY13: length 69.5
  TOP w0.127: U13.53 177.23,45.65 176.71,45.12 176.71,44.28 v3(176.46,44.04) ; CP4.4 165.1,21.61 v2(165.49,21.99) 167,23.5 v3(167,24.05)
  BOTTOM w0.127: CN14.14 v3(167,24.05) 167,25.91 164.97,27.94 150.85,27.94 149.82,28.97 149.82,40.51 151.04,41.74 174.65,41.74 176,43.09 176,43.45 176.46,43.91 v3(176.46,44.04)
MY14: length 70.3
  TOP w0.127: U13.54 177.63,45.61 177.17,45.15 177.17,43.86 v3(177.09,43.78) ; v3(168,24.02) 168,23.69 v2(167.06,22.75) 165.91,21.61 CP4.6
  BOTTOM w0.127: CN14.15 v3(168,24.02) 168,25.65 165.45,28.19 150.95,28.19 150.07,29.08 150.07,40.4 151.14,41.47 174.76,41.47 176.36,43.07 176.36,43.27 176.86,43.78 v3(177.09,43.78)
MY15: length 44.8
  TOP w0.127: v3(169.01,24) 169.01,23.91 v2(168.43,23.34) 166.7,21.61 CP4.8 ; v3(177.73,43.99) 177.63,44.09 177.63,45.05 178.03,45.46 U13.55
  IN1 w0.133: v3(169.01,24) 170.46,25.45 178.29,25.45 180.06,27.23 182.18,27.23 183.24,28.28 183.24,40.53 181.52,42.25 178.83,42.25 178.08,43 178.08,43.43 177.73,43.78 v3(177.73,43.99)
  BOTTOM w0.127: v3(169.01,24) 169,22.46 CN14.16
MY16: length 43.3
  TOP w0.127: CP6.2 v2(172.32,22.98) v3(172.32,24) ; U13.56 178.43,43.87 v3(178.36,43.81)
  IN1 w0.133: v3(172.32,24) 172.32,23.98 173.51,25.18 178.4,25.18 180.18,26.95 182.3,26.95 183.52,28.17 183.52,40.74 180.98,43.27 179.91,43.27 179.46,42.82 178.69,42.82 178.36,43.15 v3(178.36,43.81)
  BOTTOM w0.127: CN14.17 170,23.56 170.77,24.33 171.99,24.33 v3(172.32,24)
MY17: length 42.3
  TOP w0.127: U13.57 178.83,43.33 v3(178.85,43.32) ; v3(172.82,23.49) 173.1,23.21 v2(173.1,21.96) CP6.4
  IN1 w0.133: v3(178.85,43.32) 179.08,43.55 181.09,43.55 183.79,40.85 183.79,28.06 182.41,26.68 180.29,26.68 178.51,24.9 173.84,24.9 172.82,23.89 v3(172.82,23.49)
  BOTTOM w0.127: v3(172.82,23.49) 172.09,23.49 171.63,23.95 171.18,23.95 170.9,23.66 170.9,23.3 171,23.2 CN14.18
N12E_SCL: length 12
  BOTTOM w0.127: U19.C9 150.81,167.72 151.3,168.2 151.3,168.39 151.79,168.89 151.79,169.21 152.5,169.91 152.5,170.37 154.54,172.41 157.07,172.41 157.86,173.2 157.86,173.55 v3(158.2,173.88) 158.21,173.89 R398.1
N12E_SDA: length 16.4
  BOTTOM w0.127: U19.C8 152.14,167.93 152.14,169.19 152.75,169.81 152.75,170.24 154.66,172.15 157.53,172.15 158.91,173.53 158.91,177.16 R391.1 158.19,178.81 v3(158.25,178.86)
NBSWON#: length 258.7
  TOP w0.127: R274.1 164.5,68.44 164.16,68.78 155.47,68.78 152.09,65.4 152.09,63.87 152.61,63.35 v2(152.61,61.55) 152.09,61.03 152.09,54.52 143.4,45.83 143.4,33.47 135.92,25.99 112.96,25.99 v3(112.66,26.29) ; R274.1 166.02,68.44 R276.1 166.55,67.9 168.37,67.9 169.04,67.22 169.04,65.29 170.43,63.91 U13.125 ; R274.1 164.8,68.06 164.47,67.73 SW1.2
  IN1 w0.133: v3(38.63,101.13) 38.49,101.13 37.13,99.77 37.13,96.02 35.51,94.4 35.51,86.84 37.67,84.68 37.67,81.51 36.76,80.59 36.76,72.2 35.94,71.38 35.94,64.85 35.52,64.43 35.52,62.83 34.7,62.01 34.7,52.95 35.82,51.83 35.82,48.48 34.7,47.36 34.7,42.42 40.62,36.5 40.62,35.78 46.84,29.55 46.84,29.08 47.55,28.37 47.55,23.79 52.36,18.98 76.47,18.98 85.1,27.61 111.34,27.61 v3(112.66,26.29)
  BOTTOM w0.127: v3(38.63,101.13) 38.44,100.95 37.25,100.95 37.04,101.16 R532.1 37.04,102 36,103.04 CN4.3
NV_PLLVDD: length 0.6
  BOTTOM w0.381: v3(153.77,160.4) U19.L6
  vias: v2(155.12,155.72)
OBSDAT_A0: length 2
  BOTTOM w0.127: TP120.1 84.58,91.72 R567.2
OBSDAT_A1: length 1.5
  BOTTOM w0.127: R563.2 87.27,90.74 TP126.1
OBSDAT_A2: length 1.3
  TOP w0.127: R152.2 TP41.1
OBSDAT_A3: length 1.4
  BOTTOM w0.127: TP121.1 87.25,91.93 R561.2
OBSDAT_B0: length 1.6
  TOP w0.127: R148.2 85.3,99.64 TP39.1
OBSDAT_B1: length 1.2
  TOP w0.127: R141.2 85.92,100.87 85.63,100.58 TP37.1
OBSDAT_B2: length 3.1
  TOP w0.127: R110.2 88.11,107.45 86.93,107.45 86.33,108.05 TP31.1
OBSDAT_B3: length 1.3
  TOP w0.127: R132.2 86.3,102.09 TP34.1
OBSDAT_C0: length 1.1
  BOTTOM w0.127: R516.1 TP100.1
OBSDAT_C1: length 2.2
  BOTTOM w0.127: TP114.1 86.35,95.52 R550.1
OBSDAT_C2: length 1.5
  BOTTOM w0.127: TP129.1 87.43,89.46 R587.1
OBSDAT_C3: length 1.5
  BOTTOM w0.127: TP105.1 87.16,99.15 R539.1
OBSDAT_D0: length 3.3
  BOTTOM w0.127: TP99.1 86.08,106.39 86.95,107.26 R504.1
OBSDAT_D1: length 1.4
  TOP w0.127: TP30.1 87.3,108.21 R103.1
OBSDAT_D2: length 1.4
  BOTTOM w0.127: R502.1 85.48,107.16 TP96.1
OBSDAT_D3: length 1.4
  BOTTOM w0.127: R511.1 87.51,106.19 TP97.1
OBSFN_B0: length 4
  BOTTOM w0.127: TP95.1 86.67,109.04 v3(86.72,109.09) 86.8,109.09 88.36,110.65 R491.1
OBSFN_B1: length 2.3
  BOTTOM w0.127: R487.1 87.61,112.69 v3(87.58,112.67) TP92.1
OBSFN_C0: length 3.9
  BOTTOM w0.127: R545.1 87.07,97.93 R544.1 86.57,98.43 85.54,98.43 TP110.1
OBSFN_C1: length 4.1
  BOTTOM w0.127: TP113.1 85.76,96.23 86.87,96.23 87.04,96.4 R546.1 R547.1
OBSFN_D0: length 3.8
  BOTTOM w0.127: TP122.1 85.91,92.99 R558.1 87.81,93.12 87.82,93.13 R557.1
OBSFN_D1: length 2.9
  BOTTOM w0.127: R552.1 87.8,94.32 TP117.1 86.71,94.31 R553.1
ODD_DA#: length 38.8
  TOP w0.127: R94.1 194.84,111.57 191.53,111.57 v2(191.52,111.58) 190.61,111.58 185.32,106.29 v3(185.32,105.43)
  IN2 w0.089: 172.11,103.32 172.03,103.4 171.85,103.4 170.41,101.95 169.63,101.95 v3(169.39,101.71)
  IN2 w0.133: v3(185.32,105.43) 185.06,105.17 181.33,105.17 179.68,103.52 175.46,103.52 175.25,103.32 172.11,103.32
  BOTTOM w0.102: U24.F17 169.58,101.9 v3(169.39,101.71)
  BOTTOM w0.127: v3(185.32,105.43) 185.32,105.14 183.75,103.57 181.96,103.57 181.72,103.34 181.72,102.96 181.03,102.27 RP7.1
ODD_EN: length 8.4
  TOP w0.127: v2(197.79,90.82) 197.49,91.13 R195.2 R194.1 194.44,92.28 193.79,92.28 193.34,92.73 R177.1 192.94,93.28 192.94,94.68 192.86,94.76 Q21.5
ODD_EN_Q: length 8
  TOP w0.127: Q21.3 193.34,95.41 193.19,95.27 193.19,94.91 193.35,94.76 Q21.2 195.25,94.76 Q20.2 195.94,92.43 R182.2 196.37,91.98 197.66,91.98 v2(197.77,92.09)
ODD_POWER: length 58.1
  TOP w0.127: U13.19 168.49,53.93 168.94,53.48 177.97,53.48 v3(178.9,54.4) ; v3(194.55,89.43) 194.68,89.3 v2(195.69,89.3) 196.05,89.3 196.86,90.11 R195.1
  IN1 w0.133: v3(178.9,54.4) 178.9,55.48 180.16,56.74 180.16,66.76 181.41,68.01 181.41,73.15 182.64,74.38 182.64,79.79 182.64,80.24 182.64,80.24 182.64,80.47 186.36,84.2 186.36,84.2 186.68,84.52 188.43,84.52 189.13,85.21 193.34,89.43 v3(194.55,89.43)
ODD_PRSNT#: length 149.7
  TOP w0.127: R229.1 160.18,83 160.05,82.87 160.05,82.24 v3(159.97,82.16) ; v3(195.15,86.81) 195.18,86.81 198.68,90.32 198.68,97.48 199.01,97.81 199.01,99.48 v2(198.68,99.81) 198.68,100.66 198.1,101.24 198.1,101.54 197.49,102.15 R137.1 C167.1 199.63,102.19 CN6.8
  IN1 w0.133: v3(192.76,42.89) 193.68,43.81 193.68,60.52 191.19,63.01 v3(191.19,66.41)
  IN2 w0.133: v3(185.63,39.36) 185.63,39.63 184.95,40.31 182.07,43.19 180.94,43.19 179.58,44.54 165.83,44.54 163.42,46.95 163.42,50.34 161.63,52.12 161.63,57.05 161.19,57.49 161.19,64.66 160.33,65.52 160.33,75.69 159.3,76.73 159.3,77.09 159.69,77.48 159.69,81.88 v3(159.97,82.16)
  BOTTOM w0.127: v3(195.15,86.81) 191.62,86.81 189.46,84.65 188.55,84.65 184.28,80.38 184.28,77.29 186.59,74.98 186.59,71.72 191.19,67.13 v3(191.19,66.41) ; v3(185.63,39.36) 186.66,40.39 190.26,40.39 v3(192.76,42.89)
PCBEEP: length 2.9
  TOP w0.102: 27.1,32.89 27.13,32.86 27.59,32.86
  TOP w0.127: 27.1,32.89 v3(26.73,33.27) 26.95,33.49 C305.1 ; 27.59,32.86 27.8,32.65 U15.12
PCBEEP_EC: length 170.4
  TOP w0.127: U13.34 169.63,46.33 169.45,46.15 169.35,46.15 169.22,46.02 169.22,45 168.86,44.65 165.97,44.65 165.05,45.56 149.35,45.56 146.67,42.88 146.67,27.78 v2(146.38,27.5) 146.35,27.46 v3(146.35,26.75) ; D14.2 30.8,36.77 31.65,37.63 v3(31.65,38.78)
  IN2 w0.133: v3(31.65,38.78) 31.75,38.88 36.07,38.88 38.54,36.42 38.54,34.77 43.84,29.46 43.84,29.2 51.23,21.81 67.88,21.81 70.87,24.81 144.41,24.81 v3(146.35,26.75)
PCH_ACPRESENT: length 9.8
  TOP w0.102: v3(170.05,97.25) 170.05,97.25 170.05,97.25 170.06,97.25 170.06,95.7 R168.1 169.75,95.08 169.75,94.48 170.09,94.14
  TOP w0.127: R200.2 171.54,90.35 172.09,90.9 172.09,91.55 171.35,92.3 R174.1 170.35,93.88 170.09,94.14
  BOTTOM w0.102: v3(170.05,97.25) 169.77,97.53 U24.E6
PCH_APWROK: length 59.8
  TOP w0.127: R234.2 185.59,83.67 186.73,84.81 R231.2 185.59,84.9 TP59.1 184.59,84.75 v3(184.32,85.02) ; v3(177.34,73.93) 176.75,73.35 166.73,73.35 v3(166.44,73.64)
  IN2 w0.133: v3(163,97.91) 163.09,97.91 163.47,97.53 163.47,96.99 163.28,96.8 163.28,96.15 164.06,95.36 164.06,94.13 164.6,93.59 164.6,90.92 165.71,89.81 165.71,87.95 163.88,86.12 163.88,80.92 163.42,80.46 163.42,74.35 164.13,73.64 v3(166.44,73.64)
  BOTTOM w0.102: v3(163,97.91) 162.76,97.67 U24.AB7
  BOTTOM w0.127: v3(184.32,85.02) 183.65,84.35 183.65,83.38 180.97,80.7 180.97,79.9 179.56,78.5 179.56,77.16 179.2,76.8 179.2,75.43 177.71,73.93 v3(177.34,73.93)
PCH_AZ_CODEC_BITCLK: length 288.9
  TOP w0.127: v3(31.12,33.62) 31.4,33.9 C308.2 30.97,34.22 30.2,33.45 U15.6
  IN2 w0.133: v3(31.12,33.62) 31.62,33.11 36.96,33.11 41.57,28.51 41.57,27.95 50.75,18.76 68.15,18.76 70.24,20.86 144.1,20.86 149.59,26.35 168.09,26.35 170.17,24.27 170.17,21.43 171.5,20.1 179.26,20.1 182.08,22.91 182.79,22.91 185.47,25.59 185.47,25.6 189.64,29.77 189.64,40.24 185.69,44.19 185.13,44.19 183.31,46.01 182.13,46.01 180.14,48 180.14,49.63 178.23,51.54 178.23,52.93 175.14,56.02 175.14,58.7 173.37,60.47 173.37,64.84 173.71,65.18 173.71,66.32 175.39,68 175.39,69.08 174.89,69.58 174.89,76.33 v3(175.19,76.63)
  BOTTOM w0.127: R498.1 175.53,109.82 C425.2 177.21,110.48 178.95,110.48 179.13,110.66 182.22,110.66 182.83,110.05 v3(182.83,109.82) 184.28,109.82 185.22,108.88 186.81,108.88 189.17,106.52 189.17,101 188.32,100.15 188.32,98.49 188.93,97.89 188.93,92.18 187.52,90.77 187.52,89.22 184.9,86.59 183.66,86.59 179.44,82.38 179.44,81.02 175.19,76.77 v3(175.19,76.63)
PCH_AZ_CODEC_RST#: length 296.3
  TOP w0.127: D15.1 35.3,36.39 v3(35.3,36.75) ; U15.11 28.2,32.63 27.38,33.45 v3(27.38,33.6)
  IN2 w0.133: v3(27.38,33.6) 27.38,33.54 28.28,32.64 29,32.64 30.95,34.59 34.01,34.59 34.9,35.47 34.9,36.34 v3(35.3,36.75) 35.31,36.75 35.97,36.09 35.97,34.47 36.66,33.79 37.24,33.79 42.24,28.79 42.24,28.27 51.03,19.47 67.9,19.47 69.95,21.53 143.82,21.53 149.32,27.03 168.4,27.03 170.88,24.54 170.88,21.66 171.64,20.91 177.72,20.91 180.91,24.1 181.26,24.1 187.06,29.89 188.42,29.89 188.75,30.22 188.75,31.13 188.93,31.31 188.93,40 185.41,43.52 184.82,43.52 183,45.34 181.85,45.34 178.82,48.38 178.82,50.01 174.47,54.35 174.47,58.42 172.7,60.19 172.7,65.13 173.03,65.46 173.03,67.83 174.02,68.81 174.02,77.74 174.85,78.57 v3(175.21,78.57)
  BOTTOM w0.127: R694.1 21.37,33.57 v3(21.52,33.42) 21.67,33.27 27.04,33.27 v3(27.38,33.6) ; R506.1 179.87,107.22 179.99,107.34 181.92,107.34 182.27,107.69 186.6,107.69 188.18,106.11 188.18,101.41 187.3,100.53 187.3,97.78 187.94,97.15 187.94,92.86 186.53,91.46 186.53,89.63 184.49,87.58 183.18,87.58 178.36,82.77 178.36,81.55 175.39,78.57 v3(175.21,78.57)
PCH_AZ_CODEC_SDIN0: length 287
  TOP w0.127: R345.1 29.24,35.73 29.7,36.19 30.97,36.19 31.34,36.56 32.83,36.56 v4(33,36.72)
  IN2 w0.133: v3(166.88,103.72) 167.32,104.17 169.1,104.17 169.84,104.91 170.51,104.91 170.75,105.15 172.73,105.15 173.39,105.82 174.75,105.82 175.91,106.97 176.65,106.97 176.86,107.18 185.58,107.18 186.95,105.81 186.95,105.25 185.55,103.85 185.55,102.89 182.75,100.09 182.75,96.23 182.01,95.49 182.01,91.24 180.63,89.86 179.94,89.86 178.84,88.76 178.29,88.76 176.52,87 176.52,86.19 176.11,85.77 176.11,84.08 175.42,83.39 175.42,83.3 175.42,83.3 175.42,81.47 173.05,79.1 173.05,79.08 173.05,71.71 171.58,70.23 171.58,67.98 172.14,67.42 172.14,66.37 170.92,65.14 170.92,63.94 171.44,63.42 171.44,60.5 172.39,59.55 173.8,58.14 173.8,54.08 178.13,49.75 178.13,48.12 181.57,44.67 182.71,44.67 184.53,42.85 185.13,42.85 188.24,39.74 188.24,37.17 187.59,36.52 187.59,31.37 186.13,29.91 183.06,26.84 180.29,26.84 179.47,26.03 178.33,26.03 176.66,27.7 149.04,27.7 143.54,22.2 69.66,22.2 68.34,20.88 50.78,20.88 42.91,28.75 42.91,29.07 37.47,34.51 37.47,36.16 36.02,37.61 33.89,37.61 v4(33,36.72)
  BOTTOM w0.102: U24.L22 167.19,104.04 v3(166.88,103.72)
PCH_AZ_CODEC_SDOUT: length 282.8
  TOP w0.127: v3(30.66,33.06) 30.6,32.99 U15.5
  IN2 w0.133: v3(175.25,77.93) 175.25,77.42 174.55,76.73 174.55,69.44 174.94,69.06 174.94,68.03 173.37,66.46 173.37,65.32 173.03,64.98 173.03,60.33 174.81,58.56 174.81,55.88 177.9,52.79 177.9,51.4 179.81,49.49 179.81,47.86 181.99,45.68 183.15,45.68 184.97,43.86 185.55,43.86 189.29,40.12 189.29,30.28 188.56,29.56 188.1,29.56 185.07,26.53 185.07,25.66 183.16,23.76 181.31,23.76 178.13,20.57 171.5,20.57 170.5,21.57 170.5,24.41 168.23,26.69 149.45,26.69 143.96,21.19 70.09,21.19 68.04,19.14 50.86,19.14 41.9,28.1 41.9,28.65 37.1,33.45 32.13,33.45 31.47,34.11 30.94,34.11 30.48,33.65 30.48,33.23 v3(30.66,33.06)
  BOTTOM w0.127: R505.1 177.91,107.66 179.95,107.66 179.95,107.67 181.78,107.67 182.13,108.02 186.74,108.02 188.51,106.25 188.51,101.27 187.63,100.39 187.63,97.92 188.27,97.29 188.27,92.73 186.86,91.32 186.86,89.49 184.62,87.25 183.33,87.25 178.69,82.62 178.69,81.37 v3(175.25,77.93)
PCH_AZ_CODEC_SYNC: length 272.1
  TOP w0.127: v3(28.78,33.11) 28.6,32.93 U15.10 ; R92.1 184.46,111.03 184.46,104.95 186.03,103.37 v3(186.03,103.25)
  IN2 w0.133: v3(28.78,33.11) 28.85,33.11 30.66,34.92 33.88,34.92 34.56,35.61 34.56,36.96 34.85,37.25 35.89,37.25 36.36,36.78 36.36,34.56 36.8,34.12 37.38,34.12 42.57,28.93 42.57,28.58 50.61,20.54 68.49,20.54 69.81,21.87 143.68,21.87 149.18,27.36 176.52,27.36 178.49,25.39 182.09,25.39 188.57,31.88 188.57,39.88 185.27,43.18 184.68,43.18 182.86,45 181.71,45 178.46,48.26 178.46,49.89 174.13,54.21 174.13,58.28 172.36,60.06 172.36,65.26 172.67,65.57 172.67,68.98 173.39,69.69 173.39,78.96 175.75,81.33 175.75,83.03 175.75,83.03 175.75,83.25 176.44,83.94 176.44,85.63 176.86,86.05 176.86,86.86 178.43,88.43 178.98,88.43 180.08,89.53 180.77,89.53 182.35,91.1 182.35,95.35 183.09,96.09 183.09,99.95 186.03,102.89 v3(186.03,103.25)
PCH_BATLOW#: length 17.3
  TOP w0.127: v3(177.5,93.46) 177.53,93.48 177.53,93.77 178.16,94.4 178.16,95.73 v2(178.11,95.78) 178.31,95.98 178.59,95.98 179,96.39 R160.1
  IN1 w0.133: v3(177.5,93.46) 176.66,94.3 173.02,94.3 172.01,95.31 170.51,95.31 170.39,95.19 169.2,95.19 168.05,96.34 168.05,96.75 168.34,97.04 168.34,97.43 v3(167.88,97.89)
  BOTTOM w0.102: U24.K7 167.66,97.67 167.87,97.89 v3(167.88,97.89)
PCH_BLON: length 117.5
  TOP w0.127: v3(106.28,160.3) 106.19,160.21 R31.1
  IN1 w0.133: v3(106.28,160.3) 106.33,160.25 106.33,142.72 115.8,133.24 128.73,133.24 131.49,136 163.77,136 163.81,135.96 163.86,135.96 164.99,134.83 164.99,131.49 166.92,129.55 167.7,129.55 168.21,129.04 168.59,128.66 169.84,128.66 170.9,127.6 170.9,124.49 170.63,124.23 170.63,123.71 170.99,123.35 170.99,123.12 172.33,121.78 172.33,120.29 172.75,119.87 172.75,116.53 174,115.28 174,113.44 170.18,109.62 168.42,109.62 168.03,110.01 v3(168.03,110.11)
  BOTTOM w0.102: v3(168.03,110.11) 167.79,109.88 U24.K36
PCH_BLON_EC: length 167.3
  TOP w0.127: R28.1 109.11,161.34 v3(109.14,161.37) ; v3(151.9,69.77) 153.14,71.01 155.48,71.01 v2(156.65,69.84) 157.2,69.29 163.49,69.29 164.22,70.02 165.76,70.02 165.8,70.06 166.99,70.06 169.51,67.54 171.36,67.54 172.47,66.43 172.47,65.83 172.67,65.64 172.67,64.06 172.83,63.89 U13.119
  IN1 w0.133: v3(151.9,69.77) 151.95,69.77 153.97,71.79 153.97,73.23 153.32,73.88 153.32,74.71 150.53,77.5 150.53,82.39 151.52,83.38 151.52,84.96 152.09,85.53 152.09,86.83 150.59,88.32 150.59,88.68 150.92,89.01 152.78,89.01 154.94,91.17 154.94,93.18 153.9,94.23 151.11,94.23 150.19,95.15 147.57,95.15 147.05,94.63 143.01,94.63 140.88,96.75 140.88,100.33 137.75,103.47 137.75,109.04 140.37,111.66 140.37,120.81 130.03,131.16 116.36,131.16 104.63,142.89 104.63,159.37 106.79,161.53 108.97,161.53 109.14,161.37 v3(109.14,161.37)
PCH_BLON_R: length 5.3
  TOP w0.127: R28.2 108.22,160.37 107.14,160.37 106.96,160.19 106.96,159.59 R31.2 R32.2 Q8.5
PCH_BRIGHT: length 135.9
  IN1 w0.133: v3(105.3,155.68) 105.3,142.88 116.74,131.44 127.87,131.44 131.88,135.45 163.55,135.45 164.02,134.98 164.44,134.56 164.44,131.26 166.69,129.01 167.47,129.01 168.37,128.11 169.61,128.11 170.34,127.39 170.34,124.71 170.08,124.45 170.08,123.49 170.44,123.13 170.44,122.9 171.48,121.86 171.48,118.86 169.57,116.96 169.57,112.69 167.2,110.32 v3(166.99,110.32)
  BOTTOM w0.102: U24.N36 166.71,110.04 v3(166.99,110.32)
  BOTTOM w0.127: CN2.27 109.93,177.58 108.36,176.01 108.36,173.55 105.49,170.68 105.49,164.54 v2(105.95,164.08) 106.77,163.25 106.77,157.68 105.3,156.21 v3(105.3,155.68)
PCH_DRQ#0: length 4.8
  BOTTOM w0.079: U24.D21 170.62,103.64 170.94,103.96 171.18,103.96 171.39,103.75 171.69,103.75
  BOTTOM w0.127: 171.69,103.75 173.73,103.75 174.02,103.45 174.42,103.45 TP102.1
PCH_DRQ#1: length 2.9
  TOP w0.102: v3(169.32,102.73) 169.53,102.73 170.18,102.08 170.41,102.08
  TOP w0.127: TP35.1 170.95,102.08 170.41,102.08
  BOTTOM w0.102: U24.G20 168.99,103.07 v3(169.32,102.73)
PCH_HOOK1: length 1.5
  TOP w0.127: R274.2 166.21,69.22 TP66.1
PCH_HOOK7: length 3.1
  BOTTOM w0.127: TP89.1 85.2,113.58 86.24,113.58 86.59,113.94 R485.2
PCH_INVRMEN: length 11.8
  TOP w0.127: R171.2 177.61,94.97 v3(177.63,94.98)
  IN1 w0.089: v3(168.7,98.78) 168.7,98.71 169.14,98.27 169.44,98.27 169.66,98.05 169.66,98.01 170,97.67 170.5,97.67 171.85,96.32 172.05,96.32
  IN1 w0.133: v3(177.63,94.98) 176.59,94.98 175.82,95.74 173.05,95.74 172.47,96.32 172.05,96.32
  BOTTOM w0.102: U24.G10 168.7,98.97 v3(168.7,98.78)
PCH_JTAG_TCK: length 2.6
  BOTTOM w0.127: TP149.1 164.61,82.5 164.61,83.38 164.35,83.64 164.35,84.42 R615.1
PCH_JTAG_TCK_R: length 11.9
  BOTTOM w0.102: 162.61,92.37 162.67,92.42 162.67,94.6 162.3,94.96 162.3,95.27 162.56,95.52 162.56,95.79 162.61,95.84 U24.AB3 ; 162.87,91.15 162.87,90.23 R574.1 163.38,89.68 163.38,88.35 163.22,88.19 163.22,87.18
  BOTTOM w0.127: 162.87,91.15 162.67,91.36 162.67,91.41 v3(162.16,91.92) 162.61,92.37 ; 163.22,87.18 163.22,86.87 164.03,86.06 R615.2
PCH_JTAG_TDI: length 1.8
  BOTTOM w0.127: R609.1 161.59,86.46 161.59,85.85 161.24,85.5 TP137.1
PCH_JTAG_TDI_R: length 14.4
  BOTTOM w0.089: 161.94,85.43 161.94,85.99 162.12,86.18 162.12,87.25 162.01,87.37 R609.2 161.3,87.78 161.3,90.19 160.82,90.67 160.82,91.32 v3(160.94,91.43) 161.01,91.5 161.01,93.53 161.27,93.8 161.27,94.71 161.28,94.72 161.28,95.46 U24.AE2
  BOTTOM w0.127: 161.94,85.43 161.94,83.71 R634.1 R633.2
PCH_JTAG_TDO: length 5.4
  BOTTOM w0.127: R642.2 164.64,81.33 R640.1 164.1,81.44 164.1,83.21 TP144.1 162.95,84.36 R612.1
PCH_JTAG_TDO_R: length 11.4
  BOTTOM w0.089: 162.62,88.23 162.42,88.43 162.42,90.43 162.03,90.81 162.03,91.43 161.55,91.91 161.55,93.24 161.81,93.5 161.81,94.34 162.1,94.62 162.1,95.3 161.91,95.49 161.91,95.93 U24.AD3
  BOTTOM w0.127: 162.62,88.23 v3(162.72,88.13) 162.71,88.12 162.71,86.65 162.95,86.4 R612.2
PCH_JTAG_TMS: length 1.1
  BOTTOM w0.127: R641.1 TP154.1
PCH_JTAG_TMS_R: length 16.8
  TOP w0.127: R219.2 161.6,87.39 162.01,87.8 v3(162.01,88.05)
  BOTTOM w0.089: 162.45,86.04 162.44,86.04 162.44,87.62 v3(162.01,88.05) 162.21,88.25 162.21,90.38 161.86,90.74 161.86,91.35 161.37,91.84 161.37,93.36 161.63,93.63 161.63,94.57 161.8,94.73 U24.AD1
  BOTTOM w0.127: 162.45,86.04 162.45,83.99 R635.1 163.34,83.09 163.45,83.09 163.6,82.95 163.6,81.4 163.29,81.1 R641.2
PCH_ODD_EN: length 35.2
  TOP w0.127: R194.2 194.38,90.35 v2(194.24,90.49) 194.03,90.7 191.87,90.7 191.44,91.14 191.44,92.38 189.71,94.1 189.71,95.8 190.6,96.68 190.6,100.38 188.09,102.89 188.09,103.17 187.08,104.18 v3(186.97,104.18)
  BOTTOM w0.127: R518.1 178.7,104.21 179.16,104.67 180.02,104.67 180.6,105.26 180.6,105.95 180.09,106.46 180.09,106.8 180.24,106.96 182.07,106.96 182.43,107.31 186.45,107.31 187.48,106.27 187.48,104.69 v3(186.97,104.18)
PCH_ODD_EN_R: length 11.6
  BOTTOM w0.102: 175.5,101.31 175.04,101.31 174.97,101.24 171.79,101.24 171.73,101.3 171.39,101.3 171.19,101.5 170.71,101.5 U24.C16
  BOTTOM w0.127: 175.5,101.31 175.95,101.31 176.92,102.28 176.92,102.96 v3(177.3,103.35) 177.31,103.36 R518.2 177.39,104.21 177.85,103.75 179.04,103.75 R517.1
PCH_PECI: length 10.2
  BOTTOM w0.102: U24.AY1 155.27,95.01 154.18,93.92 154.18,93.61 153.8,93.24 152.92,93.24 151.16,91.48 151.16,89.15 149.89,87.88 R593.1
PCH_PWRBTN#: length 10.1
  BOTTOM w0.102: U24.K1 167.49,94.94 167.93,94.5 167.93,94.14 170.71,91.36 v3(170.95,91.36) 170.95,91.13 171.41,90.67 171.66,90.67 R580.1
  BOTTOM w0.114: R604.2 171.61,88.18 171.61,89.7 R580.1
PCH_PWROK: length 30.4
  TOP w0.127: 187.96,92.94 187.94,92.94 187.81,93.06 187.81,94.51 v2(187.41,94.91) 187.41,95.8 188.06,96.46 R163.2 189.21,97.44 R154.1 ; 187.96,92.94 187.71,92.69 185.97,92.69 185.43,93.24 v3(185.11,93.24) ; 187.96,92.94 188.16,92.94 189.56,91.54 R193.2
  IN1 w0.133: v3(185.11,93.24) 184.45,93.9 182.82,93.9 181.22,95.49 177.91,95.49 177.71,95.7 176.75,95.7 175.85,96.6 171.9,96.6 170.99,97.5 170.99,97.89 170.15,98.73 v3(169.35,98.73)
  BOTTOM w0.102: v3(169.35,98.73) 169.58,98.96 U24.F10
PCH_RI#: length 7.8
  BOTTOM w0.102: R585.1 168.84,90.33 168.15,91.03 168.15,91.8 166.28,93.68 166.28,94.8 166.27,94.81 166.27,94.83 166.17,94.93 166.17,95.26 165.99,95.44 165.98,95.44 165.98,95.72 166.27,96 U24.N4
PCH_RSMRST#: length 21.1
  TOP w0.127: v3(175.4,88.41) 176.04,89.05 178.34,89.05 v3(178.9,88.49) 179.3,88.09 179.3,87.81 179.6,87.5 R218.2
  BOTTOM w0.102: 172.37,91.44 171.51,92.3 170.7,92.3 169.75,93.25 169.56,93.25 168.4,94.41 168.4,94.61 167.99,95.01 167.99,95.51 U24.J2
  BOTTOM w0.127: R625.2 173.75,85.65 173.75,86.5 173.77,86.52 173.77,86.68 173.77,87.1 174.34,87.67 R606.1 174.66,87.67 v3(175.4,88.41) 175.04,88.77 175.04,90.18 174.61,90.61 174.6,90.6 174.6,90.61 174.5,90.61 173.78,91.33 172.89,91.33 172.83,91.39 172.42,91.39 172.37,91.44
PCH_SLP_A#: length 12.5
  BOTTOM w0.102: 170.85,94.28 169.93,94.28 169.36,94.85 169.36,95.35 169.16,95.55 U24.F3
  BOTTOM w0.127: R583.1 177.39,90.11 176.86,90.63 176.86,91.47 176.86,91.47 176.86,91.53 176.86,91.77 176.01,92.63 175.34,92.63 174.48,93.49 173.86,93.49 173.08,94.28 170.85,94.28
PCH_SLP_LAN#: length 8.3
  TOP w0.102: v3(169.45,97) 169.17,96.72 169.17,94.1
  TOP w0.127: TP55.1 170.03,90.11 170.03,91.05 170.26,91.28 170.26,92.07 R189.1 169.71,93.56 169.17,94.1
  BOTTOM w0.102: v3(169.45,97) 169.15,96.7 U24.G5
PCH_SLP_S3#: length 9.6
  BOTTOM w0.102: U24.H1 168.3,95.07 168.61,94.76 168.61,94.51 169.67,93.45 169.96,93.45 170.85,92.56 172.35,92.56
  BOTTOM w0.127: 172.35,92.56 172.63,92.56 173.31,91.89 173.94,91.89 174.71,91.12 174.83,91.12 175.55,90.4 R582.1
PCH_SLP_S4#: length 9.6
  BOTTOM w0.102: U24.C6 171.14,97.51 171.36,97.29 171.66,97.29 172.48,96.46 173.43,96.46 174.22,95.67 174.93,95.67
  BOTTOM w0.127: 174.93,95.67 175.19,95.93 178.63,95.93 R548.1
PCH_SLP_S5#: length 9
  TOP w0.089: v3(163.97,97.89) 163.58,97.49 163.58,96.97 163.36,96.76 163.36,96.33 163.6,96.1 163.6,94.44 163.84,94.2
  TOP w0.127: 163.84,94.2 163.84,93.72 v3(163.86,93.69) 163.86,93.57 164.26,93.17 164.26,90.47 R212.1
  BOTTOM w0.102: U24.Y7 163.71,97.89 v3(163.97,97.89)
PCH_SLP_SUS#: length 12
  BOTTOM w0.102: U24.F1 169.03,94.87 169.92,93.98 171.44,93.98
  BOTTOM w0.127: 171.44,93.98 172.84,93.98 173.74,93.09 173.93,93.09 174.03,92.98 174.27,92.98 175.13,92.12 175.8,92.12 176.36,91.56 176.36,90.42 176.99,89.79 176.99,89.14 R588.1
PCH_SLP_WLAN#: length 4.2
  TOP w0.102: 169.64,94.1 169.39,94.35 169.39,95.49 v3(169.6,95.69)
  TOP w0.127: TP51.1 170.79,92.95 169.64,94.1
  BOTTOM w0.102: v3(169.6,95.69) 169.68,95.78 U24.D2
PCH_SPI_CLK: length 34.9
  TOP w0.127: v3(154.01,86.37) 154.01,86.33 153.28,85.6 152.76,85.6 151.49,84.33 151.49,83.35 151.25,83.11 151.02,83.11 149.58,84.55 149.36,84.55 149.2,84.4 149.2,84.18 150.65,82.73 150.65,82.51 150.37,82.24 149.86,82.24 149.64,82.47 149.64,82.98 149.46,83.15 149.22,83.15 149.05,82.98 149.05,82.31 148.92,82.19 148.13,82.19 147.28,81.34 v4(146.67,80.73)
  IN2 w0.133: v3(159.45,99.23) 159.01,98.78 159.01,98.29 158.91,98.19 158.91,97.73 158.96,97.68 158.96,97.02 159.42,96.55 159.42,95.9 157.89,94.37 157.89,93.92 156.87,92.9 156.87,91.13 155.67,89.93 155.65,89.93 154.72,88.99 154.72,87.35 154.48,87.11 154.48,86.83 v3(154.01,86.37)
  BOTTOM w0.102: v3(159.45,99.23) 159.69,99.46 U24.AJ11
  BOTTOM w0.127: TP178.1 145.22,81.32 145.81,80.73 v4(146.67,80.73) 146.59,80.65 R648.1
PCH_SPI_CLK_EC: length 64.4
  TOP w0.127: v3(169.67,55.68) 170.45,56.46 172.16,56.46 172.8,57.09 173.69,57.09 176.1,59.51 177.39,59.51 178.09,60.21 178.09,61.48 178.43,61.82 U13.105
  BOTTOM w0.127: v3(169.67,55.68) 169.56,55.57 165.85,55.57 164.37,54.09 163.63,54.09 160.57,57.15 151.33,57.15 143.17,65.31 v2(143.17,75.56) 143.17,77.19 141.76,78.6 141.76,80.16 142.29,80.69 144.79,80.69 R645.1
PCH_SPI_CS0#: length 40.4
  TOP w0.127: TP177.1 146.74,65.88 v3(146.64,65.98) 146.64,75.3 152.77,81.43 154.16,82.83 154.16,85.19 v3(153.87,85.49)
  IN2 w0.133: v3(159.45,97.26) 159.69,97.03 159.69,95.44 158.4,94.16 158.4,94.05 157.13,92.79 157.13,90.98 155.82,89.67 155.76,89.67 154.98,88.89 154.98,87.24 154.74,87 154.74,86.29 153.93,85.49 v3(153.87,85.49)
  BOTTOM w0.102: v3(159.45,97.26) 159.86,97.67 U24.AJ7
  BOTTOM w0.127: v3(146.64,65.98) 147.29,65.98 R660.1
PCH_SPI_IO2: length 40.9
  TOP w0.127: v3(145.05,66.35) 144.58,66.82 v2(144.58,76.24) 144.58,78.62 145.81,79.85 146.94,79.85 147.48,80.38 147.48,80.94 148.32,81.78 150.39,81.78 151.82,83.21 151.82,84.07 152.67,84.92 v3(153.54,84.92)
  IN2 w0.133: v3(159.42,94.37) 157.47,92.42 157.47,90.84 155.96,89.33 155.9,89.33 155.32,88.75 155.32,87.04 155.11,86.83 155.11,85.85 154.19,84.92 v3(153.54,84.92)
  BOTTOM w0.089: U24.AJ4 159.77,96.01 159.48,95.72 159.48,95.45 159.64,95.29 159.64,95.28 159.66,95.26 159.66,94.93 159.42,94.7 v3(159.42,94.37)
  BOTTOM w0.127: R663.1 145.65,65.36 145.05,65.96 v3(145.05,66.35)
PCH_SPI_IO3: length 33.5
  TOP w0.127: v4(152.93,84.37) 152.6,84.37 152.15,83.91 152.15,83.08 150.52,81.45 148.67,81.45 v3(147.99,80.77)
  IN2 w0.133: v3(159.42,93.7) 159.28,93.56 159.28,90.71 158.4,89.83 158.4,88.12 157.59,87.31 157.59,86.75 156.57,85.73 155.47,85.73 154.11,84.37 v4(152.93,84.37)
  BOTTOM w0.089: v3(159.42,93.7) 159.82,94.1 159.82,94.8 159.87,94.85 159.87,95.5 U24.AJ2
  BOTTOM w0.127: R649.2 147.31,80.6 147.31,81.07 147.11,81.27 145.63,81.27 145.5,81.41 145.5,81.6 145.63,81.73 146.74,81.73 146.89,81.88 146.89,82.09 146.74,82.24 145.44,82.24 145.29,82.39 145.29,82.6 145.44,82.75 146.92,82.75 147.99,81.67 v3(147.99,80.77)
PCH_SPI_SI: length 32.8
  TOP w0.127: TP179.1 v3(145.37,78.43) 146.09,79.15 147.97,79.15 148.1,79.28 148.1,79.28 148.1,79.97 148.26,80.13 148.48,80.13 148.64,79.97 148.64,79.35 148.8,79.19 149.03,79.19 149.19,79.35 149.19,80.02 149.41,80.23 150.2,80.23 152.94,82.97 v4(152.94,83.04)
  IN2 w0.133: v3(160.23,94.48) 160.52,94.48 160.93,94.07 160.93,92.13 160.54,91.75 160.54,87.29 159.91,86.65 159.91,85.98 158.68,84.75 155.87,84.75 154.16,83.04 v4(152.94,83.04)
  BOTTOM w0.089: U24.AH1 160.17,94.54 v3(160.23,94.48)
  BOTTOM w0.127: R647.1 144.48,80.06 144.78,79.76 144.78,79.02 v3(145.37,78.43)
PCH_SPI_SI_EC: length 66.9
  TOP w0.127: v3(170.75,55.74) 171.95,55.74 172.06,55.62 173.58,55.62 176.5,58.54 177.79,58.54 178.93,59.68 178.93,60.33 179.63,61.03 U13.102 179.63,63.59 180.42,64.38 181.37,64.38 182.97,62.78 v2(183.9,62.78) 184.03,62.78 184.15,62.91 R341.1
  BOTTOM w0.127: R646.1 142.39,79.62 142.39,78.86 143.8,77.45 143.8,65.57 151.59,57.78 162.01,57.78 163.07,56.73 168.13,56.73 168.66,56.2 169.31,56.2 169.46,56.35 170.11,56.35 170.72,55.74 v3(170.75,55.74)
PCH_SPI_SO: length 41.2
  TOP w0.127: v3(153.42,83.75) 153.57,83.6 153.57,82.71 148.28,77.41 v2(147.2,77.41) 147.2,76.33 146,75.13 146,70.6 145.67,70.27 v3(145.67,65.98) 145.29,65.6 TP180.1
  IN2 w0.133: v3(160.26,93.83) 160.21,93.83 159.62,93.24 159.62,88.17 158.95,87.5 158.26,87.5 157.93,87.17 157.93,86.69 158.13,86.49 158.13,85.85 157.67,85.39 155.61,85.39 153.97,83.75 v3(153.42,83.75)
  BOTTOM w0.089: v3(160.26,93.83) 160.63,94.2 160.63,94.71 160.48,94.86 160.48,95.27 160.17,95.57 U24.AH3
  BOTTOM w0.127: R658.1 145.6,66.06 v3(145.67,65.98)
PCH_SPI_SO_EC: length 61.5
  TOP w0.127: v3(172.77,56.07) 173.56,56.07 176.36,58.87 177.65,58.87 178.6,59.81 178.6,60.46 179.25,61.12 179.25,61.95 179.23,61.97 U13.103 179.23,63.69 180.25,64.71 181.51,64.71 182.83,63.39 183.16,63.39 v2(183.85,64.08) 184.05,64.28 184.23,64.28 184.82,64.87 R291.1
  BOTTOM w0.127: R659.1 146.62,66.83 146.16,66.37 146.16,65.53 146.6,65.1 146.78,65.1 147.34,65.66 147.56,65.66 147.72,65.5 147.72,65.28 146.34,63.91 146.34,63.69 146.5,63.53 146.72,63.53 148.26,65.06 148.48,65.06 148.63,64.91 148.63,64.69 147.07,63.12 147.07,62.91 147.22,62.76 147.43,62.76 148.13,63.46 148.35,63.46 148.51,63.3 148.51,63.08 147.98,62.54 147.98,62.28 148.16,62.1 148.42,62.1 148.87,62.55 149.15,62.55 153.58,58.11 162.15,58.11 163.2,57.06 168.27,57.06 168.8,56.53 169.17,56.53 169.32,56.68 170.24,56.68 170.74,56.18 172.66,56.18 v3(172.77,56.07)
PCH_SUSCLK: length 11
  TOP w0.089: 164.34,94.2 164.12,94.43 164.12,94.74 164.16,94.79 164.16,97.05 v3(163.98,97.23)
  TOP w0.127: 164.34,94.2 164.34,93.89 164.76,93.47 164.76,90.58 R213.1 165.29,90.21 165.66,89.84 165.66,88.61 165.13,88.08 R222.1
  BOTTOM w0.102: U24.Y6 163.82,97.07 v3(163.98,97.23)
PCH_SUSPWRACK: length 13.4
  BOTTOM w0.102: 172.62,90.88 172.55,90.96 172.55,90.96 171.48,92.03 170.58,92.03 169.62,92.99 169.46,92.99 168.17,94.28 168.17,94.54 167.79,94.93 167.79,95.27 167.61,95.45 167.61,95.72 167.89,96 U24.J4
  BOTTOM w0.127: 172.62,90.88 173.26,90.25 R581.2 173.39,90.08 R584.1 173.92,89.6 173.92,88.33 R605.1
PCH_SYNCH: length 14
  BOTTOM w0.102: U24.AY3 155.29,95.57 155.58,95.29 155.58,95.28 155.59,95.27 155.59,94.96 154.38,93.76 154.38,93.46 153.83,92.91 153.14,92.91 152.61,92.37 152.61,91.03 152.23,90.65 v2(151.64,90.65) 151.64,89.34 150.5,88.19 150.5,87.42
  BOTTOM w0.114: R623.1 150.21,85.48 150.5,85.77 150.5,87.42
PCH_TEMP_ALERT#: length 373.2
  TOP w0.102: v3(168.85,97.25) 168.86,97.25 ; v3(168.85,97.25) 168.85,97.25 168.86,97.25 168.96,97.15 168.96,96.1 v3(168.74,95.88) 168.56,95.7 R172.2 ; v3(168.86,97.26) 168.86,97.25 ; v3(168.85,97.25) 168.86,97.25 ; v3(168.86,97.25) 168.86,97.25
  IN2 w0.133: v3(168.85,97.25) 168.85,97.25 168.86,97.25 168.99,97.12 168.99,94.99 171.05,92.93 171.05,89.96 171.5,89.5 171.5,87.22 172.14,86.58 172.14,85.82 172.57,85.39 172.57,84.24 170.18,81.85 170.18,81.27 170.18,81.27 170.18,81.1 170.18,81.04 169.23,80.1 169.23,73.26 168.04,72.07 168.04,69.45 168.49,69 168.49,65.16 167.33,63.99 167.33,60.33 169.42,58.24 169.42,57.58 169.79,57.21 172.28,57.21 173.33,56.16 173.33,54.42 173.08,54.17 173.08,51.05 174.71,49.42 174.71,48.07 175.06,47.71 177.98,47.71 181.41,44.28 182.53,44.28 186.97,39.84 186.97,36.78 187.2,36.55 187.2,31.53 186.51,30.85 183.04,27.37 180.27,27.37 179.35,26.45 178.46,26.45 176.82,28.09 148.33,28.09 146.53,26.28 146.26,26.28 144.52,24.54 71.01,24.54 68.01,21.54 51.12,21.54 43.57,29.09 43.57,29.35 38.2,34.72 38.2,36.37 36.3,38.27 22.21,38.27 18.05,42.43 18.05,56.11 24.39,62.45 24.39,67.44 27.51,70.57 27.51,72.94 28.4,73.83 29.98,73.83 31.4,75.25 31.4,90.48 30.08,91.8 30.08,94.81 29.39,95.5 29.39,102.14 33.01,105.75 45.9,105.75 46.38,106.23 54.29,106.23 56.39,104.13 v3(59.14,104.13) ; v3(168.86,97.26) 168.86,97.25 ; v3(168.85,97.25) 168.86,97.25 ; v3(168.86,97.25) 168.86,97.25 ; v3(168.85,97.25) 168.86,97.25
  BOTTOM w0.102: v3(168.85,97.25) 168.85,97.25 168.86,97.25 168.86,97.25 168.69,97.09 168.68,97.07 U24.H6 ; v3(168.85,97.25) 168.86,97.25 ; v3(168.85,97.26) 168.86,97.26 ; v3(168.85,97.25) 168.86,97.25 ; v3(168.85,97.25) 168.86,97.25
  BOTTOM w0.127: R513.2 61.43,105.31 U26.1 60.3,103.78 60.2,103.68 59.4,103.68 59.14,103.94 v3(59.14,104.13)
PCH_THRMTRIP#: length 10.4
  BOTTOM w0.102: R594.1 151.17,87.67 151.65,88.14 151.65,88.79 152.05,89.2 152.05,89.7 R570.1 153.03,90.21 153.43,90.6 154.26,90.6 154.77,91.1 154.77,91.94 154.85,92.03 154.85,93.65 156.11,94.91 U24.AV1
PCH_VCC_1_1_20: length 4
  TOP w0.254: R144.2 170.23,100.56 169.58,101.22 167.9,101.22 167.44,101.67 v3(167.44,101.69)
  BOTTOM w0.254: v3(167.44,101.69) 167.44,101.94 U24.L17
PCH_VCC_1_1_21: length 14.6
  IN1 w0.254: v3(177.42,102.48) 176.84,103.07 170.57,103.07 170.42,103.21 165.43,103.21 165,102.78 v3(165,102.69)
  BOTTOM w0.254: R525.2 177.88,102.94 v3(177.42,102.48) ; U24.R18 165.33,102.29 165.11,102.51 165.11,102.57 v3(165,102.69)
PCI_PIRQA#: length 18.2
  TOP w0.127: v3(179.66,105.15) 179.66,105.61 179.29,105.97 179.29,106.41 179.49,106.61 179.81,106.61 179.98,106.78 179.98,107.09 180.26,107.37 181.28,107.37 R106.2
  IN2 w0.089: 171.17,103.86 170.47,103.16 169.11,103.16 v3(168.65,102.71)
  IN2 w0.133: 171.17,103.86 171.52,104.22 173.12,104.22 173.78,104.88 175.23,104.88 176.39,106.04 177.03,106.04 177.24,106.25 178.62,106.25 179.66,105.21 v3(179.66,105.15)
  BOTTOM w0.102: U24.H20 168.39,102.97 v3(168.65,102.71)
PCI_PIRQB#: length 17.4
  TOP w0.127: v3(180.13,105.6) 180.41,105.33 R121.2
  IN2 w0.089: v3(166.98,102.7) 167.4,103.12 168.52,103.12 168.75,103.34 170.26,103.34 170.78,103.86
  IN2 w0.133: 170.78,103.86 171.41,104.49 173,104.49 173.67,105.15 175.02,105.15 176.18,106.31 176.92,106.31 177.13,106.52 178.73,106.52 179.55,105.7 180.03,105.7 v3(180.13,105.6)
  BOTTOM w0.102: v3(166.98,102.7) 167.19,102.92 U24.L20
PCI_PIRQC#: length 16
  TOP w0.127: R109.2 179.01,106.81 v3(179.01,105.15)
  IN2 w0.089: 171.55,103.86 170.56,102.87 170.56,102.61 170.26,102.3 168.7,102.3 v3(168.1,101.7)
  IN2 w0.133: v3(179.01,105.15) 179.01,105.47 178.51,105.97 177.36,105.97 177.15,105.76 176.5,105.76 175.34,104.61 173.9,104.61 173.23,103.94 171.63,103.94 171.55,103.86
  BOTTOM w0.102: v3(168.1,101.7) 167.79,102 U24.K17
PCI_PIRQD#: length 18.6
  TOP w0.127: v3(179.74,106.16) 179.77,106.16 180.24,106.63 180.24,106.86 180.49,107.11 181.38,107.11 R111.2
  IN2 w0.089: 170.39,103.86 170.1,103.57 168.66,103.57 168.39,103.3 166.96,103.3 v3(166.37,102.71)
  IN2 w0.133: v3(179.74,106.16) 179.11,106.79 177.02,106.79 176.81,106.58 176.07,106.58 174.91,105.43 173.56,105.43 172.89,104.76 171.29,104.76 170.39,103.86
  BOTTOM w0.102: v3(166.37,102.71) 166.6,102.93 U24.M20
PCI_PLTRST#: length 73.3
  TOP w0.127: v3(177.26,74.58) 176.54,73.86 v3(168.77,73.86)
  IN2 w0.133: v3(168.77,73.86) 168.8,73.88 168.8,80.28 169.74,81.22 169.74,81.28 169.74,81.29 169.74,84.46 169.6,84.6 169.6,87.12 169.72,87.25 169.72,88.83 167.66,90.89 167.66,92.23 165.18,94.71 165.18,95.58 164.48,96.28 164.48,98.69 v3(163.98,99.2)
  BOTTOM w0.102: v3(163.98,99.2) 163.75,99.2 U24.Y11
  BOTTOM w0.127: v3(177.26,74.58) 178.69,76.01 178.69,77.03 179.05,77.39 179.05,78.71 180.46,80.11 180.46,80.93 183.14,83.61 183.14,84.58 184.13,85.58 185.8,85.58 187.34,87.11 188.42,87.11 192.1,90.8 192.1,96.06 191.73,96.43 191.73,97.79 192.16,98.22 192.16,99.23 192.43,99.51 U28.2 193.65,99.51 193.76,99.61 193.76,99.93 193.52,100.16 U28.1
PCI_PME#: length 4.6
  TOP w0.089: TP49.1 161.19,95.37 161.19,96.81 161.02,96.98 161.02,97.76 161.01,97.78 161.01,98.16 v3(161.41,98.56)
  BOTTOM w0.102: v3(161.41,98.56) 161.71,98.86 U24.AD10
PCIE_CLKREQ_WLAN#: length 84.5
  TOP w0.127: v3(185.67,38.69) 186.08,39.11 186.08,42.28 v2(185.78,42.59) 185.78,43.22 183.53,45.47 183.53,47.28 183.97,47.72 186.7,47.72 v3(187.54,48.56)
  IN2 w0.133: v3(185.67,38.69) 186.11,39.13 186.11,39.54 182.19,43.46 181.05,43.46 179.69,44.82 165.95,44.82 163.69,47.07 163.69,50.63 161.91,52.41 161.91,57.16 161.46,57.61 161.46,64.77 160.61,65.63 160.61,79.8 v3(160.27,80.14)
  BOTTOM w0.127: v3(187.54,48.56) 187.13,48.96 R679.2 186.46,48.68 186.46,47.94 186.68,47.72 Q56.4 ; R611.1 160.15,84.73 159.33,83.91 159.08,83.91 158.91,83.74 158.91,81.16 159.93,80.14 v3(160.27,80.14)
PCIE_CLKREQ_WLAN#_R: length 6
  BOTTOM w0.127: R688.1 184.2,47.45 184.48,47.72 Q56.3 185.92,47.72 186.21,48.01 186.21,48.71 R679.1 185.9,49.02 CN10.7
