# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDA_SYNC_Q: length 13.9
  TOP w0.127: Q15.3 178.16,110.72 R102.2 178.16,107.54 178.16,106.83 178.36,106.62 v3(178.36,105.33)
  BOTTOM w0.127: v3(178.36,105.33) 178.36,105.61 178.01,105.96 177.04,105.96 176.66,105.58 175.16,105.58 174.22,104.64 173.16,104.64 172.56,104.04 U24.A22
HDA_SYNC_R: length 12.8
  TOP w0.127: R92.2 183.74,111.09 C120.1 R91.2 181.51,111.09 180.63,111.97 Q15.1 180.43,110.92 180.27,110.76 179.94,110.76 179.63,111.07 179.36,111.07 179.22,110.93 179.22,110.19 179.6,109.81 179.6,109.61 179.46,109.47 178.67,109.47 178.54,109.34 178.54,109.04 178.69,108.88 179.61,108.88 179.76,108.73 179.76,108.4 179.6,108.24 R102.1
HDMI_5V:
  vias: v2(14.43,60.01)
HDMI_DDCCLK_MB: length 18.7
  TOP w0.127: v3(19.94,59.96) 20.6,59.3 v2(20.6,58.92) R298.1 20.61,57.22 Q43.3
  IN2 w0.133: CN9.15 10.55,58.99 10.55,59.99 10.82,60.27 12.59,60.27 13.33,61.01 18.95,61.01 19.2,61.26 20.12,61.26 20.48,60.9 20.48,60.44 19.99,59.96 v3(19.94,59.96)
HDMI_DDCCLK_SW: length 230.9
  TOP w0.127: R47.1 148.36,124.76 v3(148.27,124.67) ; Q43.1 23.17,59.35 23.17,61.66 v3(22.64,62.2)
  IN2 w0.102: 162.34,109.52 162.71,109.15 163.18,109.15 163.81,108.52 165.07,108.52 165.43,108.88 165.43,111.14 v3(165.93,111.64)
  IN2 w0.133: 162.34,109.52 162.34,110.99 163.09,111.75 163.09,112.94 161.58,114.45 161.58,114.94 161.36,115.16 161.36,115.87 162.66,117.17 162.66,119.84 162.18,120.32 161.67,120.32 159.44,122.55 154.3,122.55 152.88,123.97 148.97,123.97 v3(148.27,124.67) 146.36,126.58 146.36,126.64 144.25,128.75 144.14,128.75 144.12,128.77 137.88,128.77 136.48,130.17 127.58,130.17 126.99,130.75 121.1,130.75 119.73,129.39 115.11,129.39 111.79,132.71 103.56,132.71 100.99,130.13 98.28,130.13 96.18,128.03 94.28,128.03 94.06,127.81 84.65,118.4 83.59,118.4 70.37,105.17 64.64,105.17 64.01,104.54 61.09,104.54 60.48,105.16 56.81,105.16 54.71,107.25 45.95,107.25 45.5,106.8 32.6,106.8 31.91,106.1 27.73,106.1 25.62,103.99 25.62,97.48 28.02,95.08 28.02,92.05 30.37,89.71 30.37,86.89 30.21,86.74 28.24,86.74 27.09,85.59 27.09,83.36 27.79,82.66 27.79,75.2 26.48,73.89 26.48,71 22.64,67.15 v3(22.64,62.2)
  BOTTOM w0.102: v3(165.93,111.64) 165.74,111.83 U24.R40
HDMI_DDCDATA_MB: length 19.2
  TOP w0.127: v3(19.93,60.71) 20.51,60.13 R294.1 21.35,60.13 Q41.3
  IN2 w0.133: CN9.16 11.47,58.6 13.47,60.6 14.47,60.6 14.6,60.46 14.6,59.89 14.76,59.73 14.98,59.73 15.14,59.89 15.14,60.46 15.27,60.6 15.54,60.6 15.67,60.46 15.67,59.92 15.83,59.76 16.05,59.76 16.21,59.92 16.21,60.46 16.34,60.6 16.61,60.6 16.74,60.46 16.74,59.92 16.89,59.76 17.12,59.76 17.27,59.92 17.27,60.46 17.41,60.6 17.67,60.6 17.81,60.46 17.81,59.94 17.96,59.78 18.18,59.78 18.34,59.94 18.34,60.46 18.47,60.6 18.74,60.6 18.87,60.46 18.87,59.94 19.03,59.78 19.25,59.78 19.41,59.94 19.41,60.49 19.63,60.71 v3(19.93,60.71)
HDMI_DDCDATA_SW: length 231.3
  TOP w0.127: v3(147.99,124.05) 148.46,123.59 R48.1 ; v3(23.66,63.2) 24.28,62.58 24.28,62.05
  IN2 w0.102: v3(165.93,110.99) 165.63,110.69 165.63,108.8 165.16,108.32 163.72,108.32 163.19,108.86 162.52,108.86 161.94,109.43 161.94,109.56
  IN2 w0.133: v3(23.66,63.2) 23.66,63.73 23.53,63.86 23.2,63.86 23.07,64 23.07,64.27 23.2,64.4 23.53,64.4 23.66,64.54 23.66,64.81 23.53,64.94 23.3,64.94 23.14,65.1 23.14,65.33 23.3,65.48 23.53,65.48 23.66,65.62 23.66,67.62 26.87,70.83 26.87,73.72 28.17,75.02 28.17,83.31 27.97,83.52 27.75,83.52 27.59,83.67 27.59,83.9 27.75,84.06 28.22,84.06 28.38,84.21 28.38,84.44 28.22,84.6 27.66,84.6 27.48,84.78 27.48,85.43 28.4,86.35 30.37,86.35 30.75,86.73 30.75,89.87 28.41,92.21 28.41,92.4 28.56,92.55 29.28,92.55 29.44,92.71 29.44,92.95 29.28,93.11 28.72,93.11 28.41,93.41 28.41,93.74 28.54,93.88 29.28,93.88 29.44,94.03 29.44,94.26 29.28,94.42 28.54,94.42 28.41,94.55 28.41,95.24 26.01,97.64 26.01,103.83 27.89,105.72 32.07,105.72 32.74,106.39 45.64,106.39 46.11,106.87 54.55,106.87 56.65,104.77 60.12,104.77 60.75,104.13 64.15,104.13 64.8,104.79 70.52,104.79 83.75,118.01 84.82,118.01 94.46,127.65 96.34,127.65 98.44,129.75 101.15,129.75 103.7,132.3 111.64,132.3 114.94,129 119.89,129 121.26,130.36 126.83,130.36 127.42,129.78 136.31,129.78 137.72,128.36 144.09,128.36 145.97,126.48 145.97,126.08 148,124.05 v3(147.99,124.05) 148.48,123.56 152.74,123.56 154.14,122.16 159.28,122.16 161.55,119.9 161.55,116.78 160.97,116.21 160.97,115 161.19,114.78 161.19,114.29 162.7,112.78 162.7,111.91 161.94,111.15 161.94,109.56
  BOTTOM w0.102: U24.R39 165.69,111.23 v3(165.93,110.99)
HDMI_MB_HPD: length 5
  TOP w0.127: R284.1 R280.1 v3(18.44,66.74) 18.92,67.23 Q37.3
  BOTTOM w0.127: v3(18.44,66.74) 18.47,66.77 v2(18.47,67.46)
HP_DET_CN: length 12.2
  TOP w0.127: v2(16.69,67.66) 16.69,66.78 R280.2 16.06,66.74 14.86,65.54 14.86,62.91 13.13,61.18 10.72,61.18 9.65,60.11 CN9.19
HP_JD#: length 19.1
  TOP w0.381: D24.1 v3(18.24,29.14) ; R352.2 23.36,31.18 v3(23.35,31.17)
  IN2 w0.381: CN15.6 10.18,26.26 13.34,26.26 14.56,27.48 16.57,27.48 v3(18.24,29.14) 18.61,29.51 22.38,29.51 22.8,29.93 22.8,30.62 v3(23.35,31.17)
HPL: length 27.3
  TOP w0.381: v3(16.15,10.84) 16.15,11.05 15.82,11.38 R370.1 15.41,11.37 L19.2
  IN1 w0.381: v3(16.15,10.84) 18.43,13.13 18.43,21.06 19.13,21.76 25.34,21.76 26.44,22.87 29.73,22.87 30.73,23.86 v3(30.73,24.18)
HPL-1: length 6.8
  TOP w0.102: v2(9.55,10.56) 9.26,10.86 R369.1
  TOP w0.381: R368.1 12.71,12.32 L19.1 12.04,10.7 10.94,10.7 10.67,10.97 C337.1 9.96,11.4 9.88,11.47 R369.1
HPL_SYS: length 6.9
  TOP w0.102: v2(8.28,10.56) 8.48,10.75 R369.2
  TOP w0.381: CN15.1 11.5,15.33 11.5,14.97 10.71,14.18 10.71,12.71 C336.1 D19.1 9.27,12.46 8.48,11.67 R369.2
HPR: length 18.7
  TOP w0.381: R360.1 21.8,24.18 22.79,25.17 22.79,26.36 L16.2 21.7,27.25 v3(20.97,26.52)
  IN1 w0.381: v3(31.18,25.01) 30.13,26.06 28.35,26.06 27.45,25.15 23.39,25.15 23.1,24.86 22.59,24.86 22.28,24.55 21.44,24.55 20.78,25.22 20.78,26.33 v3(20.97,26.52)
HPR-1: length 5
  TOP w0.102: L16.1 v2(20.43,28.24)
  TOP w0.381: R358.1 20.39,24.71 R357.1 20.45,24.76 20.5,24.81 20.5,25.91 20.48,25.94 C323.1 20.47,25.94 20.43,25.98 L16.1
HPR_SYS: length 15.4
  TOP w0.381: v3(16.39,24.71) v2(17.12,24.71) R358.2 18.19,24.69 D17.1 C329.1
  IN1 w0.381: CN15.2 6.03,24.84 6.86,25.67 14.91,25.67 15.88,24.71 v3(16.39,24.71)
HSYNC: length 182.3
  IN2 w0.133: v3(166.3,122.67) 165.94,123.03 165.94,123.03 164.32,124.66 161.88,124.66 160.77,125.77 155.63,125.77 153.74,127.65 151.19,127.65 146.02,132.82 138.55,132.82 136.22,135.15 132.08,135.15 131.32,134.38 120.19,134.38 119.73,133.92 115.77,133.92 113.69,135.99 102.31,135.99 99.66,133.34 96.9,133.34 94.8,131.24 92.93,131.24 83.29,121.61 82.2,121.61 68.98,108.38 60.33,108.38 59.6,109.11 57.39,109.11 55.25,111.25 52.51,111.25 51.95,110.69 45.97,110.69 45.04,111.63 42.9,111.63 42.4,111.12 41.57,111.12 40.57,110.12 24.87,110.12 23.73,111.26 23.08,111.26 21.5,109.68 20.34,109.68 16.5,105.84 15.99,105.84 14.76,104.61 v4(14.76,103.62)
  BOTTOM w0.114: 168.36,119.75 168.36,119.32 168.77,118.91 R473.1
  BOTTOM w0.127: U25.2 v4(14.76,103.62) ; v3(166.3,122.67) 168.36,120.61 168.36,119.75
HWPG: length 17.2
  TOP w0.127: D6.2 187.95,57.09 187.18,56.32 185.69,56.32 R300.1 184.71,55.88 184.26,56.33 U13.84 ; D6.2 189.48,58.09 v2(189.18,58.39) ; D6.2 190.05,57.09 190.25,56.89 190.25,54.45 189.48,53.68 D8.2 D9.2 D10.2
HWPG_1.5V: length 129
  TOP w0.127: D9.1 192.1,51.66 191.32,52.44 191.32,53.28 193.56,55.52 193.56,59.72 190.07,63.21 190.07,65.91 189.48,66.49 189.48,73.55 189.07,73.96 187.97,73.96 186.98,74.95 186.36,74.95 184.36,76.95 184.36,80.97 186.82,83.43 189.81,83.43 190.82,84.44 190.82,86.01 191.43,86.62 191.43,90.02 190.58,90.87 190.58,92.01 188.83,93.76 188.83,96.28 189.74,97.2 189.74,100.14 v3(186.97,102.91) ; v3(167.7,140.15) 167.42,140.15 164.9,137.64 v2(162.74,137.64) 160.51,137.64 v3(159.16,138.98)
  IN1 w0.133: v3(167.7,140.15) 167.7,132.84 169.56,130.98 170.8,130.98 172.58,129.21 173.26,128.52 173.26,127.25 175.3,125.2 175.3,121.58 175.7,121.19 175.7,119.91 177.18,118.43 178.18,118.43 178.56,118.05 180.67,118.05 181.46,118.84 182.56,118.84 183.35,118.05 183.35,116.16 185.11,114.4 185.11,112.02 185.58,111.55 185.58,109.11 187.46,107.23 187.46,103.4 186.97,102.91 v3(186.97,102.91)
  BOTTOM w0.127: v3(159.16,138.98) 158.79,138.98 PR137.1 158.61,139.52 159.82,139.52 160.02,139.32 PU8.14
HWPG_1.05V_S5: length 90.3
  TOP w0.127: D8.1 192.1,53.7 193.89,55.49 193.89,59.75 190.33,63.32 190.33,66.03 189.74,66.62 189.74,73.65 189.18,74.21 188.18,74.21 187.19,75.2 186.49,75.2 184.69,77 184.69,80.92 186.87,83.1 189.95,83.1 191.15,84.3 191.15,85.98 191.76,86.59 191.76,90.07 190.83,91 190.83,92.26 190.03,93.07 189.08,94.01 189.08,96.07 190,96.98 190,100.24 187.57,102.67 187.57,102.95 187.15,103.37 186.64,103.37 184.84,105.17 184.84,106.44 185.86,107.46 185.86,114.34 v2(185.68,114.52) 185.14,115.05 185.14,116.48 185.37,116.71 189.08,116.71 191.3,118.93 191.3,120.6 v3(191.11,120.8)
  BOTTOM w0.127: PU4.1 190.64,121.27 v3(191.11,120.8) 191.74,120.17 PR67.1
HWPG_1.5VGFX: length 85.4
  TOP w0.254: PU11.1 122.14,190.58 121.87,190.85 v3(121.87,191.1) 121.64,191.33 PR27.1 ; v3(161.36,156.47) v2(161.36,157.23) 161.67,157.55 R33.2
  IN1 w0.254: v3(126.98,186.28) 126.98,187.58 128.93,189.53 133.01,189.53 133.83,190.35 138.42,190.35 139.4,189.38 139.4,186.86 144.07,182.19 144.94,182.19 147.65,179.48 148.77,179.48 149.78,178.47 150.35,178.47 150.61,178.73 150.61,179.29 151.19,179.87 155.05,179.87 155.72,179.2 155.72,176.19 157.11,174.8 157.71,174.8 158.77,173.74 164.99,173.74 166.68,172.05 166.68,167.59 166.9,167.38 166.9,166.73 166.02,165.85 166.02,160.09 162.39,156.46 161.36,156.46 v3(161.36,156.47)
  BOTTOM w0.254: v3(126.98,186.28) 126.27,186.99 125.79,186.99 125.02,187.75 123.63,187.75 121.87,189.5 v3(121.87,191.1)
HWPG_VDDR: length 198.9
  TOP w0.127: PR76.1 57.32,28.65 v3(56.93,28.26) ; v3(192.76,48.55) 192.76,49.12 192.66,49.22 D10.1
  IN1 w0.133: v3(192.76,48.55) 192.76,48.32 191.31,46.87 191.31,40.49 192.21,39.59 192.21,30.85 191.39,30.04 191.39,17.95 186.51,13.07 185.79,13.07 184.61,11.88 180.45,11.88 175.92,7.36 173.16,7.36 170.59,9.92 170.59,10.95 166.49,15.06 158.32,15.06 156.65,16.73 156.65,17.96 153.08,21.52 151.69,21.52 151.25,21.08 149.25,21.08 147.57,19.4 137.95,19.4 132.83,14.27 121.11,14.27 v3(120.84,14)
  BOTTOM w0.127: v3(120.84,14) 120.84,14.67 112.38,23.13 109.82,23.13 107.24,20.55 80.38,20.55 77.82,17.99 63.54,17.99 v2(63.07,18.46) 62.9,18.46 59.34,22.02 59.34,25.6 56.93,28.01 v3(56.93,28.26) 56.29,28.9 56.29,29.86 56.15,30 PU5.20
I2C1_SCL_GPIO7_CONN: length 4.2
  TOP w0.127: v3(107.83,187.52) 107.65,187.7 TP4.1
  BOTTOM w0.102: CN2.8 109.68,187.08
  BOTTOM w0.127: 109.68,187.08 108.27,187.08 v3(107.83,187.52)
I2C1_SDA_GPIO6_CONN: length 5.1
  TOP w0.127: v3(107.8,188.28) 106.76,189.32 TP1.1
  BOTTOM w0.102: CN2.7 109.68,187.58
  BOTTOM w0.127: 109.68,187.58 108.5,187.58 v3(107.8,188.28)
I2CA_SCL: length 15.1
  BOTTOM w0.127: R388.1 160.37,176.88 v2(160.37,176.84) 159.92,176.39 159.92,173.55 157.96,171.6 154.89,171.6 153.46,170.16 153.46,169.75 152.9,169.19 152.9,168.8 152.49,168.4 U19.B7
I2CA_SDA: length 10.5
  BOTTOM w0.127: R397.1 159.45,173.9 v3(159.47,173.88) 159.47,173.56 157.78,171.87 154.79,171.87 153.06,170.15 153.06,169.72 152.49,169.14 U19.A7
ICLK_BIAS: length 3.1
  TOP w0.254: v3(157.97,114.61) 157.89,114.53 R79.2 R80.2
  BOTTOM w0.279: U24.AN44 158.14,113.34 158.14,114.44 v3(157.97,114.61)
ICLK_IREF: length 2.7
  TOP w0.254: R66.1 157.82,115.31 v3(157.71,115.2)
  BOTTOM w0.254: v3(157.71,115.2) 158.1,115.2 158.55,114.75 U24.AM45
ICMNT: length 213.2
  TOP w0.127: v3(196.77,174.28) 196.77,174.27 196.94,174.27 197.2,174.01 197.4,174.01 PC28.2 197.55,173.53 196.85,173.53 196.75,173.63 PR41.1 ; v3(187.26,49.59) 187.26,49.07 186.44,48.25 v2(186.34,48.25) 186.14,48.45 C264.2 184.69,48.45 184.23,48.92 184.23,49.35 184.04,49.53 U13.67
  IN1 w0.133: v3(187.26,49.59) 187.26,49.63 188.32,50.69 188.98,50.69 192.04,53.75 192.04,58.43 191.06,59.41 191.06,62 189.62,63.44 189.62,67.43 188.44,68.61 188.44,73.1 184.84,76.7 184.84,80.33 187.35,82.85 189.38,82.85 194.02,87.48 195.44,87.48 197.1,89.14 197.1,110.68 197.1,110.68 197.1,111.52 192.67,115.96 192.67,120.5 195.92,123.75 196.51,123.75 197.93,125.18 197.93,173.2 196.86,174.27 196.77,174.27 v3(196.77,174.28)
  IN2 w0.133: v3(156.23,185.96) 156.4,185.96 157.43,184.93 161.33,184.93 163.06,183.2 163.97,183.2 165.27,181.9 172.8,181.9 175.35,179.35 181.08,179.35 183.62,181.88 183.62,187.74 184.29,188.41 187.24,188.41 188.12,189.28 190.22,189.28 191.85,187.65 191.85,180.88 194.01,178.72 194.01,177.18 196.77,174.42 v3(196.77,174.28)
  BOTTOM w0.254: PU1.7 156.37,186.11 v3(156.23,185.96)
IMVP_PWRGD: length 483.9
  TOP w0.127: v3(51.07,90.42) 51.07,91.29 50.12,92.25 50.12,94.74 PR122.2 49.8,95.53 PC170.2 50.78,96.51 52,96.51 52.52,97.03 56.12,97.03 61.76,102.67 67.29,102.67 v3(68.93,104.31) ; v3(159.54,145.11) 159.8,145.11 159.96,145.27 168.76,145.27 169.61,144.42 v3(171.55,144.42) ; v3(36.04,82.27) 38.47,84.7 43.11,84.7 44.48,86.07 v3(46.16,86.07) ; R163.1 188.32,95.59 188.32,93.55 190.07,91.8 190.07,90.62 190.92,89.77 190.92,86.83 190.32,86.22 190.32,84.7 189.58,83.97 186.63,83.97 185.54,82.89 R234.1 184.95,82.89 184.71,83.13 184.71,84.04 184.51,84.24 184.23,84.24 184.05,84.06 U8.1 184.05,82.59 183.41,81.95 183.41,81.31 182.96,80.87 181.88,80.87 R235.2 180.98,81.43 TP63.1 179.77,80.22 178.45,80.22 176.64,78.41 176.64,76.19 175.68,75.23 161.74,75.23 161.36,74.84 152.11,74.84 149.03,71.77 149.03,53.42 142.89,47.27 142.89,33.71 135.68,26.5 113.83,26.5 113.44,26.89 110.94,26.89 v3(110.3,26.26) ; U3.2 v3(179.83,170.62)
  IN1 w0.133: v3(171.55,144.42) 172.18,145.04 172.18,156.68 173.19,157.69 173.19,168.73 173.44,168.98 174.78,168.98 176.42,170.62 v3(179.83,170.62) ; v3(68.93,104.31) 68.93,107.35 81.16,119.58 85.25,119.58 103.03,137.36 105.36,137.36 v3(106,137.99) ; v3(36.04,82.27) 35.18,81.42 35.18,72.86 34.36,72.04 34.36,65.5 33.95,65.09 33.95,63.5 32.67,62.22 32.67,51.02 33.4,50.28 33.4,41.81 39.23,35.98 39.23,35.33 45.54,29.01 45.54,28.46 46.25,27.75 46.25,23.25 46.61,22.89 46.61,20.67 51.22,16.06 75.84,16.06 84.99,25.21 109.26,25.21 v3(110.3,26.26) ; v3(159.54,145.11) 158.45,145.11 157.48,144.14 157.48,143.22 152.58,138.32 139.27,138.32 138.31,137.36 116.37,137.36 v3(116.27,137.27)
  IN2 w0.133: v3(106,137.99) 106.76,138.75 114.79,138.75 v3(116.27,137.27)
  BOTTOM w0.127: v3(51.07,90.42) 51.07,88.73 48.19,85.84 46.38,85.84 v3(46.16,86.07)
IMVP_PWRGD_3V: length 4.7
  TOP w0.127: U3.4 180.3,172.61 180.37,172.68 Q59.2 R740.1
INT_AMIC-VREFO: length 4.1
  TOP w0.127: U15.27 28.6,25.32 28.28,25.01 28.28,24.65 27.85,24.21 C328.1 R362.2
INT_HDMI_HPD: length 286
  TOP w0.127: v3(146.54,116.96) 146.31,117.18 v2(146.31,118.67) R52.1 147.32,120.67 148.58,119.41 Q13.3 ; v3(21.75,68.01) 21.52,68.24 20.07,68.24 19.33,68.98 Q37.1 19.33,69.51 19.92,70.1 22.47,70.1 R63.2
  IN2 w0.133: v3(146.46,25.77) 144.95,24.27 71.17,24.27 68.17,21.27 50.94,21.27 43.3,28.91 43.3,29.23 37.88,34.65 37.88,36.3 36.18,38 22.1,38 17.78,42.32 17.78,57.49 19.27,58.98 19.93,58.98 21.16,60.22 21.16,67.43 v3(21.75,68.01)
  BOTTOM w0.127: v3(146.46,25.77) 148.54,27.86 148.54,40.35 150.88,42.69 150.88,56.7 136.44,71.14 136.44,106.7 139.3,109.56 139.3,110.2 146.05,116.96 v3(146.54,116.96)
INT_HDMICLK+: length 151.4
  IN2 w0.102: v3(112.93,112.15) 112.42,112.66 112.42,113.35 112.42,113.35 112.42,115.79 112.4,115.82 112.4,115.84
  IN2 w0.133: v3(28.43,58.75) 28.67,59 28.99,59 29.54,59.56 29.54,65.62 36.86,72.94 36.86,88.61 38.78,90.53 38.78,93.7 40.33,95.24 45.65,95.24 46.24,95.83 48.43,95.83 48.62,96.02 73.38,96.02 82.93,105.58 85.5,105.58 93.37,113.45 98.45,113.45 100.59,115.59 100.59,117.53 101.72,118.66 111.28,118.66 112.4,117.54 112.4,115.84
  BOTTOM w0.102: U27.V31 v3(112.93,112.15)
  BOTTOM w0.127: v3(28.43,58.75) 28.17,59.01 27.46,59.01 27.17,58.72 27.17,57.61 26.87,57.31 26.45,57.31 26.15,57.61 26.15,58.74 25.89,59.01 24.83,59.01 v2(24.33,58.51) 23.95,58.89 23.32,58.89 23.12,58.69 23.12,57.5 22.82,57.21 22.41,57.21 22.11,57.5 22.11,59.17 21.93,59.35 21.67,59.35 21.49,59.17 21.49,57.35 20.01,55.86 17.73,55.86 C518.1
INT_HDMICLK+_C: length 12.7
  TOP w0.127: v3(12.2,57.14) 12.48,57.42 12.48,57.6 12.8,57.93 13.58,57.93 14.16,57.35 15.45,57.35 16.01,56.79 16.01,56.18 15.8,55.97 15.5,55.97 15.12,55.59 14.74,55.59 R301.1
  BOTTOM w0.127: C518.2 16.44,55.78 15.62,55.78 R676.1 14.89,56.08 13.76,56.08 R675.1 13.25,56.05 12.92,56.05 12.39,56.59 12.39,56.96 v3(12.2,57.14)
INT_HDMICLK+_CONN: length 2.9
  TOP w0.127: CN9.10 11.42,55.82 13.19,55.82 13.42,55.59 13.8,55.59 R301.2
INT_HDMICLK-: length 151.4
  IN2 w0.102: 112.65,115.84 112.65,115.82 112.63,115.79 112.63,113.34 v3(112.83,113.14)
  IN2 w0.133: 112.65,115.84 112.65,117.65 111.39,118.92 101.61,118.92 100.33,117.64 100.33,115.69 98.35,113.71 93.27,113.71 85.39,105.83 82.83,105.83 73.27,96.28 48.52,96.28 48.32,96.08 46.13,96.08 45.55,95.5 40.22,95.5 38.53,93.8 38.53,90.64 36.61,88.72 36.61,73.04 29.29,65.72 29.29,59.66 28.88,59.25 28.69,59.25 v3(28.43,59.51)
  BOTTOM w0.114: v3(112.83,113.14) 113.28,112.69 U27.U31
  BOTTOM w0.127: C517.1 17.44,56.25 17.58,56.1 19.91,56.1 21.25,57.45 21.25,59.27 21.57,59.59 22.03,59.59 22.35,59.27 22.35,57.6 22.51,57.45 22.72,57.45 22.88,57.6 22.88,58.79 23.22,59.13 23.66,59.13 v2(24.33,59.81) 24.89,59.25 25.99,59.25 26.39,58.84 26.39,57.71 26.55,57.55 26.77,57.55 26.93,57.71 26.93,58.82 27.36,59.25 28.17,59.25 v3(28.43,59.51)
INT_HDMICLK-_C: length 12.6
  TOP w0.127: v3(12.96,57.14) 12.78,57.14 12.72,57.21 12.72,57.5 12.9,57.69 13.48,57.69 14.06,57.1 15.35,57.1 15.77,56.69 15.77,56.28 15.7,56.22 15.35,56.22 15.12,56.44 14.74,56.44 R299.1
  BOTTOM w0.127: v3(12.96,57.14) 12.76,57.14 12.63,57.01 12.63,56.69 13.02,56.29 13.19,56.29 R675.2 13.76,56.32 14.89,56.32 R674.1 15.4,56.15 15.52,56.03 16.57,56.03 16.66,56.12 C517.2
INT_HDMICLK-_CONN: length 3
  TOP w0.127: R299.2 13.8,56.44 13.42,56.44 13.18,56.2 11.6,56.2 CN9.12
INT_HDMITX0N: length 160.6
  IN2 w0.133: v3(113.93,110.15) 113.93,109.74 114.08,109.59 114.28,109.59 115.35,110.66 115.35,111.39 114.86,111.88 114.86,113.07 114.32,113.61 114.32,115.49 115.15,116.32 115.15,117.67 112.59,120.24 100.36,120.24 97.67,117.54 94.58,117.54 87.9,110.86 85.99,110.86 72.68,97.56 52.83,97.56 51.66,98.73 49.15,98.73 47.79,97.36 40.28,97.36 37.25,94.34 37.25,91.17 34.79,88.72 34.79,73.04 28.01,66.25 28.01,61.19 22.23,55.41 22.23,49.4 22.46,49.17 22.79,49.17 22.86,49.24 v3(22.86,49.46)
  BOTTOM w0.114: v3(113.93,110.15) 114.08,110.31 114.27,110.31 114.58,109.99 114.58,109.87 U27.T28
  BOTTOM w0.127: C523.1 17.38,49.04 17.52,48.9 18.31,48.9 18.56,49.14 22.76,49.14 22.86,49.24 v3(22.86,49.46)
INT_HDMITX0N_C: length 11.3
  TOP w0.127: R316.1 17.29,49.08 16.81,49.08 R320.2 16.29,49.1 15.76,49.1 v4(15.52,49.35)
  BOTTOM w0.127: C523.2 16.16,49.09 15.78,49.09 v4(15.52,49.35) 15.29,49.12 14.3,49.12 12.66,50.75 11.13,50.75 10.21,51.67 10.08,51.67 CN9.3
INT_HDMITX0P: length 160.6
  IN2 w0.133: v3(113.93,109.15) 114.11,109.34 114.38,109.34 115.6,110.56 115.6,111.5 115.11,111.98 115.11,113.17 114.57,113.72 114.57,115.38 115.41,116.22 115.41,117.77 112.69,120.49 100.25,120.49 97.56,117.8 94.48,117.8 87.79,111.12 85.88,111.12 72.58,97.81 52.93,97.81 51.77,98.98 49.05,98.98 47.69,97.62 40.17,97.62 36.99,94.44 36.99,91.28 34.54,88.82 34.54,73.14 27.75,66.36 27.75,61.3 21.98,55.52 21.98,49.29 22.35,48.91 22.65,48.91 v4(22.86,48.7)
  BOTTOM w0.114: U27.U28 v3(113.93,109.15)
  BOTTOM w0.127: v4(22.86,48.7) 22.67,48.9 18.66,48.9 18.41,48.65 17.64,48.65 C525.1
INT_HDMITX0P_C: length 11.3
  TOP w0.127: R321.1 17.3,48.84 16.8,48.84 R320.1 16.25,48.86 15.72,48.86 v3(15.5,48.63)
  BOTTOM w0.127: CN9.1 9.98,51.43 10.11,51.43 11.03,50.51 12.56,50.51 14.2,48.88 15.25,48.88 v3(15.5,48.63) 15.71,48.85 16.15,48.85 C525.2
INT_HDMITX1N: length 161.5
  IN2 w0.102: v3(113.87,112.21) 113.87,112.34 113.52,112.69 113.52,113.64 113.35,113.81 113.35,115.53 113.49,115.67 113.53,115.67 113.54,115.69
  IN2 w0.133: 113.54,115.69 114.48,116.63 114.48,117.61 112.39,119.7 100.66,119.7 97.94,116.99 94.75,116.99 84.37,106.6 82.48,106.6 72.93,97.05 48.2,97.05 48,96.85 40.49,96.85 37.76,94.12 37.76,90.96 35.31,88.51 35.31,72.83 28.52,66.04 28.52,60.87 26.83,59.18 26.83,58.43 28.3,56.96 28.3,56.69 28.11,56.49 27.86,56.49 26.27,58.08 25.75,58.08 25.18,57.51 25.18,57.01 26.68,55.51 26.68,55.24 26.49,55.05 26.22,55.05 24.71,56.57 24.21,56.57 23.64,55.99 23.64,55.5 25.43,53.71 25.43,53.43 25.23,53.23 24.95,53.23 24.42,53.76 23.38,53.76 v3(23.12,54.03)
  BOTTOM w0.102: U27.T30 114.51,111.79 114.51,112.01 114.18,112.34 114,112.34 v3(113.87,112.21)
  BOTTOM w0.127: C519.1 17.85,53.76 19.27,53.76 v2(19.79,54.29) 20.32,53.76 22.86,53.76 v3(23.12,54.03)
INT_HDMITX1N_C: length 9
  TOP w0.127: R305.1 17.37,54.22 16.92,53.78 16.43,53.78 R306.2 15.89,53.79 15.39,53.79 v3(15.11,54.07) 14.84,53.79 12.92,53.79 12.35,53.22 11.58,53.22 CN9.6
  BOTTOM w0.127: v3(15.11,54.07) 15.39,53.79 16.16,53.79 C519.2
INT_HDMITX1P: length 161.5
  IN2 w0.102: 113.36,115.87 113.35,115.85 113.35,115.81 113.15,115.62 113.15,113.72 113.31,113.56 113.31,112.61 113.46,112.46 113.46,111.63 v3(113.84,111.24)
  IN2 w0.133: 113.36,115.87 114.23,116.73 114.23,117.51 112.29,119.45 100.77,119.45 98.05,116.73 94.85,116.73 84.47,106.35 82.59,106.35 73.03,96.79 48.31,96.79 48.11,96.6 40.59,96.6 38.02,94.02 38.02,90.85 35.56,88.4 35.56,72.72 28.78,65.94 28.78,60.76 27.08,59.07 27.08,58.54 28.55,57.07 28.55,56.58 28.21,56.24 27.75,56.24 26.17,57.82 25.86,57.82 25.44,57.4 25.44,57.12 26.93,55.62 26.93,55.14 26.6,54.8 26.12,54.8 24.61,56.31 24.32,56.31 23.9,55.89 23.9,55.6 25.68,53.82 25.68,53.33 25.33,52.98 24.84,52.98 24.31,53.51 23.37,53.51 v3(23.12,53.26)
  BOTTOM w0.102: U27.U30 113.4,111.69 v3(113.84,111.24)
  BOTTOM w0.127: C520.1 17.81,53.52 19.27,53.52 v2(19.79,53) 20.32,53.52 22.86,53.52 v3(23.12,53.26)
INT_HDMITX1P_C: length 9
  TOP w0.127: R307.1 17.37,53.1 16.93,53.54 16.42,53.54 R306.1 15.88,53.55 15.38,53.55 v4(15.11,53.28) 14.85,53.55 13.02,53.55 12.45,52.98 11.58,52.98 CN9.4
  BOTTOM w0.127: C520.2 16.15,53.55 15.38,53.55 v4(15.11,53.28)
INT_HDMITX2N: length 155.4
  IN2 w0.133: v3(23.26,51.62) 23.51,51.38 26.39,51.38 26.85,51.84 26.85,52.18 26.2,52.84 26.2,53.24 26.54,53.57 26.97,53.57 27.71,52.83 27.98,52.83 28.56,53.42 28.56,53.7 27.75,54.51 27.75,55 28.05,55.3 28.47,55.3 29.25,54.51 29.51,54.51 29.68,54.69 29.68,54.95 29.14,55.49 29.14,57.83 30.06,58.75 30.06,65.4 37.38,72.72 37.38,88.4 39.3,90.32 39.3,93.48 40.5,94.68 48.06,94.68 48.88,95.51 73.6,95.51 83.15,105.06 85.71,105.06 93.57,112.92 98.68,112.92 101.2,115.44 101.2,117.42 101.91,118.13 111.09,118.13 111.83,117.39 111.83,116.72 111.46,116.35 111.46,111.66 112.53,110.59 112.53,110.29 112.63,110.19 v3(112.9,110.19)
  BOTTOM w0.102: U27.U29 v3(112.9,110.19)
  BOTTOM w0.127: C521.1 17.84,51.36 23,51.36 v3(23.26,51.62)
INT_HDMITX2N_C: length 15.3
  TOP w0.127: CN9.9 10.08,54.67 10.29,54.67 10.53,54.42 10.53,51.24 10.94,50.83 12.42,50.83 13.04,51.45 14.07,51.45 v3(14.25,51.63) 14.49,51.39 15.91,51.39 R311.2 16.44,51.35 16.89,51.35 R310.1
  BOTTOM w0.127: v3(14.25,51.63) 14.49,51.39 14.81,51.39 v2(15.32,51.9) 15.85,51.37 16.15,51.37 C521.2
INT_HDMITX2P: length 155.4
  IN2 w0.133: v3(111.9,110.19) 112.16,110.19 112.27,110.3 112.27,110.48 111.2,111.55 111.2,116.46 111.57,116.83 111.57,117.28 110.98,117.87 102.01,117.87 101.45,117.31 101.45,115.33 98.78,112.67 93.67,112.67 85.82,104.81 83.26,104.81 73.7,95.26 48.99,95.26 48.16,94.43 40.6,94.43 39.55,93.38 39.55,90.21 37.63,88.29 37.63,72.62 30.31,65.3 30.31,58.64 29.39,57.72 29.39,55.6 29.94,55.05 29.94,54.59 29.61,54.26 29.15,54.26 28.36,55.05 28.16,55.05 28,54.89 28,54.62 28.81,53.81 28.81,53.31 28.08,52.58 27.61,52.58 26.86,53.32 26.64,53.32 26.45,53.13 26.45,52.94 27.11,52.29 27.11,51.73 26.5,51.12 23.52,51.12 v4(23.26,50.86)
  BOTTOM w0.102: U27.V29 112.25,110.84 112.02,110.84 111.9,110.72 v3(111.9,110.19)
  BOTTOM w0.127: v4(23.26,50.86) 23,51.12 17.83,51.12 C522.1
INT_HDMITX2P_C: length 15.3
  TOP w0.127: CN9.7 9.98,54.43 10.19,54.43 10.29,54.32 10.29,51.14 10.84,50.59 12.52,50.59 13.14,51.21 13.96,51.21 v3(14.25,50.92) 14.48,51.15 15.87,51.15 R311.1 16.41,51.11 16.93,51.11 R314.1
  BOTTOM w0.127: v3(14.25,50.92) 14.48,51.15 14.78,51.15 v2(15.32,50.6) 15.85,51.13 16.15,51.13 C522.2
IRQ_SERIRQ: length 147.5
  TOP w0.127: R273.1 188.9,67.31 189.13,67.07 189.13,66.46 189.82,65.78 189.82,62.82 v3(191.54,61.1) ; TP53.1 153.7,90.42 R206.2 153.86,90.21 154.28,89.79 v3(154.28,89.81) ; v3(154.54,64.67) 154.54,63.87 157.82,60.6 162.54,60.6 164.24,58.9 166.14,58.9 166.78,59.53 U13.5
  IN1 w0.133: v3(154.54,64.67) 154.54,65.52 155.04,66.02 155.04,69.65 155.41,70.02 155.41,70.87 154.24,72.04 154.24,73.34 153.59,74 153.59,74.82 150.8,77.62 150.8,82.27 151.81,83.29 151.81,84.86 152.36,85.41 152.36,88.2 153.96,89.81 v3(154.28,89.81)
  IN2 w0.133: v3(154.54,64.67) 154.54,63.87 154.97,63.45 154.97,51.92 155.33,51.56 155.33,48.52 154.07,47.26 v3(153.39,47.26) ; v3(158.48,99.09) 158.42,99.09 158.01,98.68 158.01,95.44 157.23,94.67 157.23,93.63 156.61,93 156.61,91.25 155.55,90.19 155.42,90.19 155.04,89.81 v3(154.28,89.81)
  BOTTOM w0.102: v3(158.48,99.09) 158.6,99.09 U24.AL11
  BOTTOM w0.127: v3(191.54,61.1) 191.54,60.93 192.67,59.8 192.67,56.9 193.2,56.38 193.2,48.99 193.2,48.99 193.2,48.36 191.44,46.6 191.44,45.33 188.51,42.39 184.76,42.39 184.04,43.11 181.82,43.11 178.92,46.01 172.45,46.01 170.94,44.51 166.79,44.51 165,46.3 154.36,46.3 v3(153.39,47.26)
ISOLATEB: length 7.2
  TOP w0.127: R119.2 25.64,105.35 R120.1 26.98,104.83 v2(26.98,104.06) 26.98,103.83 28.25,102.56 28.25,101.29 28.12,101.16 U7.20
JTAG_TCK: length 11.4
  BOTTOM w0.127: R446.1 163.5,147.86 TP79.1 162.01,149.04 161.8,148.84 154.75,148.84 154.34,149.24 U19.AE5
JTAG_TDI: length 12.6
  BOTTOM w0.127: R451.1 153.87,141.12 TP82.1 154.54,143.6 155.37,144.44 155.37,147.86 155.19,148.04 154.82,148.04 154.54,148.33 154.54,148.56 154.26,148.83 153.65,148.83 153.29,149.19 U19.AE6
JTAG_TDO: length 9.4
  BOTTOM w0.127: U19.AF6 153.29,148.29 153.71,147.87 153.71,147.6 154.28,147.03 154.28,145.91 153.55,145.18 152.43,145.18 150.63,143.38 TP81.1
JTAG_TMS: length 14.8
  BOTTOM w0.127: R444.1 165.88,147.74 TP80.1 165.23,148.23 163.5,149.95 160.68,149.95 160.38,149.65 153.6,149.65 153.29,149.95 U19.AD6
JTAG_TRST#: length 6.7
  BOTTOM w0.127: R448.1 152.73,142.99 v2(153.17,143.43) 154.99,145.25 U19.AG4
KB_BL_LED: length 33.4
  TOP w0.127: v3(178.69,52.94) 179.6,53.85 179.6,55.31 180.73,56.45 180.73,57.02 181.07,57.35 181.92,57.35 182.49,57.93 U13.88
  BOTTOM w0.127: v3(178.69,52.94) 175.97,55.67 175.3,55.67 174.46,56.51 170.88,56.51 170.38,57.01 169.58,57.01 168.56,58.02 163.68,58.02 163.45,58.25 163.45,60.88 v2(162.13,62.2) 159.59,64.74 Q51.2
L_SPK+: length 73.5
  BOTTOM w1.016: 37.89,28.43 38.31,28.43 38.83,28.95 41.57,28.95 50.48,20.04 52.08,20.04 53.05,19.06 55.02,19.06 61.54,12.54 68.91,12.54 70.6,10.85 78.12,10.85 79.91,12.64 81.37,12.64 83.71,14.98 99.72,14.98 100.74,13.96 100.74,13.2
  vias: v2(102.19,11.4) v3(35.16,29.15) v3(35.82,29.15) v3(100.84,12.24) v3(100.84,11.52)
L_SPK+_1:
  vias: v3(104.09,6.88) v3(104.09,6.19)
L_SPK-: length 77.2
  BOTTOM w1.016: 37.76,30.35 42.14,30.35 51.06,21.43 52.65,21.43 53.63,20.46 55.6,20.46 62.12,13.94 69.49,13.94 71.18,12.25 77.55,12.25 79.33,14.04 v2(79.99,14.04) 80.79,14.04 83.13,16.38 100.84,16.38 104.32,12.9
  vias: v3(35.05,29.81) v3(35.71,29.81) v3(104.93,12.18) v3(104.96,11.5)
L_SPK-_1:
  vias: v3(105.74,6.06) v3(106.4,6.06)
LAN_DISABLE#: length 19.2
  TOP w0.127: R169.1 182.62,95.41 v3(183.07,95.41)
  IN1 w0.089: v3(168.03,99.71) 168.52,100.19 169.01,100.19 169.06,100.15 169.14,100.15 169.15,100.15 169.63,100.15 169.63,100.15 170.61,100.15 171.35,99.41
  IN1 w0.133: 171.35,99.41 171.99,98.77 171.99,98.01 172.34,97.66 178.27,97.66 179.29,96.64 181.85,96.64 v3(183.07,95.41)
  BOTTOM w0.102: v3(168.03,99.71) 167.79,99.94 U24.K13
LAN_MCT0: length 5.6
  TOP w0.762: v3(20.93,73.91) 20.98,73.91 v2(21.72,74.64) 23.47,76.39 R248.1
  BOTTOM w0.762: v3(20.93,73.91) 20.93,73.88 20.63,73.58 U29.15
LAN_MCT1: length 6.5
  TOP w0.762: R237.1 23.47,78.81 v2(21.87,77.21) 20.73,76.07 v3(20.73,75.35)
  BOTTOM w0.762: U29.16 20.22,74.85 v3(20.73,75.35)
LAN_MCT2: length 4.6
  TOP w0.762: v3(20.73,81.22) 21.47,81.22 v2(21.87,81.63) 21.88,81.64 R236.1
  BOTTOM w0.762: U29.21 20.71,81.2 v3(20.73,81.22)
LAN_MCT3: length 5.1
  TOP w0.762: v3(20.48,82.49) v2(21.85,83.86) 22.09,84.1 R233.1
  BOTTOM w0.762: U29.22 20.45,82.47 v3(20.48,82.49)
LAN_MX0+: length 19.3
  BOTTOM w0.127: U29.24 18.14,85.01 18.04,84.91 18.04,84.35 17.94,84.24 17.61,84.24 16.92,84.94 16.92,85.29 17.78,86.14 17.78,86.9 17.05,87.63 16.34,87.63 14.76,86.06 14.76,84.26 16.62,82.41 v3(16.62,81.53) 16.62,80.21 17.3,79.52 17.3,78.87 17.07,78.64 16.23,78.64 16.08,78.79 CN7.1
LAN_MX0-: length 19.3
  BOTTOM w0.127: U29.23 17.4,83.74 16.41,84.73 16.41,85.5 17.27,86.35 17.27,86.69 16.84,87.12 16.55,87.12 15.27,85.84 15.27,84.47 v3(16.74,83) 17.12,82.62 17.12,80.42 17.81,79.73 17.81,78.66 17.28,78.13 CN7.2
LAN_MX1+: length 11.2
  IN2 w0.133: CN7.3 16.08,76.73 17.29,75.51 17.29,75.16 17.42,75.03 18.11,75.03 18.6,75.53 18.6,78.5 19.67,79.56 20.44,79.56 v3(20.58,79.7)
  BOTTOM w0.127: U29.20 19.81,79.93 20.17,79.57 20.45,79.57 v3(20.58,79.7)
LAN_MX1-: length 11.3
  IN2 w0.133: v3(20.58,78.94) 20.44,79.07 19.87,79.07 19.1,78.29 19.1,75.32 18.32,74.54 17.22,74.54 16.73,74.05 CN7.6
  BOTTOM w0.127: U29.19 19.6,78.66 20.01,79.06 20.45,79.06 v3(20.58,78.94)
LAN_MX2+: length 4.6
  BOTTOM w0.127: CN7.4 15.49,76.09 15.65,76.25 16.55,76.25 17.27,76.98 17.89,76.98 v3(17.96,77.06) 18.29,77.39 U29.18
LAN_MX2-: length 4.5
  BOTTOM w0.127: CN7.5 15.71,75.44 15.71,75.6 15.86,75.75 16.76,75.75 17.48,76.47 17.91,76.47 18.27,76.12 U29.17
LAN_MX3+: length 4.4
  BOTTOM w0.127: U29.14 18.35,72.31 18.15,72.1 18.15,71.69 18,71.54 v3(17.61,71.54) 17.02,71.54 16.08,72.49 CN7.7
LAN_MX3-: length 4.4
  BOTTOM w0.127: CN7.8 15.84,72.01 16.41,71.44 16.81,71.04 U29.13
LAN_XTAL2: length 7.7
  TOP w0.127: U7.28 25.02,98.54 24.69,98.88 C189.2 24.19,98.25 23.73,97.79 v3(22.97,97.79) 22.39,97.79 22.2,97.61 20.32,97.61 20.16,97.77 Y1.3
LAN_XTALI: length 5.5
  TOP w0.127: U7.29 24.72,98.14 v3(24.27,97.69) 24.27,96.92 C196.2 24,96.84 23.85,97 23.85,97.17 23.75,97.27 22.63,97.27 Y1.1
LANCT3:
  vias: v2(26.09,86.71) v3(21.37,86.81) v3(22,87.24) v3(22,86.48) v3(22.76,87.24) v3(22.76,86.48)
LANVCC: length 1.2
  TOP w0.203: v3(31.17,97.63) 31.06,97.74 U7.11
  vias: v2(30.46,97.45) v3(25.58,95.45) v3(32.44,96.89) v3(33.1,96.94)
LCDVCC:
  vias: v2(106.55,174.67)
LID#: length 402.1
  TOP w0.127: R38.2 109.9,154.73 109.42,154.73 109.29,154.59 D1.1 109.29,149.6 108.24,148.55 108.24,141.53 104.7,137.99 104.7,133.06 78.74,107.1 72.19,107.1 70.58,105.49 64.31,105.49 64.05,105.23 62.63,103.82 61.29,103.82 56.22,98.75 49.81,98.75 48.11,100.45 46.64,100.45 46.32,100.77 45.43,100.77 45.07,100.41 43.63,100.41 43.46,100.58 v2(39.91,100.58) 35.64,100.58 v3(35.28,100.93) ; U13.86 184.12,57.13 v3(184.51,56.74)
  IN1 w0.133: v3(184.51,56.74) 184.51,55.67 183.37,54.53 183.37,48.91 186.3,45.98 186.3,41.38 185.17,40.24 185.17,23.97 184.3,23.1 184.3,17.59 182.73,16.02 177.73,16.02 177.27,15.56 171.81,15.56 171.35,16.02 169.63,16.02 165.65,20 159.58,20 158.1,21.48 158.1,24.65 156.25,26.5 148.75,26.5 146.89,24.63 143.9,24.63 141.91,22.64 122.72,22.64 120.55,20.47 83.29,20.47 75.5,12.68 71.96,12.68 69.64,15 50.74,15 44.74,21 44.74,22.71 45.19,23.16 45.19,27.3 44.48,28.02 44.48,28.58 38.16,34.9 38.16,35.5 32.34,41.32 32.34,49.84 31.61,50.58 31.61,62.65 32.89,63.94 32.89,65.53 33.3,65.94 33.3,72.47 34.12,73.3 34.12,85.54 33.65,86.01 33.65,99.3 v3(35.28,100.93)
  BOTTOM w0.127: v3(35.28,100.93) 35.41,100.81 36.17,100.81 36.48,101.11 36.48,102.15 35.87,102.76 35.49,102.76 35,103.25 CN4.2
LINE1L-VREFO: length 25.4
  TOP w0.381: R368.2 14.11,12.67 v3(14.48,13.04)
  BOTTOM w0.381: v3(14.48,13.04) 15.28,13.04 16.77,14.52 v2(16.77,19.35) 16.77,21.21 17.94,22.39 21.16,22.39 21.89,23.12 22.9,23.12 24.47,24.69 26.15,24.69 26.28,24.55 28.14,24.55 28.7,23.99 29.9,23.99 v3(30.03,24.12)
LINE1L_R: length 28.1
  TOP w0.381: C337.2 11.45,11.81 v3(11.67,12.03)
  IN1 w0.381: v3(25.68,27.3) 22.33,27.3 21.92,27.7 18.62,27.7 17.66,26.74 17.66,24.81 16.4,23.55 16.4,14.12 14.69,12.41 13.09,12.41 12.71,12.03 v3(11.67,12.03)
LINE1R-VREFO: length 10.2
  TOP w0.381: R357.2 21.44,24.76 v3(21.85,25.16)
  BOTTOM w0.381: v3(21.85,25.16) 22.36,25.16 23.7,26.51 v2(23.98,26.51) 25.58,26.51 26.65,25.44 27.41,25.44 27.74,25.78 29.11,25.78 29.7,25.18 v3(29.7,24.98)
LINE1R_R: length 7.9
  TOP w0.381: C323.2 22,25.94 v3(22.08,25.86)
  IN1 w0.381: v3(25.82,28.2) 26.18,28.2 26.71,27.66 26.71,26.83 26.18,26.29 22.37,26.29 22.08,26 v3(22.08,25.86)
LINE2-L: length 3.3
  TOP w0.203: U15.24 26.49,26.83 26.28,26.61 26.28,26.28
  TOP w0.254: T2.1 26.28,24.77 26.28,26.28
LINE2-R: length 2.5
  TOP w0.203: U15.23 26.33,27.22 25.63,26.53 25.63,26.28
  TOP w0.254: T1.1 25.63,26.28
LM393_PIN2: length 41.6
  TOP w0.508: v3(52.73,110.28) 52.76,110.31 PU9.2 55.2,110.31 55.72,109.79 PR153.2
  BOTTOM w0.508: PR156.2 19.73,101.53 20.17,101.98 20.17,104.09 25.06,108.98 40.5,108.98 41.44,109.92 v2(48.87,109.92) 52.38,109.92 v3(52.73,110.28)
LPC_LAD0: length 88.6
  TOP w0.127: v3(171.39,72.79) 171.39,72.79 171.43,72.84 176.96,72.84 177.29,73.17 180.73,73.17 184.09,69.82 184.98,69.82 185.34,69.46 U11.26 185.34,67.26 185.9,66.69 v3(186.2,66.69) ; v3(172.62,57.71) 172.52,57.71 171.9,57.09 169.7,57.09 169.26,57.53 U13.10
  IN2 w0.133: v3(172.62,57.71) 172.62,57.77 170.21,60.18 169.31,60.18 169.04,60.45 169.04,61.07 169.89,61.92 169.89,65.57 170.55,66.23 170.55,70.66 170.98,71.09 170.98,72.38 v3(171.39,72.79) 171.33,72.84 171.33,78.89 174.39,81.94 174.39,83.81 175.08,84.5 175.08,87.43 175.29,87.64 177.44,89.79 178.42,89.79 180.11,91.49 180.8,91.49 180.98,91.67 180.98,95.91 181.73,96.66 181.73,98.69 180.38,100.04 179.64,100.04 178.33,101.36 175.41,101.36 v3(174.33,102.44)
  BOTTOM w0.102: U24.A20 171.85,103.23 171.87,103.26 173.51,103.26 v3(174.33,102.44)
  BOTTOM w0.127: R665.2 186.56,64.43 186.2,64.8 v3(186.2,66.69)
LPC_LAD1: length 89.1
  TOP w0.127: U13.9 169.24,57.93 169.82,57.35 171.53,57.35 v3(171.94,57.76) ; v3(183.97,66.07) 183.39,66.65 U11.23 183.39,70.15 180.63,72.92 177.42,72.92 177.09,72.58 171.83,72.58 171.59,72.34 170.92,72.34 v3(170.55,72.71)
  IN2 w0.133: v3(173.65,102.44) 174.99,101.1 176.84,101.1 178.47,99.47 179.03,99.47 179.12,99.55 180.37,99.55 181.47,98.46 181.47,96.77 180.72,96.02 179.79,96.02 178.82,95.05 178.82,90.95 177.92,90.05 176.39,90.05 174.91,88.57 174.91,88.29 174.9,88.28 174.9,88.27 174.81,88.18 174.81,86.45 174.81,86.45 174.81,86.06 174.81,86.06 174.81,84.6 174.13,83.92 174.13,82.05 170.54,78.47 170.54,72.71 v3(170.55,72.71) 170.72,72.54 170.72,71.2 170.29,70.77 170.29,66.34 169.63,65.68 169.63,62.03 168.78,61.18 168.78,60.34 169.2,59.92 169.81,59.92 171.94,57.79 v3(171.94,57.76)
  BOTTOM w0.102: v3(173.65,102.44) 173.03,103.06 172.01,103.06 171.88,102.93 171.38,102.93 171.17,103.13 170.71,103.13 U24.C20
  BOTTOM w0.127: R670.2 185.34,64.7 v3(183.97,66.07)
LPC_LAD2: length 84.2
  TOP w0.127: v3(184.07,64.78) 183.16,64.78 181.44,66.51 U11.20 181.44,70.67 180.29,71.82 177.78,71.82 177.52,71.57 172.27,71.57 172.03,71.32 171.05,71.32 170.42,71.95 v3(169.75,71.95) ; U13.8 169.49,58.33 v3(170.01,57.81)
  IN2 w0.133: v3(172.35,102.43) 172.35,102.24 172.82,101.77 173.28,101.77 176.1,98.95 179.25,98.95 179.33,99.03 180.13,99.03 180.75,98.42 180.75,96.79 180.51,96.54 179.57,96.54 178.3,95.26 178.3,91.17 177.7,90.58 175.53,90.58 173.69,88.74 173.69,88.73 173.61,88.65 173.61,86.38 173.61,86.38 173.61,86 173.61,86 173.61,84.14 173.61,84.14 173.61,83.5 171.81,81.7 171.81,80.76 169.75,78.69 v3(169.75,71.95) 169.77,71.94 169.77,68.04 169.01,67.28 169.01,64.15 167.84,62.98 167.84,60.54 169.93,58.45 169.93,57.88 v3(170.01,57.81)
  BOTTOM w0.102: v3(172.35,102.43) 172.32,102.47 171.57,102.47 U24.A18
  BOTTOM w0.127: R669.2 184.19,64.66 v3(184.07,64.78)
LPC_LAD3: length 86.2
  TOP w0.127: v3(183.05,63.95) 183.05,64.54 180.42,67.17 179.59,67.17 179.49,67.28 U11.17 179.49,69.07 179.35,69.21 179.35,70.25 179.89,70.78 179.89,71.24 179.56,71.57 177.88,71.57 177.63,71.31 172.38,71.31 172.14,71.07 170.58,71.07 v3(170.26,71.39) ; v3(171.28,57.8) 170.35,58.73 U13.7
  IN2 w0.133: v3(173,102.42) 176.21,99.21 179.14,99.21 179.23,99.29 180.26,99.29 181.01,98.55 181.01,96.68 180.61,96.28 179.68,96.28 178.56,95.16 178.56,91.06 177.81,90.32 175.64,90.32 173.87,88.54 173.87,86.49 173.87,86.49 173.87,85.89 173.87,84.03 173.87,84.03 173.87,82.16 170.01,78.3 170.01,74.24 170.01,72.6 170.26,72.35 v3(170.26,71.39) 170.03,71.16 170.03,67.94 169.27,67.18 169.27,62.03 168.52,61.28 168.52,60.23 170.96,57.8 v3(171.28,57.8)
  BOTTOM w0.102: v3(173,102.42) 172.57,102.85 172.15,102.85 172.02,102.72 171.39,102.72 171.17,102.51 170.7,102.51 U24.C18
  BOTTOM w0.127: R668.2 v3(183.05,63.95)
LPC_LFRAME#: length 88.3
  TOP w0.127: v3(171.57,71.83) 171.82,71.83 172.06,72.08 177.3,72.08 177.55,72.33 180.5,72.33 182.74,70.08 U11.22 182.74,67 v3(182.8,66.95) ; v3(173.28,57.71) 173.28,57.83 171.87,59.24 168.7,59.24 168.59,59.13 U13.6
  IN2 w0.089: v3(174.99,102.53) 175.03,102.48
  IN2 w0.133: v3(173.28,57.71) 173.28,57.85 170.93,60.21 170.93,63.21 170.4,63.73 170.4,65.36 171.61,66.56 171.61,67.23 171.06,67.77 171.06,70.45 171.57,70.95 v3(171.57,71.83) 172.54,72.8 172.54,79.3 172.54,79.3 172.54,79.32 174.9,81.68 174.9,83.51 174.9,83.51 174.9,83.6 175.59,84.29 175.59,87.21 177.66,89.28 178.63,89.28 180.25,90.9 180.94,90.9 181.49,91.45 181.49,95.7 182.24,96.45 182.24,98.99 180.67,100.56 179.85,100.56 179.38,101.03 179.38,101.64 179.1,101.92 178.29,101.92 178.24,101.88 175.64,101.88 175.03,102.48
  BOTTOM w0.102: v3(174.99,102.53) 174.81,102.53 174.5,102.84 174.21,102.84 173.52,103.54 171.19,103.54 U24.B21
  BOTTOM w0.127: R667.2 182.01,63.3 182.01,66.16 v3(182.8,66.95)
M_A_A0: length 56.7
  IN1 w0.089: v3(111.93,89.16) 111.53,88.75 111.53,82.88 111.76,82.64
  IN1 w0.216: 111.76,82.64 112.07,82.33 112.07,77.25 111,76.18 111,68.85 104.15,62 104.15,61.39 102.87,60.12 102.87,58.62 102.76,58.5 102.76,51.8 104.5,50.06 104.5,44.75 104.27,44.51 104.27,43.11 v3(104.5,42.88)
  BOTTOM w0.178: v3(111.93,89.16) 112.4,89.62 U27.V8
  BOTTOM w0.191: v3(104.5,42.88) 105.19,42.19 105.19,40.16 105.55,39.8 JDIM2.98
M_A_A1: length 65.7
  IN1 w0.089: 109.36,83.16 109.21,83.31 109.21,83.78 109,83.99 109,85.72 108.87,85.84 108.42,85.84 108.33,85.94 108.33,86.1 108.4,86.18 108.87,86.18 108.97,86.28 108.97,86.48 108.87,86.58 106.61,86.58 106.46,86.73 106.46,87.01 106.6,87.16 v3(106.93,87.16)
  IN1 w0.216: v3(103.11,42.9) 102.85,42.65 102.38,42.65 102.22,42.81 102.22,43.17 102.4,43.36 102.62,43.36 102.8,43.54 102.8,43.8 102.62,43.98 102.4,43.98 102.22,44.16 102.22,45.21 102.79,45.78 102.79,49.35 100.54,51.6 100.54,53.5 100.67,53.63 100.67,57.02 101.06,57.42 101.06,57.93 100.88,58.11 100.49,58.11 100.31,58.29 100.31,58.55 100.49,58.73 100.88,58.73 101.06,58.91 101.06,59.17 100.88,59.35 100.49,59.35 100.31,59.54 100.31,59.79 100.49,59.98 100.88,59.98 101.06,60.16 101.06,60.35 100.74,60.67 100.74,61.02 101.53,61.81 102.14,61.81 102.44,62.1 102.44,62.71 109.25,69.53 109.25,76.86 110.36,77.96 110.36,81.67 109.62,82.42 109.62,82.9 109.36,83.16
  BOTTOM w0.178: v3(106.93,87.16) 106.93,87.22 U27.AC6
  BOTTOM w0.191: v3(103.11,42.9) 103.49,42.52 103.87,42.52 104,42.65 104,43.03 104.47,43.51 104.47,43.96 104.22,44.21 104.22,44.55 104.43,44.76 104.76,44.76 105.25,45.25 JDIM2.97
M_A_A2: length 76.2
  IN1 w0.216: v3(103.69,41.73) 104.21,41.21 104.21,38.38 104.68,37.91 106.43,37.91 106.61,38.1 106.61,38.38 106.44,38.55 105.03,38.55 104.86,38.73 104.86,39.03 105.03,39.21 106.37,39.21 106.53,39.37 106.53,39.68 106.35,39.86 105.08,39.86 104.78,40.16 104.78,41.8 103.81,42.77 103.81,45.11 103.93,45.23 103.93,49.82 101.99,51.77 101.99,53.7 102.21,53.92 102.21,60.26 103.58,61.63 103.58,62.24 110.42,69.08 110.42,76.41 111.5,77.49 111.5,82.12 110.85,82.77 110.85,83.36 110.44,83.76 110.44,88.33 111.39,89.28 111.4,89.28 111.75,89.63 112.4,89.63 v3(112.93,90.16)
  BOTTOM w0.178: v3(112.93,90.16) U27.V9
  BOTTOM w0.191: v3(103.69,41.73) 103.69,42.06 103.77,42.14 104.58,42.14 104.71,42.01 104.71,41.33 104.58,41.2 104.28,41.2 104.15,41.07 104.15,40.69 104.28,40.57 104.61,40.57 104.76,40.41 104.76,40.03 104.95,39.84 JDIM2.96
M_A_A3: length 76.5
  IN1 w0.216: v3(113.92,90.16) 113.92,90.5 113.72,90.69 111.66,90.69 111.61,90.65 107.6,90.65 107.42,90.47 107.42,89 107.24,88.82 106.56,88.82 106.39,88.65 106.39,87.84 106.58,87.65 108.26,87.65 108.41,87.8 108.41,89.54 108.56,89.69 110.53,89.69 110.72,89.5 110.72,89.2 110.21,88.69 109.58,88.69 109.39,88.5 109.39,83.94 110.1,83.23 110.1,82.78 110.93,81.95 110.93,77.73 109.83,76.63 109.83,69.3 103.01,62.48 103.01,61.87 101.64,60.49 101.64,57.25 101.12,56.73 101.12,51.83 103.36,49.59 103.36,45.65 102.72,45.01 102.72,44.73 v3(103.23,44.22)
  BOTTOM w0.178: v3(113.92,90.16) 113.4,90.68 U27.U9
  BOTTOM w0.191: JDIM2.95 104.65,45.89 104.78,45.77 104.78,45.46 104.6,45.28 104.37,45.28 104.14,45.51 103.86,45.51 103.71,45.36 103.71,45.13 103.86,44.98 103.86,43.53 103.68,43.35 103.18,43.35 103,43.53 103,43.99 v3(103.23,44.22)
M_A_A4: length 66.3
  IN1 w0.089: v3(106.93,86.16) 107.36,86.16 107.47,86.05 107.47,85.69 107.57,85.59 108.67,85.59 108.74,85.51 108.74,85.26 108.67,85.18 108.41,85.18 108.33,85.1 108.33,84.93 108.42,84.84 108.65,84.84 108.74,84.75 108.74,84.57 108.65,84.48 108.39,84.48 108.33,84.42 108.33,84.32 109.01,83.64 109.01,83.04 109.22,82.82 109.22,82.61 109.18,82.57
  IN1 w0.216: 109.18,82.57 109.18,82.07 109.79,81.47 109.79,78.2 108.67,77.08 108.67,69.75 99.74,60.82 99.74,58.46 99.69,58.42 99.69,53.62 99.85,53.46 99.85,51.48 102.22,49.11 102.22,45.9 101.81,45.49 101.81,42.04 101.99,41.87 102.79,41.87 102.99,41.68 102.99,40.27 102.63,39.92 102.63,37.45 102.88,37.21 103.96,37.21 104.14,37.39 104.14,37.64 103.94,37.84 103.41,37.84 103.26,38 103.26,39.57 103.64,39.96 v3(103.64,40.39)
  BOTTOM w0.178: U27.AC5 106.93,86.22 v3(106.93,86.16)
  BOTTOM w0.191: JDIM2.92 103.75,40.28 v3(103.64,40.39)
M_A_A5: length 68.6
  IN1 w0.089: v5(106.93,85.16) 106.99,85.16 108.63,83.51 108.63,81.44 108.67,81.4 108.67,80.86 108.64,80.84
  IN1 w0.216: v3(100.48,42.36) 101,42.89 101,46.1 101.08,46.18 101.08,47.97 98.71,50.34 98.71,58.24 98.59,58.36 98.59,61.29 100.56,63.26 100.56,63.52 100.18,63.9 100.18,64.15 100.36,64.34 100.62,64.34 101,63.96 101.25,63.96 101.44,64.14 101.44,64.4 101.06,64.78 101.06,65.03 101.24,65.22 101.5,65.22 101.88,64.84 102.13,64.84 102.32,65.02 102.32,65.28 101.94,65.66 101.94,65.91 102.12,66.1 102.38,66.1 102.76,65.72 103.02,65.72 103.2,65.9 103.2,66.16 102.82,66.54 102.82,66.79 103,66.98 103.26,66.98 103.64,66.6 103.9,66.6 104.08,66.78 104.08,67.04 103.7,67.42 103.7,67.67 103.88,67.86 104.14,67.86 104.52,67.48 104.78,67.48 104.96,67.66 104.96,67.92 104.58,68.3 104.58,68.55 104.76,68.74 105.02,68.74 105.4,68.36 105.66,68.36 105.84,68.54 105.84,68.8 105.46,69.18 105.46,69.44 105.64,69.62 105.9,69.62 106.28,69.24 106.54,69.24 106.7,69.4 106.7,69.73 106.33,70.1 106.33,70.36 106.52,70.55 107.28,70.55 107.51,70.77 107.51,71.08 107.34,71.24 107,71.24 106.83,71.4 106.83,71.8 107.51,72.48 107.51,77.54 108.64,78.67 108.64,80.84
  BOTTOM w0.178: U27.AC4 107.16,85.69 106.93,85.45 v5(106.93,85.16)
  BOTTOM w0.191: v3(100.48,42.36) 100.67,42.17 101.08,42.17 101.21,42.3 101.21,42.89 101.4,43.08 101.71,43.08 102.07,42.72 102.39,42.72 102.52,42.85 102.52,44.8 103.45,45.73 JDIM2.91
M_A_A6: length 66.8
  IN1 w0.089: v3(105.93,87.16) 105.64,86.87 105.64,86.68 105.77,86.56 106.28,86.56 106.44,86.39 106.44,85.98 106.77,85.65 107.13,85.65 107.43,85.34 107.43,84.96 108.8,83.59 108.8,81.77 109.08,81.49
  IN1 w0.216: v3(102.52,41.15) 102.06,40.69 102.06,37.31 101.88,37.13 101.55,37.13 101.41,37.28 101.41,45.77 101.65,46.01 101.65,48.22 99.28,50.58 99.28,53.32 99.17,53.44 99.17,61.06 108.08,69.97 108.08,77.3 109.22,78.44 109.22,81.36 109.08,81.49
  BOTTOM w0.178: U27.AD6 105.93,87.22 v3(105.93,87.16)
  BOTTOM w0.191: JDIM2.90 103.15,41.59 103.01,41.73 102.65,41.73 102.52,41.61 v3(102.52,41.15)
M_A_A7: length 68.2
  IN1 w0.089: 107.5,81.07 107.5,81.7 107.43,81.77 107.43,82.22 107.76,82.55 107.76,82.75 107.43,83.08 107.43,83.49 107.36,83.56 106.52,83.56 106.42,83.67 106.42,84.27 106.54,84.4 106.85,84.4 106.93,84.32 v3(106.93,84.16)
  IN1 w0.216: v3(100.44,41.7) 100.35,41.61 100.08,41.61 99.93,41.76 99.93,46.3 99.83,46.4 99.83,47.6 97.57,49.87 97.57,53.85 97.18,54.24 97.18,58.08 97.44,58.35 97.44,64.5 97.85,64.9 98.11,64.9 98.58,64.43 98.84,64.43 99.02,64.61 99.02,64.87 98.55,65.34 98.55,65.6 98.73,65.78 98.99,65.78 99.46,65.31 99.72,65.31 99.9,65.49 99.9,65.75 99.43,66.22 99.43,66.48 99.61,66.66 99.87,66.66 100.34,66.19 100.6,66.19 100.78,66.37 100.78,66.63 100.31,67.1 100.31,67.36 100.49,67.54 100.75,67.54 101.22,67.07 101.48,67.07 101.66,67.25 101.66,67.51 101.19,67.98 101.19,68.24 101.37,68.42 101.63,68.42 102.1,67.95 102.36,67.95 102.54,68.13 102.54,68.39 102.07,68.86 102.07,69.12 103.14,70.2 103.14,70.46 102.63,70.97 102.63,71.23 102.81,71.41 103.07,71.41 103.59,70.9 103.84,70.9 104.03,71.08 104.03,71.34 103.51,71.85 103.51,72.11 103.69,72.29 103.95,72.29 104.47,71.78 104.72,71.78 104.91,71.96 104.91,72.22 104.39,72.73 104.39,72.99 106.28,74.88 106.28,77.92 107.5,79.15 107.5,81.07
  BOTTOM w0.178: U27.AC3 106.93,84.22 v3(106.93,84.16)
  BOTTOM w0.191: JDIM2.86 101.95,41.66 101.82,41.8 101.55,41.8 101.07,41.32 100.81,41.32 v3(100.44,41.7)
M_A_A8: length 68.7
  IN1 w0.089: v3(105.93,86.16) 105.68,86.16 105.57,86.04 105.57,85.69 105.64,85.62 106.27,85.62 106.42,85.47 106.42,84.78 106.59,84.61 107.11,84.61 107.43,84.29 107.43,83.8 107.56,83.67 108.02,83.67 108.45,83.25 108.45,83 108.19,82.75 108.19,82.5 108.45,82.24 108.45,81.97 108.07,81.59 108.07,81.35
  IN1 w0.216: v3(100.5,43.77) 100.5,43.77 100.5,47.74 98.14,50.1 98.14,53.21 98.23,53.3 98.23,58.01 98.01,58.22 98.01,61.52 98.66,62.17 98.66,62.53 98.01,63.17 98.01,63.45 98.21,63.64 98.49,63.64 99.16,62.98 99.42,62.98 99.6,63.16 99.6,63.42 99.22,63.8 99.22,64 103.47,68.26 103.47,68.51 103,68.99 103,69.24 103.18,69.43 103.44,69.43 103.91,68.95 104.17,68.95 104.35,69.14 104.35,69.39 103.83,69.91 103.83,70.17 104.01,70.35 104.27,70.35 104.79,69.83 105.05,69.83 105.23,70.02 105.23,70.27 104.71,70.79 104.71,71.05 104.9,71.23 105.15,71.23 105.63,70.75 105.92,70.75 106.26,71.1 106.26,71.38 105.57,72.08 105.57,72.36 105.72,72.51 106.73,72.51 106.93,72.71 106.93,72.97 106.73,73.17 106.06,73.17 105.86,73.37 105.86,73.66 106.06,73.86 106.66,73.86 106.86,74.06 106.86,77.7 108.07,78.91 108.07,81.35
  BOTTOM w0.178: U27.AD5 105.93,86.22 v3(105.93,86.16)
  BOTTOM w0.191: v3(100.5,43.77) 100.79,43.48 101.86,43.48 102.14,43.77 102.14,44.07 102.02,44.2 101.28,44.2 101.15,44.32 101.15,44.63 101.28,44.76 101.97,44.76 102.85,45.63 JDIM2.89
M_A_A9: length 66.9
  IN1 w0.089: 106.36,80.51 106.36,81.12 106.51,81.27 106.51,82.44 106.63,82.56 107.2,82.56 107.29,82.65 107.29,82.79 v3(106.93,83.16)
  IN1 w0.216: v3(99.02,43.09) 98.54,43.09 98.36,43.27 98.36,43.81 98.54,43.99 98.86,43.99 99.06,44.2 99.06,44.61 98.86,44.82 98.54,44.82 98.36,45 98.36,45.68 98.69,46.01 98.69,47.13 95.93,49.88 95.93,52.52 95.61,52.84 95.61,53.46 95.97,53.82 95.97,54.07 95.61,54.43 95.61,57.88 96.3,58.57 96.3,65.04 96.99,65.73 96.99,65.93 96.3,66.62 96.3,66.88 96.48,67.06 96.74,67.06 97.43,66.37 97.69,66.37 97.87,66.55 97.87,66.81 97.36,67.32 97.36,67.58 97.54,67.76 97.8,67.76 98.31,67.25 98.57,67.25 98.75,67.43 98.75,67.69 98.24,68.2 98.24,68.46 98.42,68.64 98.68,68.64 99.19,68.13 99.45,68.13 99.63,68.31 99.63,68.57 99.12,69.08 99.12,69.34 99.3,69.52 99.56,69.52 100.07,69.01 100.33,69.01 100.51,69.19 100.51,69.45 100.03,69.93 100.03,70.19 100.22,70.38 100.46,70.38 100.94,69.89 101.21,69.89 101.4,70.08 101.4,70.33 100.92,70.81 100.92,71.14 104.89,75.11 104.89,78.15 106.36,79.62 106.36,80.51
  BOTTOM w0.178: U27.AC2 106.96,83.69 106.77,83.49 106.77,83.31 v3(106.93,83.16)
  BOTTOM w0.191: JDIM2.85 101.65,45.82 99.96,44.12 99.96,42.06 99.78,41.88 99.45,41.88 99.29,42.03 99.29,42.82 v3(99.02,43.09)
M_A_A10: length 70.7
  IN1 w0.089: v3(112.93,87.16) 112.5,87.16 112.35,87.31 112.35,87.52 112.5,87.67 113.06,87.67 113.29,87.9 113.57,87.9 113.8,87.67 114.13,87.67 114.36,87.45 114.36,86.86 114.58,86.64 115.42,86.64 115.54,86.51 115.54,85.76 115.68,85.62 116.22,85.62 116.33,85.51 116.33,84.97 116.08,84.73 116.08,84.57 116.18,84.47 116.46,84.47 116.62,84.32 116.62,84.17 116.41,83.97 116.41,83.74 116.62,83.53 116.62,82.58 116.53,82.49 115.98,82.49 115.88,82.38 115.88,82.24 115.98,82.13 116.53,82.13 116.62,82.04 116.62,81.86 116.51,81.76 116.26,81.76 116.13,81.62 116.13,81.43
  IN1 w0.216: 116.13,81.43 116.13,68.37 112.7,64.95 112.7,64.69 113.56,63.83 113.56,63.57 113.38,63.39 113.12,63.39 112.26,64.25 112,64.25 111.82,64.07 111.82,63.81 112.34,63.29 112.34,63.03 112.16,62.85 111.9,62.85 111.38,63.37 111.12,63.37 110.94,63.19 110.94,62.93 111.46,62.41 111.46,62.15 111.28,61.97 111.02,61.97 110.5,62.49 110.24,62.49 110.06,62.31 110.06,62.05 110.58,61.53 110.58,61.27 110.4,61.09 110.14,61.09 109.89,61.34 109.63,61.34 109.45,61.16 109.45,60.9 109.7,60.65 109.7,60.39 109.4,60.09 109.4,55.75 108.86,55.21 108.86,48.27 108.58,47.99 108.58,46.14 109.05,45.66 109.05,44.86 108.87,44.68 v3(108.87,43.56)
  BOTTOM w0.178: v3(112.93,87.16) 112.93,87.52 112.77,87.69 U27.V6
  BOTTOM w0.191: v3(108.87,43.56) 108.52,43.56 108.34,43.38 108.34,42.26 108.16,42.08 107.8,42.08 107.62,42.26 107.62,43.63 107.9,43.91 107.9,45.51 108.25,45.86 JDIM2.107
M_A_A11: length 65.2
  IN1 w0.216: v3(100.72,40.43) 100.72,37.56 100.36,37.21 97.59,37.21 97.42,37.38 97.42,37.71 97.62,37.92 99.83,37.92 100.05,38.15 100.05,38.88 99.86,39.08 98.61,39.08 98.42,39.26 98.42,39.6 98.61,39.79 99.75,39.79 99.98,40.02 99.98,40.48 99.53,40.93 99.53,45.66 99.26,45.92 99.26,47.37 96.51,50.12 96.51,52.92 96.66,53.07 96.66,58.25 96.87,58.46 96.87,64.73 102.21,70.07 102.21,70.33 101.71,70.83 101.71,71.12 105.69,75.11 105.69,78.15 106.93,79.38 v3(106.93,82.16)
  BOTTOM w0.178: U27.AC1 106.93,82.22 v3(106.93,82.16)
  BOTTOM w0.191: JDIM2.84 101.35,40 100.92,40.43 v3(100.72,40.43)
