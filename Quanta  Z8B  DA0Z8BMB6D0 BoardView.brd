# Allegro board Quanta  Z8B  DA0Z8BMB6D0 BoardView.brd (continued)
## Nets (continued)
+VCCIO_OUT: C406.2 R68.2 R453.2 R457.2 R458.2 R468.2 R482.1 R520.1 R533.1
+VCCIO_OUT_R: R482.2 U27.AN35
+VCCIO_PCH: C138.2 R116.1 R117.1 R129.1
+VCCIO_PCH_R: R117.2 U27.A23
+VCCIOA_OUT: R100.2 R105.1 R107.1
+VCCIOA_OUT_R: R105.2 U27.F22
+VCCPDSW: C168.2 R127.2 R136.2 U24.A16
+VCCPRTCSUS_3P3: C190.1 R149.2 R151.2 U24.K8
+VCCRTCEXT: C177.2 U24.P14 U24.P16
+VCCSST: C178.2 U24.AA14
+VCCST: C388.1 C390.1 R462.2 U27.AK31
+VIN_VCCIN: PC71.2 PC72.2 PC73.2 PC74.2 PC144.2 PC149.2 PC159.2 PC161.2 PL14.1 PL15.1 PR95.1 PU6.5 PU12.5
AGND_CPU: PC77.2 PC78.2 PC79.2 PC86.2 PC88.2 PC89.2 PC92.2 PC154.2 PC156.2 PC158.2 PR98.1 PR99.2 PR100.2 PR101.2 PR102.2 PR103.1 PR124.1 PR133.2 PR135.2 PR193.2 PR218.1 PU7.29 PU7.33 PU7.34 PU7.35 PU7.36 PU7.37 PU7.38 PU7.39 PU7.40 PU7.41 PU7.42
AGND_DDR: PC59.2 PC68.2 PC69.2 PR80.1 PR81.1 PR83.2 PR86.2 PU5.7 PU5.21 PU5.22 PU5.23 PU5.24 PU5.25 PU5.26
AVDD: C557.1 C558.1 C559.2 L32.1 U32.4
DVDD: C544.2 C545.2 C546.1 C548.2 C549.1 L32.2 R707.2 R709.1 U32.1 U32.19 U32.23
DVDD_IO: C306.1 C530.1 R692.1 R693.1 U15.9
GND: BT1.2 C1.2 C3.1 C4.1 C5.1 C6.2 C7.2 C8.2 C9.1 C10.1 C11.1 C12.1 C14.1 C15.1 C16.2 C17.2 C18.2 C19.2 C20.1 C21.2 C22.1 C23.1 C24.2 C25.2 C26.2 C27.2 C28.2 C29.1 C30.1 C31.1 C32.1 C33.1 C34.2 C35.1 C36.2 C37.1 C38.1 C39.2 C40.1 C41.1 C42.1 C43.2 C44.1 C45.2 C46.1 C47.1 C48.1 C49.2 C50.1 C51.2 C52.1 C53.2 C54.1 C55.1 C56.1 C57.1 C58.2 C59.1 C60.1 C61.1 C62.1 C63.1 C64.2 C65.2 C66.1 C67.1 C68.1 C69.2 C70.2 C71.1 C72.2 C73.2 C74.2 C75.2 C76.1 C77.2 C78.1 C79.1 C80.1 C81.1 C82.1 C83.2 C84.2 C85.2 C94.1 C95.1 C96.1 C97.1 C98.1 C99.1 C100.2 C101.2 C102.1 C111.1 C112.1 C113.1 C114.1 C115.2 C116.1 C117.2 C118.2 C120.2 C121.2 C122.2 C123.2 C124.1 C125.2 C126.2 C127.1 C128.2 C129.1 C130.2 C131.2 C132.2 C133.1 C134.1 C135.2 C136.1 C137.1 C138.1 C139.2 C140.2 C141.2 C142.2 C143.2 C144.1 C145.2 C146.2 C147.2 C148.2 C149.1 C150.2 C151.2 C152.1 C153.1 C154.1 C155.2 C158.2 C159.1 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.1 C169.2 C170.1 C171.2 C172.2 C173.1 C174.2 C175.2 C176.2 C177.1 C178.1 C179.1 C180.2 C181.1 C182.1 C183.2 C184.1 C185.2 C186.1 C187.2 C188.1 C189.1 C190.2 C191.1 C192.2 C193.2 C194.2 C195.1 C196.1 C197.2 C198.2 C199.1 C200.2 C201.1 C202.1 C203.1 C204.2 C205.1 C206.2 C207.2 C208.2 C209.1 C210.2 C211.2 C212.2 C213.2 C214.1 C215.2 C216.1 C217.2 C220.2 C221.1 C222.1 C223.2 C224.2 C225.1 C226.1 C227.2 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C237.2 C238.2 C239.2 C240.2 C241.1 C242.2 C243.2 C244.1 C245.2 C246.1 C248.2 C249.2 C250.2 C251.2 C252.1 C253.1 C254.1 C255.1 C256.2 C257.2 C258.2 C259.2 C260.2 C261.2 C262.2 C263.2 C265.2 C266.2 C267.2 C268.1 C269.1 C270.2 C271.2 C272.2 C273.2 C274.2 C275.1 C276.1 C277.2 C278.2 C279.1 C280.1 C281.1 C282.2 C284.2 C285.2 C286.1 C287.2 C288.2 C290.2 C291.2 C292.2 C293.1 C294.1 C295.1 C296.2 C297.2 C298.1 C299.2 C301.1 C302.2 C303.2 C304.2 C306.2 C307.2 C308.1 C313.2 C316.2 C318.2 C321.1 C325.2 C326.2 C332.1 C333.1 C334.1 C335.1 C338.2 C339.2 C340.2 C341.2 C342.2 C350.1 C351.1 C352.1 C353.1 C354.1 C355.1 C356.1 C357.1 C358.2 C359.2 C360.2 C361.1 C362.2 C363.1 C364.2 C365.1 C366.2 C367.1 C368.2 C369.1 C370.1 C372.2 C373.1 C374.1 C375.1 C376.2 C377.2 C378.2 C379.1 C380.2 C381.1 C382.2 C383.1 C384.1 C385.2 C386.1 C387.1 C388.2 C389.1 C390.2 C391.1 C406.1 C407.1 C408.2 C409.1 C412.2 C413.1 C414.1 C415.1 C416.1 C417.2 C418.2 C419.1 C420.1 C425.1 C426.1 C427.1 C428.2 C429.1 C430.2 C431.2 C432.1 C433.1 C434.1 C435.1 C436.1 C437.1 C438.1 C439.1 C440.2 C441.1 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.1 C449.1 C450.2 C451.1 C452.2 C453.2 C454.1 C455.1 C456.1 C457.1 C458.1 C459.2 C460.1 C461.1 C462.1 C463.2 C464.1 C465.1 C466.1 C467.2 C468.1 C469.2 C470.1 C471.2 C472.2 C473.2 C474.1 C475.1 C476.1 C477.1 C478.1 C479.2 C480.2 C481.2 C482.1 C483.2 C484.1 C485.2 C486.1 C487.2 C488.2 C489.1 C490.2 C491.2 C492.1 C493.2 C495.1 C497.1 C500.2 C501.2 C502.2 C503.1 C504.1 C505.2 C506.1 C507.2 C508.1 C509.1 C510.1 C511.1 C512.1 C513.2 C514.2 C515.1 C516.1 C524.2 C526.2 C527.1 C528.1 C529.1 C530.2 C531.1 C535.1 C536.2 C538.1 C539.2 C540.1 C541.2 C542.2 C543.2 C544.1 C545.1 C546.2 C547.2 C548.1 C549.2 C550.2 C551.1 C552.2 C553.2 C554.1 C555.2 C556.2 C557.2 C558.2 C559.1 C560.1 C561.2 C562.2 C563.2 C564.2 C565.2 C566.2 C567.2 C568.2 C569.2 C570.1 C715.2 C716.1 C717.1 C718.1 C719.1 C720.1 C721.1 C722.1 C723.1 C724.1 C725.1 C726.2 C727.1 C728.2 C729.1 C730.2 C731.1 C732.1 C733.1 C734.2 C735.1 C736.2 C737.1 C738.1 C739.1 C740.1 C741.1 C742.2 C743.1 C744.1 C745.1 C746.1 C747.1 C748.1 C749.1 C750.2 C751.1 C752.2 C753.1 C754.1 CN1.3 CN1.6 CN1.12 CN1.13 CN1.14 CN1.15 CN2.3 CN2.9 CN2.12 CN2.15 CN2.18 CN2.21 CN2.24 CN2.28 CN2.41 CN2.42 CN2.43 CN2.44 CN3.3 CN4.4 CN4.5 CN4.6 CN5.5 CN5.6 CN5.7 CN5.8 CN5.10 CN5.16 CN5.17 CN6.1 CN6.4 CN6.7 CN6.12 CN6.13 CN6.14 CN6.15 CN8.1 CN8.5 CN8.6 CN9.2 CN9.5 CN9.8 CN9.11 CN9.17 CN9.20 CN9.21 CN9.22 CN9.23 CN10.4 CN10.9 CN10.15 CN10.18 CN10.21 CN10.26 CN10.27 CN10.29 CN10.34 CN10.35 CN10.37 CN10.40 CN10.43 CN10.50 CN10.53 CN10.54 CN11.1 CN11.4 CN11.7 CN11.11 CN11.12 CN11.13 CN11.17 CN11.19 CN11.23 CN11.24 CN12.4 CN12.7 CN12.10 CN12.11 CN12.12 CN12.13 CN13.1 CN13.4 CN13.11 CN13.12 CN14.27 CN14.28 CN16.3 CN16.6 CN16.7 CN16.8 CN17.10 CN17.13 CN17.16 CN17.19 CN17.22 CN17.23 CN17.24 CN17.25 CN17.26 CN18.5 CN18.6 CN18.7 CN18.8 CN19.5 CN19.6 CP1.1 CP1.3 CP1.5 CP1.7 CP2.1 CP2.3 CP2.5 CP2.7 CP3.1 CP3.3 CP3.5 CP3.7 CP4.1 CP4.3 CP4.5 CP4.7 CP5.1 CP5.3 CP5.5 CP5.7 CP6.1 CP6.3 CP6.5 CP6.7 D2.1 D5.2 D16.2 D20.2 D21.1 D24.2 HOLE1.1 HOLE1.2 HOLE1.3 HOLE1.4 HOLE1.5 HOLE1.6 HOLE1.7 HOLE1.8 HOLE1.9 HOLE2.1 HOLE2.2 HOLE2.3 HOLE2.4 HOLE2.5 HOLE2.6 HOLE2.7 HOLE2.8 HOLE2.9 HOLE3.1 HOLE3.2 HOLE3.3 HOLE3.4 HOLE3.5 HOLE3.6 HOLE3.7 HOLE3.8 HOLE3.9 HOLE4.1 HOLE5.1 HOLE6.1 HOLE7.1 HOLE8.1 HOLE8.2 HOLE8.3 HOLE8.4 HOLE8.5 HOLE8.6 HOLE8.7 HOLE8.8 HOLE8.9 HOLE9.1 HOLE12.1 HOLE12.2 HOLE12.3 HOLE12.4 HOLE12.5 HOLE12.6 HOLE12.7 HOLE12.8 HOLE12.9 HOLE14.1 HOLE15.1 HOLE16.1 HOLE17.1 HOLE18.1 HOLE21.1 HOLE21.2 HOLE21.3 HOLE21.4 HOLE21.5 HOLE21.6 HOLE21.7 HOLE21.8 HOLE21.9 HOLE22.1 HOLE22.2 HOLE22.3 HOLE22.4 HOLE22.5 HOLE22.6 HOLE22.7 HOLE22.8 HOLE22.9 HOLE25.1 HOLE25.2 HOLE25.3 HOLE25.4 HOLE25.5 HOLE25.6 HOLE25.7 HOLE25.8 HOLE25.9 J2.2 JDIM1.2 JDIM1.3 JDIM1.8 JDIM1.9 JDIM1.11 JDIM1.13 JDIM1.14 JDIM1.19 JDIM1.20 JDIM1.25 JDIM1.26 JDIM1.28 JDIM1.31 JDIM1.32 JDIM1.37 JDIM1.38 JDIM1.43 JDIM1.44 JDIM1.46 JDIM1.48 JDIM1.49 JDIM1.54 JDIM1.55 JDIM1.60 JDIM1.61 JDIM1.63 JDIM1.65 JDIM1.66 JDIM1.71 JDIM1.72 JDIM1.127 JDIM1.128 JDIM1.133 JDIM1.134 JDIM1.136 JDIM1.138 JDIM1.139 JDIM1.144 JDIM1.145 JDIM1.150 JDIM1.151 JDIM1.153 JDIM1.155 JDIM1.156 JDIM1.161 JDIM1.162 JDIM1.167 JDIM1.168 JDIM1.170 JDIM1.172 JDIM1.173 JDIM1.178 JDIM1.179 JDIM1.184 JDIM1.185 JDIM1.187 JDIM1.189 JDIM1.190 JDIM1.195 JDIM1.196 JDIM1.205 JDIM1.206 JDIM2.2 JDIM2.3 JDIM2.8 JDIM2.9 JDIM2.11 JDIM2.13 JDIM2.14 JDIM2.19 JDIM2.20 JDIM2.25 JDIM2.26 JDIM2.28 JDIM2.31 JDIM2.32 JDIM2.37 JDIM2.38 JDIM2.43 JDIM2.44 JDIM2.46 JDIM2.48 JDIM2.49 JDIM2.54 JDIM2.55 JDIM2.60 JDIM2.61 JDIM2.63 JDIM2.65 JDIM2.66 JDIM2.71 JDIM2.72 JDIM2.127 JDIM2.128 JDIM2.133 JDIM2.134 JDIM2.136 JDIM2.138 JDIM2.139 JDIM2.144 JDIM2.145 JDIM2.150 JDIM2.151 JDIM2.153 JDIM2.155 JDIM2.156 JDIM2.161 JDIM2.162 JDIM2.167 JDIM2.168 JDIM2.170 JDIM2.172 JDIM2.173 JDIM2.178 JDIM2.179 JDIM2.184 JDIM2.185 JDIM2.187 JDIM2.189 JDIM2.190 JDIM2.195 JDIM2.196 JDIM2.205 JDIM2.206 L12.1 PC1.1 PC2.1 PC3.1 PC5.2 PC6.1 PC7.1 PC8.2 PC9.1 PC10.1 PC12.2 PC13.2 PC14.2 PC16.2 PC17.2 PC18.1 PC19.2 PC20.1 PC21.1 PC22.2 PC24.1 PC25.1 PC26.2 PC27.2 PC28.1 PC29.2 PC30.2 PC31.1 PC32.1 PC33.1 PC34.2 PC35.1 PC36.2 PC39.2 PC40.1 PC41.1 PC42.2 PC43.2 PC44.2 PC47.1 PC48.1 PC49.1 PC50.1 PC51.2 PC52.1 PC54.1 PC55.2 PC56.2 PC57.2 PC58.2 PC60.1 PC61.1 PC62.1 PC63.2 PC65.1 PC66.2 PC67.2 PC70.2 PC71.1 PC72.1 PC73.1 PC74.1 PC75.2 PC76.1 PC80.2 PC82.2 PC83.2 PC85.2 PC91.2 PC94.2 PC95.2 PC96.1 PC98.1 PC99.2 PC100.2 PC101.1 PC102.1 PC103.2 PC104.2 PC105.1 PC106.1 PC107.1 PC108.1 PC109.2 PC110.2 PC111.2 PC112.2 PC113.1 PC115.2 PC116.2 PC117.2 PC118.2 PC119.1 PC120.2 PC121.1 PC122.2 PC124.2 PC126.2 PC127.1 PC128.2 PC129.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC139.1 PC140.1 PC142.2 PC143.2 PC144.1 PC145.1 PC146.1 PC147.1 PC148.1 PC149.1 PC150.2 PC151.1 PC152.2 PC153.2 PC155.2 PC159.1 PC160.2 PC161.1 PC162.2 PC163.1 PC164.2 PC165.2 PC166.2 PC167.2 PC168.2 PC169.2 PC170.1 PD2.2 PJ1.3 PJ1.4 PJ2.7 PJ2.8 PJ2.9 PJ2.10 PQ3.4 PQ4.1 PQ6.1 PQ6.4 PQ7.1 PQ7.2 PQ7.3 PQ8.1 PQ9.1 PQ12.1 PQ12.2 PQ12.3 PQ13.1 PQ13.2 PQ13.3 PQ18.1 PQ19.1 PQ20.1 PQ21.1 PQ23.1 PQ23.2 PQ23.3 PQ25.1 PQ25.2 PQ25.3 PQ28.1 PQ29.1 PQ30.1 PQ31.1 PQ32.1 PQ33.1 PQ34.1 PQ35.1 PQ37.1 PQ37.2 PQ37.3 PQ39.1 PQ39.2 PQ39.3 PQ40.1 PQ41.5 PQ41.6 PQ41.7 PQ44.1 PQ45.1 PQ46.1 PQ48.1 PQ49.1 PQ50.1 PQ51.1 PQ52.1 PQ53.1 PR6.2 PR11.1 PR31.1 PR34.1 PR36.1 PR37.2 PR59.1 PR66.2 PR70.1 PR71.1 PR72.1 PR75.2 PR83.1 PR87.2 PR96.1 PR124.2 PR134.1 PR142.2 PR143.2 PR150.2 PR152.2 PR157.2 PR159.2 PR162.1 PR176.2 PR177.2 PR182.2 PR188.1 PR201.2 PR202.2 PR207.2 PR208.2 PR214.2 PR218.2 PU1.14 PU1.21 PU1.22 PU1.23 PU1.24 PU1.25 PU2.2 PU3.21 PU3.22 PU3.23 PU3.24 PU3.25 PU3.26 PU4.11 PU4.12 PU4.13 PU4.14 PU4.15 PU4.16 PU5.4 PU5.10 PU6.3 PU6.9 PU8.3 PU8.4 PU8.5 PU8.17 PU8.18 PU8.19 PU8.20 PU8.21 PU8.22 PU9.4 PU9.5 PU9.6 PU10.21 PU11.11 PU11.12 PU11.13 PU11.14 PU11.15 PU11.16 PU12.3 PU12.9 Q5.1 Q6.1 Q7.1 Q8.1 Q8.4 Q9.1 Q11.1 Q12.1 Q16.2 Q20.1 Q21.1 Q21.4 Q25.1 Q28.1 Q33.1 Q34.1 Q40.2 Q42.1 Q46.1 Q48.1 Q50.1 Q51.1 Q53.1 Q57.1 R9.2 R13.1 R14.1 R19.1 R21.1 R22.1 R23.1 R25.2 R27.1 R32.1 R40.1 R41.1 R42.2 R44.1 R46.1 R49.1 R52.2 R56.1 R57.1 R58.2 R59.1 R65.2 R81.1 R83.1 R90.1 R91.1 R93.1 R96.1 R112.2 R115.2 R120.2 R122.2 R126.1 R131.2 R135.2 R140.2 R146.2 R147.2 R154.2 R155.2 R156.2 R157.2 R164.1 R165.1 R167.1 R168.2 R170.2 R175.2 R177.2 R191.1 R192.1 R201.2 R204.2 R221.2 R222.2 R225.2 R226.2 R244.2 R247.1 R249.1 R251.2 R252.2 R253.2 R254.2 R258.1 R260.1 R261.2 R272.2 R281.2 R282.2 R284.2 R287.1 R291.2 R296.1 R297.2 R304.2 R319.1 R323.2 R325.2 R329.1 R341.2 R342.1 R348.1 R350.2 R356.2 R359.2 R361.1 R363.2 R364.2 R375.2 R378.1 R384.1 R385.2 R388.2 R389.2 R390.2 R391.2 R392.2 R393.2 R395.2 R396.2 R397.2 R398.2 R400.2 R410.1 R413.1 R415.2 R419.1 R420.2 R422.2 R424.1 R426.2 R429.1 R431.1 R432.1 R435.1 R438.2 R442.1 R443.1 R446.2 R448.2 R450.1 R452.2 R461.1 R464.1 R465.1 R466.1 R469.2 R476.1 R478.2 R484.2 R490.2 R494.1 R495.1 R496.1 R497.1 R507.2 R519.2 R526.2 R529.2 R535.2 R538.2 R541.1 R543.1 R549.2 R564.2 R565.1 R566.1 R572.2 R574.2 R592.1 R601.2 R606.2 R608.1 R616.2 R634.2 R635.2 R637.2 R640.2 R681.2 R691.1 R708.2 RV1.2 RV2.2 RV3.2 RV4.2 RV5.2 RV6.2 SW1.3 SW1.5 SW1.6 TP11.1 TP62.1 TP64.1 TP71.1 TP74.1 TP76.1 TP77.1 TP155.1 TP157.1 TP159.1 TP164.1 TP176.1 U1.5 U2.2 U2.5 U3.3 U5.3 U6.3 U7.33 U8.3 U9.2 U10.2 U11.4 U11.11 U11.18 U11.25 U12.3 U13.1 U13.27 U13.49 U13.91 U13.113 U13.122 U15.4 U15.49 U16.5 U16.10 U16.12 U16.13 U16.15 U16.16 U17.1 U17.2 U17.3 U18.3 U19.A2 U19.A26 U19.AA7 U19.AB7 U19.AB11 U19.AB14 U19.AB17 U19.AB20 U19.AB24 U19.AC2 U19.AC5 U19.AC8 U19.AC22 U19.AC26 U19.AD12 U19.AD13 U19.AD15 U19.AD16 U19.AD18 U19.AD19 U19.AD21 U19.AD22 U19.AE11 U19.AE14 U19.AE17 U19.AE20 U19.AF1 U19.AF5 U19.AF8 U19.AF11 U19.AF14 U19.AF17 U19.AF20 U19.AF23 U19.AG2 U19.AG26 U19.B1 U19.B5 U19.B8 U19.B11 U19.B14 U19.B17 U19.B20 U19.B23 U19.B27 U19.E2 U19.E5 U19.E8 U19.E11 U19.E14 U19.E17 U19.E20 U19.E22 U19.E25 U19.H2 U19.H5 U19.H23 U19.H25 U19.K11 U19.K13 U19.K15 U19.K17 U19.L2 U19.L5 U19.L10 U19.L12 U19.L14 U19.L16 U19.L18 U19.L23 U19.L25 U19.M11 U19.M13 U19.M15 U19.M17 U19.N10 U19.N12 U19.N14 U19.N16 U19.N18 U19.P2 U19.P5 U19.P11 U19.P13 U19.P15 U19.P17 U19.P23 U19.P26 U19.R10 U19.R12 U19.R14 U19.R16 U19.R18 U19.T11 U19.T13 U19.T15 U19.T17 U19.U2 U19.U5 U19.U10 U19.U12 U19.U14 U19.U16 U19.U18 U19.U23 U19.U26 U19.V11 U19.V13 U19.V15 U19.V17 U19.Y2 U19.Y5 U19.Y23 U19.Y26 U20.3 U21.3 U22.1 U22.3 U23.3 U24.A2 U24.A4 U24.A5 U24.A41 U24.A43 U24.AA4 U24.AA16 U24.AA20 U24.AA22 U24.AA28 U24.AB8 U24.AB12 U24.AB34 U24.AB38 U24.AC2 U24.AC44 U24.AD6 U24.AD8 U24.AD14 U24.AD16 U24.AD18 U24.AD30 U24.AD32 U24.AD40 U24.AE16 U24.AE28 U24.AF8 U24.AF38 U24.AG2 U24.AG16 U24.AG26 U24.AG28 U24.AG44 U24.AJ6 U24.AJ8 U24.AJ16 U24.AJ18 U24.AJ20 U24.AJ22 U24.AJ24 U24.AJ34 U24.AJ38 U24.AK14 U24.AK16 U24.AK24 U24.AK43 U24.AK45 U24.AL2 U24.AL8 U24.AL12 U24.AL34 U24.AL38 U24.AM14 U24.AM16 U24.AM24 U24.AM26 U24.AM28 U24.AM30 U24.AM32 U24.AN8 U24.AN36 U24.AN40 U24.AN42 U24.AP13 U24.AP24 U24.AP31 U24.AP43 U24.AR2 U24.AT10 U24.AT15 U24.AT17 U24.AT20 U24.AT26 U24.AT29 U24.AT36 U24.AT38 U24.AT43 U24.AV6 U24.AV7 U24.AV13 U24.AV22 U24.AV24 U24.AV31 U24.AV33 U24.AV40 U24.AW2 U24.AY7 U24.AY10 U24.AY15 U24.AY20 U24.AY26 U24.AY29 U24.AY36 U24.B1 U24.B2 U24.B7 U24.B11 U24.B15 U24.B19 U24.B23 U24.B27 U24.B31 U24.B35 U24.B39 U24.B44 U24.BA1 U24.BA40 U24.BB25 U24.BB42 U24.BC1 U24.BC16 U24.BC22 U24.BC28 U24.BD2 U24.BD7 U24.BD11 U24.BD15 U24.BD19 U24.BD31 U24.BD35 U24.BD39 U24.BD44 U24.BD45 U24.BE2 U24.BE3 U24.BE41 U24.C45 U24.D1 U24.D4 U24.D25 U24.D42 U24.E1 U24.E45 U24.F15 U24.F20 U24.F29 U24.F33 U24.F43 U24.G2 U24.G8 U24.G38 U24.G44 U24.H7 U24.H10 U24.H13 U24.H17 U24.H22 U24.H24 U24.H26 U24.H31 U24.H36 U24.H40 U24.K10 U24.K15 U24.K20 U24.K29 U24.K33 U24.K39 U24.L2 U24.L44 U24.M17 U24.M22 U24.M24 U24.N6 U24.N10 U24.N12 U24.N35 U24.N39 U24.P22 U24.P24 U24.P26 U24.P28 U24.P30 U24.P32 U24.P43 U24.R2 U24.R8 U24.R12 U24.R14 U24.R16 U24.R34 U24.R38 U24.R44 U24.T43 U24.U6 U24.U10 U24.U16 U24.U28 U24.U34 U24.U38 U24.U39 U24.U42 U24.V14 U24.V16 U24.V26 U24.V43 U24.W2 U24.W44 U24.Y8 U24.Y14 U24.Y16 U24.Y24 U24.Y28 U24.Y34 U24.Y36 U24.Y40 U25.1 U25.3 U26.5 U26.6 U26.7 U26.8 U27.A3 U27.A4 U27.A7 U27.A10 U27.A13 U27.A16 U27.A19 U27.A22 U27.A25 U27.A27 U27.A29 U27.A31 U27.A33 U27.AA11 U27.AA25 U27.AA27 U27.AA29 U27.AA31 U27.AA33 U27.AA35 U27.AB1 U27.AB3 U27.AB4 U27.AB6 U27.AB7 U27.AB9 U27.AB10 U27.AC11 U27.AC25 U27.AC27 U27.AC29 U27.AC31 U27.AC33 U27.AC35 U27.AD7 U27.AD11 U27.AE1 U27.AE3 U27.AE4 U27.AE6 U27.AE7 U27.AE9 U27.AE10 U27.AE25 U27.AE27 U27.AE29 U27.AE31 U27.AE33 U27.AE35 U27.AF6 U27.AF8 U27.AF11 U27.AG6 U27.AG11 U27.AG25 U27.AG27 U27.AG29 U27.AG31 U27.AG33 U27.AG35 U27.AH1 U27.AH2 U27.AH3 U27.AH4 U27.AH5 U27.AH6 U27.AH7 U27.AH8 U27.AH9 U27.AH10 U27.AJ5 U27.AJ11 U27.AK5 U27.AK11 U27.AK25 U27.AK26 U27.AK28 U27.AK29 U27.AK30 U27.AK32 U27.AK34 U27.AL1 U27.AL2 U27.AL3 U27.AL4 U27.AL5 U27.AL6 U27.AL7 U27.AL8 U27.AL9 U27.AL10 U27.AL11 U27.AL12 U27.AL14 U27.AL15 U27.AL17 U27.AL18 U27.AL19 U27.AL20 U27.AL21 U27.AL22 U27.AL23 U27.AL24 U27.AM4 U27.AM7 U27.AM10 U27.AM13 U27.AM16 U27.AM19 U27.AM20 U27.AM21 U27.AM22 U27.AM23 U27.AM24 U27.AM25 U27.AM32 U27.AN2 U27.AN4 U27.AN7 U27.AN10 U27.AN13 U27.AN16 U27.AN19 U27.AN21 U27.AN24 U27.AN27 U27.AN30 U27.AN34 U27.AP1 U27.AP4 U27.AP7 U27.AP10 U27.AP13 U27.AP16 U27.AP19 U27.AP27 U27.AP35 U27.AR2 U27.AR4 U27.AR7 U27.AR10 U27.AR13 U27.AR16 U27.AR19 U27.AR22 U27.AR25 U27.AR26 U27.AR28 U27.AR31 U27.AR34 U27.AT3 U27.AT4 U27.AT7 U27.AT10 U27.AT13 U27.AT16 U27.AT19 U27.AT21 U27.AT24 U27.AT27 U27.AT30 U27.AT32 U27.AT33 U27.AT34 U27.B2 U27.B4 U27.B7 U27.B10 U27.B13 U27.B16 U27.B19 U27.B22 U27.B34 U27.C1 U27.C2 U27.C4 U27.C7 U27.C10 U27.C13 U27.C16 U27.C19 U27.C22 U27.C24 U27.C26 U27.C28 U27.C30 U27.C32 U27.C34 U27.D4 U27.D7 U27.D10 U27.D13 U27.D16 U27.D19 U27.D22 U27.D25 U27.D27 U27.D29 U27.D31 U27.D33 U27.D35 U27.E1 U27.E4 U27.E7 U27.E10 U27.E13 U27.E16 U27.E19 U27.E22 U27.E25 U27.F4 U27.F6 U27.F7 U27.F8 U27.F9 U27.F10 U27.F11 U27.F12 U27.F14 U27.F15 U27.F17 U27.F18 U27.F19 U27.F20 U27.F21 U27.F23 U27.F24 U27.F26 U27.F28 U27.F30 U27.F32 U27.F34 U27.G1 U27.G2 U27.G3 U27.G4 U27.G5 U27.G11 U27.G27 U27.G29 U27.G31 U27.G33 U27.G35 U27.H6 U27.H7 U27.H10 U27.H11 U27.H26 U27.J6 U27.J11 U27.J26 U27.J28 U27.J30 U27.J32 U27.J34 U27.K1 U27.K2 U27.K3 U27.K4 U27.K5 U27.K7 U27.K8 U27.K9 U27.K10 U27.K29 U27.K31 U27.K33 U27.K35 U27.L6 U27.L11 U27.L26 U27.M6 U27.M11 U27.M26 U27.M28 U27.M30 U27.M32 U27.M34 U27.N1 U27.N2 U27.N3 U27.N4 U27.N5 U27.N6 U27.N7 U27.N9 U27.N10 U27.N29 U27.N31 U27.N33 U27.N35 U27.P5 U27.P11 U27.P26 U27.R5 U27.R11 U27.R26 U27.R28 U27.R30 U27.R32 U27.R34 U27.T1 U27.T3 U27.T4 U27.T6 U27.T7 U27.T9 U27.T10 U27.T26 U27.T29 U27.T31 U27.T33 U27.T35 U27.U11 U27.U27 U27.V11 U27.V28 U27.V30 U27.V32 U27.V34 U27.W1 U27.W3 U27.W4 U27.W6 U27.W7 U27.W9 U27.W10 U27.W25 U27.W33 U27.W35 U27.Y11 U28.3 U30.4 U31.2 U32.25 U33.2 VC1.1 VC2.1 VRAM1.A9 VRAM1.B1 VRAM1.B3 VRAM1.B9 VRAM1.D1 VRAM1.D8 VRAM1.E1 VRAM1.E2 VRAM1.E8 VRAM1.F9 VRAM1.G1 VRAM1.G8 VRAM1.G9 VRAM1.J2 VRAM1.J8 VRAM1.M1 VRAM1.M9 VRAM1.P1 VRAM1.P9 VRAM1.T1 VRAM1.T9 VRAM2.A9 VRAM2.B1 VRAM2.B3 VRAM2.B9 VRAM2.D1 VRAM2.D8 VRAM2.E1 VRAM2.E2 VRAM2.E8 VRAM2.F9 VRAM2.G1 VRAM2.G8 VRAM2.G9 VRAM2.J2 VRAM2.J8 VRAM2.M1 VRAM2.M9 VRAM2.P1 VRAM2.P9 VRAM2.T1 VRAM2.T9 VRAM3.A9 VRAM3.B1 VRAM3.B3 VRAM3.B9 VRAM3.D1 VRAM3.D8 VRAM3.E1 VRAM3.E2 VRAM3.E8 VRAM3.F9 VRAM3.G1 VRAM3.G8 VRAM3.G9 VRAM3.J2 VRAM3.J8 VRAM3.M1 VRAM3.M9 VRAM3.P1 VRAM3.P9 VRAM3.T1 VRAM3.T9 VRAM4.A9 VRAM4.B1 VRAM4.B3 VRAM4.B9 VRAM4.D1 VRAM4.D8 VRAM4.E1 VRAM4.E2 VRAM4.E8 VRAM4.F9 VRAM4.G1 VRAM4.G8 VRAM4.G9 VRAM4.J2 VRAM4.J8 VRAM4.M1 VRAM4.M9 VRAM4.P1 VRAM4.P9 VRAM4.T1 VRAM4.T9 Y1.2 Y1.4 Y2.2 Y2.4 Y3.2 Y3.4
VCC_SENSE: PC91.1 PR125.2 PR130.1 R455.1
VCC_SENSE_R: R455.2 R460.1 U27.AL35
VCC_XD: C539.1 C543.1 CN1.4 U32.24
VCCRTC_3: Q30.3 R243.2
VCCRTC_4: R242.2 R243.1
VDD10: C459.1 C460.2 C463.1 C469.1 C473.1 C484.2 C487.1 C488.1 L24.2 U7.3 U7.8 U7.22 U7.30
VDD18: C547.1 C551.2 U32.18
VDDREG/VDD33: C444.2 C446.2 R527.2 U7.23
VIN: C362.1 C363.2 C725.2 C726.1 C727.2 C728.1 C733.2 C734.1 C735.2 C736.1 C749.2 C750.1 PC5.1 PC6.2 PC9.2 PC14.1 PC29.1 PC30.1 PC31.2 PC35.2 PC36.1 PC50.2 PC51.1 PC62.2 PC63.1 PC75.1 PC76.2 PC108.2 PC109.1 PC110.1 PC111.1 PC115.1 PC126.1 PC127.2 PC128.1 PC129.1 PC137.1 PC164.1 PC165.1 PD7.2 PL14.2 PL15.2 PQ2.1 PQ2.2 PQ2.3 PQ5.5 PQ10.5 PQ11.5 PQ22.5 PQ26.5 PQ36.5 PQ38.5 PQ41.2 PR1.2 PR2.1 PR4.1 PR43.1 PR61.1 PR65.1 PR145.1 PR163.1 PR197.1 PR203.1 PR213.1 PR215.1 R416.2 R417.2
VSS_SENSE: PC94.1 PR123.2 PR134.2 R456.2
VSS_SENSE_R: R456.1 R461.2 U27.AK35
1.5GFX_DRVH: PQ26.4 PU11.9
1.5GFX_DRVL: PQ25.4 PU11.6
1.5GFX_EN: PC139.2 PR32.2 PU11.3
1.5GFX_FB: PR87.1 PR97.2 PU11.4
1.5GFX_SW: PC138.2 PL11.1 PQ25.5 PQ26.1 PQ26.2 PQ26.3 PR190.1 PU11.8
1.5GFX_TRIP: PR31.2 PU11.2
1.5GFX_TST: PR96.2 PU11.5
1.5GFX_VBST: PR29.2 PU11.10
2ND_MBCLK: Q3.3 Q27.1 R331.1 U1.8 U13.115
2ND_MBDATA: Q3.6 Q29.1 R330.1 U1.7 U13.116
27M_XTAL_IN_R: C353.2 U19.C11 Y2.3
27M_XTAL_OUT: C354.2 U19.B10 Y2.1
1658R-BOOT1: PR160.2 PU10.1
1658R-BOOT2: PR175.2 PU10.15
1658R-COMP: PC123.1 PC124.1 PU10.12
1658R-EN: PR121.2 PR164.2 PU10.3
1658R-FB: PC130.1 PR180.2 PU10.11
1658R-FBRTN: PR181.2 PU10.10
1658R-LGATE1: PQ37.4 PU10.19
1658R-LGATE2: PQ39.4 PU10.17
1658R-OCS/CB: PR159.1 PR161.2 PR165.2 PU10.9
1658R-PG: PR169.1 PR171.1 PU10.13
1658R-PHASE1: PC114.2 PL8.1 PQ36.1 PQ36.2 PQ36.3 PQ37.5 PR168.1 PU10.20
1658R-PHASE2: PC125.2 PL9.1 PQ38.1 PQ38.2 PQ38.3 PQ39.5 PR183.1 PU10.16
1658R-PSI: PR166.2 PU10.4
1658R-PVCC: PC112.1 PR158.1 PU10.18
1658R-REFADJ: PR172.1 PU10.6
1658R-REFIN: PC121.2 PR174.2 PR178.1 PU10.7
1658R-UGATE1: PQ36.4 PU10.2
1658R-UGATE2: PQ38.4 PU10.14
1658R-VID: PR167.2 PU10.5
1658R-VREF: PC119.2 PR161.1 PR170.1 PU10.8
24707_LX: PC15.1 PC166.1 PC167.1 PL1.2 PQ5.1 PQ5.2 PQ5.3 PQ7.5 PR22.1 PU1.19
24737_ACDET: PR10.2 PR11.2 PU1.6
24737_ACN: PC8.1 PC11.2 PR2.2 PU1.1
24737_ACP: PC7.2 PC11.1 PR5.2 PU1.2
24737_BM#: PQ8.2 PR25.1 PU1.11
24737_BST: PR16.2 PU1.17
24737_CMPIN: PR36.2 PR41.2 PR42.1 PU1.4
24737_CMPOUT: PQ9.2 PR26.1 PR42.2 PR191.2 PU1.3
24737_DH: PQ5.4 PU1.18
24737_DL: PQ7.4 PU1.15
24737_ILIM: PC25.2 PR28.1 PR33.2 PR34.2 PU1.10
24737_REGN: PC12.1 PD4.2 PU1.16
24737_SRN: PC23.1 PC24.2 PR24.1 PR210.1
24737_SRP: PC21.2 PC23.2 PR23.1 PR209.1
24737_VCC: PC10.2 PR13.2 PU1.20
51216_DRVH: PQ41.1 PU5.14
51216_DRVL: PQ41.8 PU5.11
51216_MODE: PR80.2 PU5.19
51216_REF: PC68.1 PR84.1 PU5.6
51216_REFIN: PC69.1 PR84.2 PR86.1 PU5.8
51216_S3: PR77.1 PR85.2 PU5.17
51216_S5: PR78.1 PR85.1 PU5.16
51216_SW: PC64.2 PL13.1 PQ41.9 PR82.1 PU5.13
51216_TRIP: PR81.2 PU5.18
51216_VBST: PR79.1 PU5.15
51225_CS1: PR57.2 PU3.1
51225_CS2: PR58.2 PU3.5
51225_DH1: PQ10.4 PU3.16
51225_DH2: PQ11.4 PU3.10
51225_DL1: PQ12.4 PU3.15
51225_DL2: PQ13.4 PU3.11
51225_EN1: PR45.1 PU3.20
51225_FB1: PR50.1 PR54.1 PU3.2
51225_FB2: PR52.2 PR55.1 PU3.4
51225_SW1: PC38.2 PL2.2 PQ10.1 PQ10.2 PQ10.3 PQ12.5 PR53.1 PU3.18
51225_SW2: PC37.1 PL3.2 PQ11.1 PQ11.2 PQ11.3 PQ13.5 PR51.1 PU3.8
51225_VBST1: PR49.2 PU3.17
51225_VBST2: PR48.1 PU3.9
51225_VCLK: PR56.1 PU3.19
51225_VIN: PC33.2 PR43.2 PU3.12
51631_ALERT#: PR116.1 PU7.32
51631_B-RAMP: PR91.2 PR101.1 PU7.11
51631_CLK: PR115.1 PU7.31
51631_COMP: PC90.2 PR128.2 PR132.1 PR192.2 PU7.26
51631_CSN1: PC87.2 PC89.1 PR107.2 PR109.2 PR114.1 PU7.18
51631_CSN2: PC157.2 PC158.1 PR184.2 PR211.2 PR212.1 PU7.19
51631_CSN3: PR135.1 PU7.22
51631_CSP1: PC86.1 PC87.1 PR106.2 PR108.1 PR109.1 PU7.17
51631_CSP2: PC156.1 PC157.1 PR127.2 PR196.1 PR211.1 PU7.20
51631_CSP3: PR136.2 PU7.21
51631_DATA: PR117.1 PU7.1
51631_DROOP: PC90.1 PC93.1 PR128.1 PU7.25
51631_F-IMAX: PR90.2 PR100.1 PU7.10
51631_GFB: PR123.1 PU7.23
51631_IMON: PC92.1 PR129.1 PU7.13
51631_O-USR: PR89.2 PR99.1 PU7.9
51631_OCP-I: PR129.2 PR133.1 PU7.12
51631_PWM1: PU6.8 PU7.6
51631_PWM2: PU7.5 PU12.8
51631_PWM3: PR193.1 PU7.4
51631_SKIP#: PR119.1 PU6.1 PU7.7 PU12.1
51631_SLEWA: PR92.2 PR102.1 PU7.15
51631_THERM: PC78.1 PR93.1 PR103.2 PU7.14
51631_V5A: PC79.1 PR94.1 PU7.28
51631_VBAT: PR95.2 PU7.16
51631_VDD: PC154.1 PR88.1 PU7.2
51631_VFB: PR125.1 PU7.24
51631_VREF: PC77.1 PR89.1 PR90.1 PR91.1 PR92.1 PR93.2 PR192.1 PU7.27
51631_VRON: PR98.2 PR120.1 PR131.1 PR195.2 PU7.8
+AZA_VDD: C302.1 C303.1 C325.1 R346.1 R690.1 U15.1 U15.36
+DDR_VTT_RUN: C236.1 C239.1 C241.2 C246.2 C250.1 C259.1 C266.1 C274.1 C281.2 C286.2 C288.1 C292.1 JDIM1.203 JDIM1.204 JDIM2.203 JDIM2.204 PC57.1 PC58.1 PU5.1 PU5.3
+FB_PLLAVDD: C83.1 C94.2 C97.2 C101.1 L3.1 U19.F16 U19.H22 U19.P22
+G_SEN_PW: C339.1 C342.1 R365.2 R366.2 R377.2 U16.1 U16.8 U16.14
+PCH_VCCDSW: R210.2 U24.U14
+SM_VREF: C222.2 Q32.1 Q39.1 R246.2 R254.1 R261.1 R263.2 R267.1 U27.AM3
+SMDDR_VREF_DIMM: C248.1 C258.1 C296.1 C297.1 C301.2 JDIM1.126 JDIM2.126 R335.2 R337.1 R342.2 R343.1
+SMDDR_VREF_DQ0: C262.1 C265.1 JDIM2.1 R309.2 R312.2
+SMDDR_VREF_DQ1: C234.1 C238.1 JDIM1.1 R286.1 R292.2
+TPVDD: C541.1 CN18.1 CN18.2 L29.1 L30.2 L33.2
+VGPU_CORE: C30.2 C31.2 C32.2 C33.2 C35.2 C37.2 C38.2 C42.2 C44.2 C46.2 C48.2 C52.2 C54.2 C55.2 C59.2 C60.2 C61.2 C63.2 C66.2 C67.2 C68.2 C358.1 C731.2 C732.2 PC116.1 PC117.1 PC118.1 PC131.1 PC132.1 PC133.1 PC134.1 PL8.2 PL9.2 PR185.2 U19.K10 U19.K12 U19.K14 U19.K16 U19.K18 U19.L11 U19.L13 U19.L15 U19.L17 U19.M10 U19.M12 U19.M14 U19.M16 U19.M18 U19.N11 U19.N13 U19.N15 U19.N17 U19.P10 U19.P12 U19.P14 U19.P16 U19.P18 U19.R11 U19.R13 U19.R15 U19.R17 U19.T10 U19.T12 U19.T14 U19.T16 U19.T18 U19.U11 U19.U13 U19.U15 U19.U17 U19.V10 U19.V12 U19.V14 U19.V16 U19.V18
+VREF_CA_CPU: Q39.3 R267.2 R335.1
+VREFDQ_SA_CPU: Q36.1 R156.1 R269.1 U27.F16
+VREFDQ_SA_M3: Q36.3 R269.2 R309.1
+VREFDQ_SB_CPU: Q35.1 R170.1 R268.1 U27.F13
+VREFDQ_SB_M3: Q35.3 R268.2 R286.2
+WL_VDD: C510.2 C511.2 C512.2 C515.2 C524.1 C527.2 CN10.2 CN10.24 CN10.39 CN10.41 CN10.52 Q56.2 Q56.5 R680.2 R685.2 R688.2
A_LAD0_R: CN10.8 R665.1
A_LAD1_R: CN10.10 R670.1
A_LAD2_R: CN10.12 R669.1
A_LAD3_R: CN10.14 R668.1
A_LFRAME#_R: CN10.16 R667.1
AC_PROTECT: PR191.1 U13.85
ACCEL_INTA: C334.2 D18.1 U13.68
ACCEL_INTA_R: D18.2 U16.11
ACIN: PQ6.3 PR12.1 U13.72
ACPRESENT: PR17.1 PR18.2 R200.1
ACZ_SDIN: R345.2 U15.8
ADOGND: C316.1 C319.2 C322.2 C324.1 C327.2 C328.2 C329.2 C330.1 C331.2 C336.2 C340.1 C344.2 C371.2 C532.2 C534.2 C537.1 CN15.5 CN15.7 D17.2 D19.2 Q44.1 Q44.4 R350.1 R353.2 R356.1 R359.1 R360.2 R361.2 R362.1 R363.1 R364.1 R370.2 R375.1 R696.1 U15.25 U15.38
AMP_MUTE#: D13.1 U13.108
BAT-V: PC17.1 PC18.2 PC19.1 PL5.2 PL10.2 PQ2.5 PR20.2 PR24.2
BATLED0#: R719.1 R724.1 U13.29
BATLED1#: R718.1 R723.1 U13.25
BBS_BIT0: R571.1 R572.1 U24.AU2
BBS_BIT1: R146.1 U24.C10
BEEP_1: C304.1 C305.2 R338.1 R691.2
BIOS_REC: R175.1 R178.1 U24.BB4
BIOS_RESP: R628.1 R637.1 U24.AN4
BL#: Q8.2 Q8.3 R30.1
BL_ON: CN2.26 D1.2 Q8.6 Q9.3 R34.1
BOARD_ID0: R507.1 R508.1 R509.1 U24.L15
BOARD_ID1: R514.1 R515.1 R519.1 U24.M15
BT_POWERON: R682.1 U13.104
BT_PWRON_R: CN10.51 R682.2
BXTALOUT: R395.1 U19.C10
C_PEG_TX0: C392.2 U27.J35
C_PEG_TX1: C395.2 U27.G34
C_PEG_TX2: C397.2 U27.H33
C_PEG_TX3: C399.2 U27.G32
C_PEG_TX4: C401.2 U27.H31
C_PEG_TX5: C402.2 U27.H30
C_PEG_TX6: C405.2 U27.B33
C_PEG_TX7: C411.2 U27.A32
C_PEG_TX#0: C393.1 U27.H35
C_PEG_TX#1: C394.2 U27.H34
C_PEG_TX#2: C396.2 U27.J33
C_PEG_TX#3: C398.2 U27.H32
C_PEG_TX#4: C400.2 U27.J31
C_PEG_TX#5: C403.2 U27.G30
C_PEG_TX#6: C404.2 U27.C33
C_PEG_TX#7: C410.2 U27.B32
CATERR#: TP15.1 U27.AN32
CCD_PWR: C10.2 C14.2 CN2.32 CN2.33 R6.1
CFG0: R567.1 U27.AT20
CFG1: R563.1 U27.AR20
CFG2: R147.1 R152.1 U27.AP20
CFG3: R561.1 U27.AP22
CFG4: R140.1 R148.1 U27.AT22
CFG5: R135.1 R141.1 U27.AN22
CFG6: R110.1 R115.1 U27.AT25
CFG7: R131.1 R132.1 U27.AN23
CFG8: R516.2 U27.AR24
CFG9: R550.2 U27.AT23
CFG10: R587.2 U27.AN20
CFG11: R539.2 U27.AP24
CFG12: R504.2 U27.AP26
CFG13: R103.2 U27.AN25
CFG14: R502.2 U27.AN26
CFG15: R511.2 U27.AP25
CFG16: R544.2 R546.2 U27.AR21
CFG17: R545.2 R547.2 U27.AR23
CFG18: R553.2 R558.2 U27.AP21
CFG19: R552.2 R557.2 U27.AP23
CFG_RCOMP: R490.1 U27.AT31
CL_CLK: TP52.1 U24.AF11
CL_CLK1_WLAN: CN10.45 R684.1
CL_DAT: TP50.1 U24.AF10
CL_DATA1_WLAN: CN10.47 R683.1
CL_RST1#_WLAN: CN10.49 TP163.1
CL_RST#: TP45.1 U24.AF7
CLK_BUF_CKSSCDN: R566.2 U24.BE6
CLK_BUF_CKSSCDP: R565.2 U24.BC6
CLK_BUF_CPYCKN: R496.2 U24.AR24
CLK_BUF_CPYCKP: R497.2 U24.AT24
CLK_BUF_DOT96N: R93.2 U24.H33
CLK_BUF_DOT96P: R96.2 U24.G33
CLK_BUF_EXPN: R495.2 U24.AY24
CLK_BUF_EXPP: R494.2 U24.AW24
CLK_BUF_REF14: R476.2 U24.F45
CLK_CPU_BCLKN: R738.1 U24.AF39
CLK_CPU_BCLKN_R: R738.2 U27.D26
CLK_CPU_BCLKP: R739.1 U24.AF40
CLK_CPU_BCLKP_R: R739.2 U27.E26
CLK_DPLL_NSCLKN: R734.1 U24.AF35
CLK_DPLL_NSCLKN_R: R734.2 U27.G28
CLK_DPLL_NSCLKP: R735.1 U24.AF36
CLK_DPLL_NSCLKP_R: R735.2 U27.H28
CLK_DPLL_SSCLKN: R736.1 U24.AJ40
CLK_DPLL_SSCLKN_R: R65.1 R736.2 U27.F27
CLK_DPLL_SSCLKP: R737.1 U24.AJ39
CLK_DPLL_SSCLKP_R: R68.1 R737.2 U27.E27
CLK_FLEX0: TP19.1 U24.C40
CLK_FLEX1: TP87.1 U24.F38
CLK_FLEX2: TP25.1 U24.F36
CLK_PCH_PCI0: TP21.1 U24.D44
CLK_PCH_PCI1: R467.2 U24.E44
CLK_PCH_PCI2: R86.2 U24.B42
CLK_PCH_PCI3: R474.2 U24.F41
CLK_PCH_PCI4: R69.2 U24.A40
CLK_PCI_EC: C116.2 R69.1 R303.2 U13.13
CLK_PCI_FB: R86.1 U24.D17
CLK_PCI_LPC: C409.2 R474.1 R684.2
CLK_PCIE_LAN_REQ#: Q18.3 R130.2 R638.1
CLK_PCIE_LANN: U7.16 U24.AD43
CLK_PCIE_LANP: U7.15 U24.AD45
CLK_PCIE_REQ0#: R590.2 U24.AB1
CLK_PCIE_REQ1#: R600.2 R632.1 U24.AF1
CLK_PCIE_REQ2#: R611.2 R630.1 R631.2 U24.AF3
CLK_PCIE_REQ3#: R578.2 R638.2 U24.T3
CLK_PCIE_REQ4#: R614.2 U24.V3
CLK_PCIE_REQ5#: R575.2 U24.AA2
CLK_PCIE_REQ6#: R573.2 U24.AE4
CLK_PCIE_REQ7#: R576.2 U24.Y3
CLK_PCIE_VGA: U19.AE8 U24.AB36
CLK_PCIE_VGA#: U19.AD8 U24.AB35
CLK_PCIE_WLAN#_C: CN10.11 R687.2
CLK_PCIE_WLAN_C: CN10.13 R686.2
CLK_PCIE_WLANN: R687.1 U24.AB43
CLK_PCIE_WLANP: R686.1 U24.AB45
CLK_PCIE_XDPN: R745.1 U24.AH43
CLK_PCIE_XDPN_R: R745.2 TP86.1
CLK_PCIE_XDPP: R744.1 U24.AH45
CLK_PCIE_XDPP_R: R744.2 TP85.1
CLK_PEGA_REQ#: Q10.3 R39.2 R215.1 R215.2 R220.2 U24.AF6
CLK_PEGB_REQ#: R214.2 U24.U4
CLKRUN#: R176.1 R271.2 TP48.1 U13.93 U24.AN7
CODEC_JDREF: R353.1 U15.15
CODEC_VREF: C330.2 U15.28
CON_BAT-V: PC16.1 PC20.2 PJ2.1 PJ2.2 PL5.1 PL10.1
CPU_DRAMRST#: Q38.1 R260.2 R266.2 U27.AN3
CPU_HOOK0: R51.1 TP13.1
CPU_HOOK1: R532.2 TP104.1
CPU_HOOK2: R87.2 TP27.1
CPU_HOOK3: R277.1 TP68.1
CPU_HOOK6: R540.1 TP109.1
CPU_HOOK7: R486.2 TP91.1
CPU_PLTRST#: R123.1 R540.2 TP125.1 U24.AU4
CPU_PLTRST#_Q: R112.1 R113.2 R124.1 U5.4
CPU_RST#_R: R123.2 R124.2 U27.AT26
CPUFAN#: U13.81 U26.4
CRT_11: CN5.11 TP38.1
CRT_B1: C445.2 CN5.3 L25.2 U6.5 U6.6
CRT_BLU: C415.2 C447.2 L25.1 R466.2 R526.1 U24.T45
CRT_DDCCLK_CON: C426.2 CN5.15 Q58.3 R730.1
CRT_DDCDATA_CON: C430.1 CN5.12 Q58.6 R731.1 U6.4 U6.7 U23.5 U23.6
CRT_G1: C462.2 CN5.2 L26.2 U6.2 U6.9
CRT_GRE: C414.2 C458.2 L26.1 R465.2 R535.1 U24.U44
CRT_HSYNC_R: R473.2 U24.N42
CRT_R1: C474.2 CN5.1 L27.2 U6.1 U6.10
CRT_RED: C413.2 C470.2 L27.1 R464.2 R543.2 U24.V45
CRT_VSYNC_R: R472.2 U24.N44
CRTHSYNC: C436.2 CN5.13 U23.1 U23.10 U25.4
CRTVDD5: C131.1 C132.1 C133.2 C134.2 CN5.9 Q16.1 U23.2 U23.9
CRTVSYNC: C432.2 CN5.14 U22.4 U23.4 U23.7
CS_BST1: PC84.1 PU6.7
CS_BST2: PC141.1 PU12.7
CS_BSTR1: PR105.2 PU6.6
CS_BSTR2: PR126.2 PU12.6
CS_SW1: PL6.1 PR104.1 PU6.4
CS_SW2: PL12.1 PR194.1 PU12.4
D/C#: PR7.2 U13.107
DAC_IREF: R81.2 U24.U40
DDCCLK: Q58.4 R729.1 U24.M43
DDCDAT: Q58.1 R728.1 U24.M45
DDR3_DRAMRST#: JDIM1.30 JDIM2.30 R279.2
DDR3_DRAMRST#_R: Q38.3 R266.1 R278.2 R279.1
DDR_THERMDA: C2.1 Q2.2 Q2.3 U1.2
DDR_THERMDC: C2.2 Q2.1 U1.3
DDR_VTTREF: PC59.1 PU5.5 Q32.3 R263.1 R285.1 R313.1 R337.2
DEVSLP0: R523.1 U24.B17
DGPU_D: PC147.2 PQ47.2 PQ50.3 PR205.2
DGPU_D1: PC145.2 PQ43.4 PQ46.3 PR199.2
DGPU_EDIDCLK: R396.1 U19.A9
DGPU_EDIDDATA: R389.1 U19.B9
DGPU_EVENT#: R445.2 U24.A14
DGPU_HOLD_RST#: RP7.9 U20.1 U24.A12
DGPU_OPP#: Q45.3 R308.1 U13.18
DGPU_OTP#: Q1.3 R732.1 U13.76
DGPU_PGOK-1: C49.1 Q6.2 Q7.3 R35.1
DGPU_POK4: C53.1 Q7.2 R33.1
DGPU_PRSNT: R599.2 R608.2 U24.AM3
DGPU_PRSNT#_R: R77.2 U24.F39
DGPU_PSI: PR166.1 PR173.2 PR176.1 PR189.2 R408.1 U19.B4
DGPU_PWM_SLT#: TP106.1 U24.A10
DGPU_PWR_EN: PR206.1 RP7.8 U24.C12
DGPU_PWROK: Q6.3 R23.2 R24.1 R529.1 U24.C14
DGPU_SELECT#: RP7.7 TP103.1 U24.B13
DIMM0_SA0: JDIM2.197 R323.1
DIMM0_SA1: JDIM2.201 R325.1
DIMM1_SA0: JDIM1.197 R297.1
DIMM1_SA1: JDIM1.201 R302.1
DMI_IREF: R531.2 U24.BE16
DMI_RCOMP: R138.1 U24.AY17
DMI_RXN0: U24.AW22 U27.D18
DMI_RXN1: U24.AR20 U27.C17
DMI_RXN2: U24.AP17 U27.B17
DMI_RXN3: U24.AV20 U27.A17
DMI_RXP0: U24.AY22 U27.D17
DMI_RXP1: U24.AP20 U27.C18
DMI_RXP2: U24.AR17 U27.B18
DMI_RXP3: U24.AW20 U27.A18
DMI_TXN0: U24.BD21 U27.D21
DMI_TXN1: U24.BE20 U27.C21
DMI_TXN2: U24.BD17 U27.B21
DMI_TXN3: U24.BE18 U27.A21
DMI_TXP0: U24.BB21 U27.D20
DMI_TXP1: U24.BC20 U27.C20
DMI_TXP2: U24.BB17 U27.B20
DMI_TXP3: U24.BC18 U27.A20
DMIC_CLK_L: U15.3 U17.4
DMIC_DAT_L: U15.2 U17.5
DNBSWON#: R604.1 TP140.1 U13.120
DPB_HPD_Q: Q13.1 R49.2 U24.K40
DPWROK: R232.2 U13.124
DPWROK_R: C215.1 Q25.3 R197.1 R218.1 R232.1 U24.L13
DRAMRST_CNTRL: C230.1 Q35.2 Q36.2 Q38.2 Q39.2 R288.1 R289.1 R290.1
DRAMRST_CNTRL_EC: R289.2 U13.78
DRAMRST_CNTRL_PCH: R290.2 U24.N8
DSW_WAKE#: R202.1 U13.30
DSW_WAKE#_R: R202.2 R203.1 U24.R11
DSWVREN: R541.2 R542.1 U24.C8
E51_TXD: TP69.1 U13.109
EC_A20GATE: R208.2 U13.126 U24.AN10
EC_FB_CLAMP: R383.2 R414.1 R427.1 U13.77
EC_FPBACK#: Q9.2 U13.118
EC_ODD_EJ: R97.2 U13.20
EC_PECR_R: R275.1 U13.117
EC_PWROK: PR195.1 R193.1 R231.1 R326.2 U8.2 U13.33
EC_RCIN#: R207.1 U13.4 U24.AT6
ECAGND: C247.2 C264.1 L12.2 U13.75
EDP_AUX#_C: C348.2 CN2.22 R3.2 R385.1
EDP_AUX_C: C349.2 CN2.23 R4.2 R392.1
EDP_AUXN: C348.1 U27.M27
EDP_AUXP: C349.1 U27.N27
EDP_HPD: CN2.25 Q46.2 R452.1
EDP_HPD_Q: Q46.3 R457.1 U27.P27
EDP_RCOMP: R100.1 U27.E24
EDP_TX0#_C: C343.2 CN2.16
EDP_TX0_C: C346.2 CN2.17
EDP_TX1#_C: C345.2 CN2.19
EDP_TX1_C: C347.2 CN2.20
EDP_TXN0: C343.1 U27.P35
EDP_TXN1: C345.1 U27.N34
EDP_TXP0: C346.1 U27.R35
EDP_TXP1: C347.1 U27.P34
EDP_VDD_EN: R26.1 U24.G36
EDP_VDD_EN_R: R26.2 R27.2 U2.3
FANSIG: C433.2 CN3.2 R510.2 U13.47
FB_CAL_PD_VDDQ: R20.2 U19.D22
FB_CAL_PU_GND: R19.2 U19.C24
FB_CAL_TERM_GND: R14.2 U19.B25
FB_CLAMP: R426.1 R427.2 U19.F3
FB_CLAMP_MON: Q24.1 R401.1 U19.C6
FB_CLAMP_REQ#: R441.2 R733.1 U13.70
FB_CLAMP_REQ#_R: Q26.1 R404.1 R405.1 U19.A4
FBA_CMD0: U19.C27 VRAM1.L2 VRAM3.L2
FBA_CMD1: TP78.1 U19.C26
FBA_CMD2: R21.2 U19.E24 VRAM1.K1 VRAM3.K1
FBA_CMD3: R413.2 U19.F24 VRAM1.K9 VRAM3.K9
FBA_CMD4: U19.D27 VRAM1.T7 VRAM2.T7 VRAM3.T7 VRAM4.T7
FBA_CMD5: R25.1 U19.D26 VRAM1.T2 VRAM2.T2 VRAM3.T2 VRAM4.T2
FBA_CMD6: U19.F25 VRAM1.R3 VRAM2.R3 VRAM3.R3 VRAM4.R3
FBA_CMD7: U19.F26 VRAM1.R2 VRAM2.R2 VRAM3.R2 VRAM4.R2
FBA_CMD8: U19.F23 VRAM1.P3 VRAM2.P3 VRAM3.P3 VRAM4.P3
FBA_CMD9: U19.G22 VRAM1.N3 VRAM2.N3 VRAM3.N3 VRAM4.N3
FBA_CMD10: U19.G23 VRAM1.P8 VRAM2.P8 VRAM3.P8 VRAM4.P8
FBA_CMD11: U19.G24 VRAM1.P7 VRAM2.P7 VRAM3.P7 VRAM4.P7
FBA_CMD12: U19.F27 VRAM1.M2 VRAM2.M2 VRAM3.M2 VRAM4.M2
FBA_CMD13: U19.G25 VRAM1.L3 VRAM2.L3 VRAM3.L3 VRAM4.L3
FBA_CMD14: U19.G27 VRAM1.M7 VRAM2.M7 VRAM3.M7 VRAM4.M7
FBA_CMD15: U19.G26 VRAM1.K3 VRAM2.K3 VRAM3.K3 VRAM4.K3
FBA_CMD16: U19.M24 VRAM2.L2 VRAM4.L2
FBA_CMD17: TP10.1 U19.M23
FBA_CMD18: R438.1 U19.K24 VRAM2.K1 VRAM4.K1
FBA_CMD19: R42.1 U19.K23 VRAM2.K9 VRAM4.K9
FBA_CMD20: U19.M27 VRAM1.T3 VRAM2.T3 VRAM3.T3 VRAM4.T3
FBA_CMD21: U19.M26 VRAM1.T8 VRAM2.T8 VRAM3.T8 VRAM4.T8
FBA_CMD22: U19.M25 VRAM1.R8 VRAM2.R8 VRAM3.R8 VRAM4.R8
FBA_CMD23: U19.K26 VRAM1.R7 VRAM2.R7 VRAM3.R7 VRAM4.R7
FBA_CMD24: U19.K22 VRAM1.P2 VRAM2.P2 VRAM3.P2 VRAM4.P2
FBA_CMD25: U19.J23 VRAM1.N2 VRAM2.N2 VRAM3.N2 VRAM4.N2
FBA_CMD26: U19.J25 VRAM1.M3 VRAM2.M3 VRAM3.M3 VRAM4.M3
FBA_CMD27: U19.J24 VRAM1.N8 VRAM2.N8 VRAM3.N8 VRAM4.N8
FBA_CMD28: U19.K27 VRAM1.N7 VRAM2.N7 VRAM3.N7 VRAM4.N7
FBA_CMD29: U19.K25 VRAM1.L7 VRAM2.L7 VRAM3.L7 VRAM4.L7
FBA_CMD30: U19.J27 VRAM1.J3 VRAM2.J3 VRAM3.J3 VRAM4.J3
FBA_CMD31: TP9.1 U19.J26
FBVDDQ_EN: PR32.1 R431.2 R743.2 U18.4
FDI_CSYNC: R463.1 U24.AL39
FDI_CSYNC_R: R463.2 U27.H29
FDI_INT: U24.AL40 U27.J29
FDI_IREF: R470.1 U24.AT45
FDI_OVRVLTG: R619.2 R620.1 U24.AK1
FDI_RCOMP: R471.2 U24.AR44
FDI_TXN0: U24.AJ35 U27.P33
FDI_TXN1: U24.AL35 U27.N32
FDI_TXP0: U24.AJ36 U27.R33
FDI_TXP1: U24.AL36 U27.P32
G_MBCLK: C338.1 R367.1 U13.94
G_MBCLK_R: R366.1 R367.2 U16.4
G_MBDATA: C341.1 R376.1 U13.95
G_MBDATA_R: R376.2 R377.1 U16.6
GC6_FB_EN: R387.2 R425.1
GPIO0: R153.2 U24.AT8
GPIO2: RP7.2 U24.G17
GPIO8: CN2.2 R601.1 R621.2 R636.1 U24.Y1
GPIO12_ACIN: Q45.1 R403.1 U19.D7
GPIO13: TP98.1 U24.C22
GPIO15: R223.1 U24.AB11
GPIO16: R597.2 R598.1 U24.AN2
GPIO21: R610.1 R622.2 U24.AT1
GPIO24: R184.1 U24.Y10
GPIO35: R568.1 R569.2 U24.AP1
GPIO36: R595.2 R596.1 U24.AT3
GPIO49: R226.1 R227.1 R228.2 R229.2 U24.AK3
GPIO57: R185.1 U24.U12
GPIO70: R556.1 U24.G13
GPIO71: R555.1 U24.H15
GPP_TX4N_LAN: C156.1 U7.18
GPP_TX4P_LAN: C157.1 U7.17
GPU_PEX_RST_HOLD#: R440.1 U19.C4 U21.1
GPU_PWR_GD: PR171.2 R412.1
GPUT_CLK_L: Q3.4 R10.2 U19.D9
GPUT_DATA_L: Q3.1 R12.2 U19.D8
H_CPU_SVIDART#: R521.1 U27.AM28
H_CPU_SVIDCLK: R524.1 U27.AM29
H_CPU_SVIDDAT: R533.2 R534.1 U27.AL28
H_PECI: R275.2 R593.2 U27.AR27
H_PROCHOT#: PQ9.3 PR40.1 PR113.2 PU7.30 Q53.3 R453.1 R454.1
H_PROCHOT#_R: R454.2 U27.AM30
H_PWRGOOD: R50.1 TP124.1 U24.AV3
H_PWRGOOD_R: R50.2 R51.2 R58.1 U27.AL34
HDA_BCLK_R: R498.2 U24.B25
HDA_RST#_R: R506.2 U24.C24
HDA_SDO_R: R501.1 R505.2 U13.106 U24.A24
HDA_SYNC_Q: Q15.3 R102.2 U24.A22
HDA_SYNC_R: C120.1 Q15.1 R91.2 R92.2 R102.1
HDMI_5V: C232.1 CN9.18 D5.1 Q40.1
HDMI_DDCCLK_MB: CN9.15 Q43.3 R298.1
HDMI_DDCCLK_SW: Q43.1 R47.1 U24.R40
HDMI_DDCDATA_MB: CN9.16 Q41.3 R294.1
HDMI_DDCDATA_SW: Q41.1 R48.1 U24.R39
HDMI_MB_HPD: Q37.3 R280.1 R284.1
HP_DET_CN: CN9.19 R280.2
HP_JD#: CN15.6 D24.1 R352.2
HPL: L19.2 R370.1 U15.32
HPL-1: C337.1 L19.1 R368.1 R369.1
HPL_SYS: C336.1 CN15.1 D19.1 R369.2
HPR: L16.2 R360.1 U15.33
HPR-1: C323.1 L16.1 R357.1 R358.1
HPR_SYS: C329.1 CN15.2 D17.1 R358.2
HSYNC: R473.1 U25.2
HWPG: D6.2 D8.2 D9.2 D10.2 R300.1 U13.84
HWPG_1.5V: D9.1 PR137.1 PU8.14
HWPG_1.05V_S5: D8.1 PR67.1 PU4.1
HWPG_1.5VGFX: PR27.1 PU11.1 R33.2
HWPG_VDDR: D10.1 PR76.1 PU5.20
I2C1_SCL_GPIO7_CONN: CN2.8 TP4.1
I2C1_SDA_GPIO6_CONN: CN2.7 TP1.1
I2CA_SCL: R388.1 U19.B7
I2CA_SDA: R397.1 U19.A7
ICLK_BIAS: R79.2 R80.2 U24.AN44
ICLK_IREF: R66.1 U24.AM45
ICMNT: C264.2 PC28.2 PR41.1 PU1.7 U13.67
IMVP_PWRGD: PC170.2 PR122.2 R163.1 R234.1 R235.2 TP63.1 U3.2 U8.1
IMVP_PWRGD_3V: Q59.2 R740.1 U3.4
INT_AMIC-VREFO: C328.1 R362.2 U15.27
INT_HDMI_HPD: Q13.3 Q37.1 R52.1 R63.2
INT_HDMICLK+: C518.1 U27.V31
INT_HDMICLK+_C: C518.2 R301.1 R675.1 R676.1
INT_HDMICLK+_CONN: CN9.10 R301.2
INT_HDMICLK-: C517.1 U27.U31
INT_HDMICLK-_C: C517.2 R299.1 R674.1 R675.2
INT_HDMICLK-_CONN: CN9.12 R299.2
INT_HDMITX0N: C523.1 U27.T28
INT_HDMITX0N_C: C523.2 CN9.3 R316.1 R320.2
INT_HDMITX0P: C525.1 U27.U28
INT_HDMITX0P_C: C525.2 CN9.1 R320.1 R321.1
INT_HDMITX1N: C519.1 U27.T30
INT_HDMITX1N_C: C519.2 CN9.6 R305.1 R306.2
INT_HDMITX1P: C520.1 U27.U30
INT_HDMITX1P_C: C520.2 CN9.4 R306.1 R307.1
INT_HDMITX2N: C521.1 U27.U29
INT_HDMITX2N_C: C521.2 CN9.9 R310.1 R311.2
INT_HDMITX2P: C522.1 U27.V29
INT_HDMITX2P_C: C522.2 CN9.7 R311.1 R314.1
IRQ_SERIRQ: R206.2 R273.1 TP53.1 U13.5 U24.AL11
ISOLATEB: R119.2 R120.1 U7.20
JTAG_TCK: R446.1 TP79.1 U19.AE5
JTAG_TDI: R451.1 TP82.1 U19.AE6
JTAG_TDO: TP81.1 U19.AF6
JTAG_TMS: R444.1 TP80.1 U19.AD6
JTAG_TRST#: R448.1 U19.AG4
KB_BL_LED: Q51.2 U13.88
L_SPK+: R371.2 U15.42
L_SPK+_1: C563.1 CN19.1 R371.1
L_SPK-: R372.2 U15.43
L_SPK-_1: C566.1 CN19.2 R372.1
LAN_DISABLE#: R169.1 U24.K13
LAN_MCT0: R248.1 U29.15
LAN_MCT1: R237.1 U29.16
LAN_MCT2: R236.1 U29.21
LAN_MCT3: R233.1 U29.22
LAN_MX0+: CN7.1 U29.24
LAN_MX0-: CN7.2 U29.23
LAN_MX1+: CN7.3 U29.20
LAN_MX1-: CN7.6 U29.19
LAN_MX2+: CN7.4 U29.18
LAN_MX2-: CN7.5 U29.17
LAN_MX3+: CN7.7 U29.14
LAN_MX3-: CN7.8 U29.13
LAN_XTAL2: C189.2 U7.28 Y1.3
LAN_XTALI: C196.2 U7.29 Y1.1
LANCT3: D2.2 D21.2 R233.2 R236.2 R237.2 R248.2 R560.2
LANVCC: C205.2 C214.2 C461.2 C471.1 C472.1 C485.1 R527.1 R537.2 U7.11 U7.32 U9.5 U10.5
LCDVCC: C4.2 C5.2 C6.1 C11.2 C16.1 R17.1 U2.1
LID#: CN4.2 D1.1 R38.2 U13.86
LINE1L-VREFO: R368.2 U15.31
LINE1L_R: C337.2 U15.22
LINE1R-VREFO: R357.2 U15.30
LINE1R_R: C323.2 U15.21
LINE2-L: T2.1 U15.24
LINE2-R: T1.1 U15.23
LM393_PIN2: PR153.2 PR156.2 PU9.2
LPC_LAD0: R665.2 U11.26 U13.10 U24.A20
LPC_LAD1: R670.2 U11.23 U13.9 U24.C20
LPC_LAD2: R669.2 U11.20 U13.8 U24.A18
LPC_LAD3: R668.2 U11.17 U13.7 U24.C18
LPC_LFRAME#: R667.2 U11.22 U13.6 U24.B21
M_A_A0: JDIM2.98 U27.V8
M_A_A1: JDIM2.97 U27.AC6
M_A_A2: JDIM2.96 U27.V9
M_A_A3: JDIM2.95 U27.U9
M_A_A4: JDIM2.92 U27.AC5
M_A_A5: JDIM2.91 U27.AC4
M_A_A6: JDIM2.90 U27.AD6
M_A_A7: JDIM2.86 U27.AC3
M_A_A8: JDIM2.89 U27.AD5
M_A_A9: JDIM2.85 U27.AC2
M_A_A10: JDIM2.107 U27.V6
M_A_A11: JDIM2.84 U27.AC1
M_A_A12: JDIM2.83 U27.AD4
M_A_A13: JDIM2.119 U27.V7
M_A_A14: JDIM2.80 U27.AD3
M_A_A15: JDIM2.78 U27.AD2
M_A_BS#0: JDIM2.109 U27.V5
M_A_BS#1: JDIM2.108 U27.U5
M_A_BS#2: JDIM2.79 U27.AD1
M_A_CAS#: JDIM2.115 U27.U8
M_A_CKE0: JDIM2.73 U27.AD9
M_A_CKE1: JDIM2.74 U27.AC9
M_A_CLKN0: JDIM2.103 U27.U4
M_A_CLKN1: JDIM2.104 U27.U3
M_A_CLKP0: JDIM2.101 U27.V4
M_A_CLKP1: JDIM2.102 U27.V3
M_A_CS#0: JDIM2.114 U27.M7
M_A_CS#1: JDIM2.121 U27.L9
M_A_DQ0: JDIM2.6 U27.AR15
M_A_DQ1: JDIM2.4 U27.AT14
M_A_DQ2: JDIM2.18 U27.AM14
M_A_DQ3: JDIM2.16 U27.AN14
M_A_DQ4: JDIM2.5 U27.AT15
M_A_DQ5: JDIM2.7 U27.AR14
M_A_DQ6: JDIM2.17 U27.AN15
M_A_DQ7: JDIM2.15 U27.AM15
M_A_DQ8: JDIM2.23 U27.AM9
M_A_DQ9: JDIM2.21 U27.AN9
M_A_DQ10: JDIM2.35 U27.AM8
M_A_DQ11: JDIM2.36 U27.AN8
M_A_DQ12: JDIM2.22 U27.AR9
M_A_DQ13: JDIM2.24 U27.AT9
M_A_DQ14: JDIM2.34 U27.AR8
M_A_DQ15: JDIM2.33 U27.AT8
M_A_DQ16: JDIM2.41 U27.AJ9
M_A_DQ17: JDIM2.42 U27.AK9
M_A_DQ18: JDIM2.53 U27.AJ6
M_A_DQ19: JDIM2.51 U27.AK6
M_A_DQ20: JDIM2.40 U27.AJ10
M_A_DQ21: JDIM2.39 U27.AK10
M_A_DQ22: JDIM2.52 U27.AJ7
M_A_DQ23: JDIM2.50 U27.AK7
M_A_DQ24: JDIM2.59 U27.AF4
M_A_DQ25: JDIM2.57 U27.AF5
M_A_DQ26: JDIM2.69 U27.AF1
M_A_DQ27: JDIM2.70 U27.AF2
M_A_DQ28: JDIM2.56 U27.AG4
M_A_DQ29: JDIM2.58 U27.AG5
M_A_DQ30: JDIM2.67 U27.AG1
M_A_DQ31: JDIM2.68 U27.AG2
M_A_DQ32: JDIM2.130 U27.J1
M_A_DQ33: JDIM2.132 U27.J2
M_A_DQ34: JDIM2.141 U27.J5
M_A_DQ35: JDIM2.140 U27.H5
M_A_DQ36: JDIM2.129 U27.H2
M_A_DQ37: JDIM2.131 U27.H1
M_A_DQ38: JDIM2.143 U27.J4
M_A_DQ39: JDIM2.142 U27.H4
M_A_DQ40: JDIM2.146 U27.F2
M_A_DQ41: JDIM2.147 U27.F1
M_A_DQ42: JDIM2.158 U27.D2
M_A_DQ43: JDIM2.160 U27.D3
M_A_DQ44: JDIM2.148 U27.D1
M_A_DQ45: JDIM2.149 U27.F3
M_A_DQ46: JDIM2.159 U27.C3
M_A_DQ47: JDIM2.157 U27.B3
M_A_DQ48: JDIM2.165 U27.B5
M_A_DQ49: JDIM2.163 U27.E6
M_A_DQ50: JDIM2.174 U27.A5
M_A_DQ51: JDIM2.176 U27.D6
M_A_DQ52: JDIM2.166 U27.D5
M_A_DQ53: JDIM2.164 U27.E5
M_A_DQ54: JDIM2.175 U27.B6
M_A_DQ55: JDIM2.177 U27.A6
M_A_DQ56: JDIM2.180 U27.E12
M_A_DQ57: JDIM2.182 U27.D12
M_A_DQ58: JDIM2.194 U27.B11
M_A_DQ59: JDIM2.192 U27.A11
M_A_DQ60: JDIM2.183 U27.E11
M_A_DQ61: JDIM2.181 U27.D11
M_A_DQ62: JDIM2.191 U27.B12
M_A_DQ63: JDIM2.193 U27.A12
M_A_DQSN0: JDIM2.10 U27.AP15
M_A_DQSN1: JDIM2.27 U27.AP8
M_A_DQSN2: JDIM2.45 U27.AJ8
M_A_DQSN3: JDIM2.62 U27.AF3
M_A_DQSN4: JDIM2.135 U27.J3
M_A_DQSN5: JDIM2.152 U27.E2
M_A_DQSN6: JDIM2.169 U27.C5
M_A_DQSN7: JDIM2.186 U27.C11
M_A_DQSP0: JDIM2.12 U27.AP14
M_A_DQSP1: JDIM2.29 U27.AP9
M_A_DQSP2: JDIM2.47 U27.AK8
M_A_DQSP3: JDIM2.64 U27.AG3
M_A_DQSP4: JDIM2.137 U27.H3
M_A_DQSP5: JDIM2.154 U27.E3
M_A_DQSP6: JDIM2.171 U27.C6
M_A_DQSP7: JDIM2.188 U27.C12
M_A_ODT0: JDIM2.116 U27.M8
M_A_ODT1: JDIM2.120 U27.L7
M_A_RAS#: JDIM2.110 U27.U6
M_A_WE#: JDIM2.113 U27.U7
M_B_A0: JDIM1.98 U27.R8
M_B_A1: JDIM1.97 U27.Y5
M_B_A2: JDIM1.96 U27.Y10
M_B_A3: JDIM1.95 U27.AA5
M_B_A4: JDIM1.92 U27.Y7
M_B_A5: JDIM1.91 U27.AA6
M_B_A6: JDIM1.90 U27.Y6
M_B_A7: JDIM1.86 U27.AA7
M_B_A8: JDIM1.89 U27.Y8
M_B_A9: JDIM1.85 U27.AA10
M_B_A10: JDIM1.107 U27.R9
M_B_A11: JDIM1.84 U27.Y9
M_B_A12: JDIM1.83 U27.AF7
M_B_A13: JDIM1.119 U27.P9
M_B_A14: JDIM1.80 U27.AA8
M_B_A15: JDIM1.78 U27.AG7
M_B_BS#0: JDIM1.109 U27.R7
M_B_BS#1: JDIM1.108 U27.P8
M_B_BS#2: JDIM1.79 U27.AA9
M_B_CAS#: JDIM1.115 U27.P7
M_B_CKE0: JDIM1.73 U27.AF10
M_B_CKE1: JDIM1.74 U27.AG10
M_B_CLKN0: JDIM1.103 U27.Y4
M_B_CLKN1: JDIM1.104 U27.Y3
M_B_CLKP0: JDIM1.101 U27.AA4
M_B_CLKP1: JDIM1.102 U27.AA3
M_B_CS#0: JDIM1.114 U27.P4
M_B_CS#1: JDIM1.121 U27.R2
M_B_DQ0: JDIM1.4 U27.AR18
M_B_DQ1: JDIM1.6 U27.AT18
M_B_DQ2: JDIM1.17 U27.AM17
M_B_DQ3: JDIM1.15 U27.AM18
M_B_DQ4: JDIM1.7 U27.AR17
M_B_DQ5: JDIM1.5 U27.AT17
M_B_DQ6: JDIM1.16 U27.AN17
M_B_DQ7: JDIM1.18 U27.AN18
M_B_DQ8: JDIM1.22 U27.AT12
M_B_DQ9: JDIM1.24 U27.AR12
M_B_DQ10: JDIM1.35 U27.AN12
M_B_DQ11: JDIM1.34 U27.AM11
M_B_DQ12: JDIM1.21 U27.AT11
M_B_DQ13: JDIM1.23 U27.AR11
M_B_DQ14: JDIM1.33 U27.AM12
M_B_DQ15: JDIM1.36 U27.AN11
M_B_DQ16: JDIM1.42 U27.AR5
M_B_DQ17: JDIM1.40 U27.AR6
M_B_DQ18: JDIM1.51 U27.AM5
M_B_DQ19: JDIM1.50 U27.AM6
M_B_DQ20: JDIM1.39 U27.AT5
M_B_DQ21: JDIM1.41 U27.AT6
M_B_DQ22: JDIM1.53 U27.AN5
M_B_DQ23: JDIM1.52 U27.AN6
M_B_DQ24: JDIM1.58 U27.AJ4
M_B_DQ25: JDIM1.57 U27.AK4
M_B_DQ26: JDIM1.69 U27.AJ1
M_B_DQ27: JDIM1.67 U27.AJ2
M_B_DQ28: JDIM1.56 U27.AM1
M_B_DQ29: JDIM1.59 U27.AN1
M_B_DQ30: JDIM1.70 U27.AK2
M_B_DQ31: JDIM1.68 U27.AK1
M_B_DQ32: JDIM1.132 U27.L2
M_B_DQ33: JDIM1.130 U27.M2
M_B_DQ34: JDIM1.143 U27.L4
M_B_DQ35: JDIM1.141 U27.M4
M_B_DQ36: JDIM1.129 U27.L1
M_B_DQ37: JDIM1.131 U27.M1
M_B_DQ38: JDIM1.142 U27.L5
M_B_DQ39: JDIM1.140 U27.M5
M_B_DQ40: JDIM1.149 U27.G7
M_B_DQ41: JDIM1.148 U27.J8
M_B_DQ42: JDIM1.157 U27.G8
M_B_DQ43: JDIM1.159 U27.G9
M_B_DQ44: JDIM1.147 U27.J7
M_B_DQ45: JDIM1.146 U27.J9
M_B_DQ46: JDIM1.158 U27.G10
M_B_DQ47: JDIM1.160 U27.J10
M_B_DQ48: JDIM1.165 U27.A8
M_B_DQ49: JDIM1.163 U27.B8
M_B_DQ50: JDIM1.174 U27.A9
M_B_DQ51: JDIM1.176 U27.B9
M_B_DQ52: JDIM1.164 U27.D8
M_B_DQ53: JDIM1.166 U27.E8
M_B_DQ54: JDIM1.175 U27.D9
M_B_DQ55: JDIM1.177 U27.E9
M_B_DQ56: JDIM1.183 U27.E15
M_B_DQ57: JDIM1.180 U27.D15
M_B_DQ58: JDIM1.194 U27.A15
M_B_DQ59: JDIM1.192 U27.B15
M_B_DQ60: JDIM1.182 U27.E14
M_B_DQ61: JDIM1.181 U27.D14
M_B_DQ62: JDIM1.191 U27.A14
M_B_DQ63: JDIM1.193 U27.B14
M_B_DQSN0: JDIM1.10 U27.AP18
M_B_DQSN1: JDIM1.27 U27.AP11
M_B_DQSN2: JDIM1.45 U27.AP5
M_B_DQSN3: JDIM1.62 U27.AJ3
M_B_DQSN4: JDIM1.135 U27.L3
M_B_DQSN5: JDIM1.152 U27.H9
M_B_DQSN6: JDIM1.169 U27.C8
M_B_DQSN7: JDIM1.186 U27.C14
M_B_DQSP0: JDIM1.12 U27.AP17
M_B_DQSP1: JDIM1.29 U27.AP12
M_B_DQSP2: JDIM1.47 U27.AP6
M_B_DQSP3: JDIM1.64 U27.AK3
M_B_DQSP4: JDIM1.137 U27.M3
M_B_DQSP5: JDIM1.154 U27.H8
M_B_DQSP6: JDIM1.171 U27.C9
M_B_DQSP7: JDIM1.188 U27.C15
M_B_ODT0: JDIM1.116 U27.R4
M_B_ODT1: JDIM1.120 U27.R3
M_B_RAS#: JDIM1.110 U27.R6
M_B_WE#: JDIM1.113 U27.P6
MAIN_ONG: PQ28.2 PQ30.3 PQ31.2 PQ32.2 PQ33.2 PR145.2 PR150.1 Q33.2 Q34.2
MAIND: C217.1 PC105.2 PQ15.4 PQ16.2 PQ24.4 PQ33.3 PR149.2 Q14.2 Q31.4 Q32.2
MAINON: PQ30.2 PR77.2 PR139.1 PR152.1 R304.1 U13.80
MBCLK: PR21.1 PR39.2 PU2.4 R332.1 U13.110
MBDATA: PR19.1 PR38.2 PU2.6 R340.1 U13.111
MDI_0+: R626.1 U7.1
MDI_0+_C: R626.2 U9.6 U29.1
MDI_0-: R629.1 U7.2
MDI_0-_C: R629.2 U9.1 U29.2
MDI_1+: R643.1 U7.4
MDI_1+_C: R643.2 U9.3 U29.5
MDI_1-: R650.1 U7.5
MDI_1-_C: R650.2 U9.4 U29.6
MDI_2+: R651.1 U7.6
MDI_2+_C: R651.2 U10.6 U29.7
MDI_2-: R653.1 U7.7
MDI_2-_C: R653.2 U10.1 U29.8
MDI_3+: R654.1 U7.9
MDI_3+_C: R654.2 U10.3 U29.11
MDI_3-: R655.1 U7.10
MDI_3-_C: R655.2 U10.4 U29.12
MFG_MODE: R204.1 R205.1 U24.AT7
MIC2-VREFO: R283.1 R355.1 U15.29
MOD_EN_5V: C212.1 Q19.3 Q21.6 R159.1
MS_BS: TP169.1 U32.11
MS_INS: TP166.1 U32.5
MX0: C333.2 CN14.26 RP2.4 U13.58
MX1: C332.2 CN14.25 RP2.5 U13.59
MX2: CN14.24 CP6.6 RP2.3 U13.60
MX3: CN14.23 CP6.8 RP2.1 U13.61
MX4: CN14.22 CP5.2 RP2.9 U13.62
MX5: CN14.21 CP5.4 RP2.7 U13.63
MX6: CN14.20 CP5.6 RP2.8 U13.64
MX7: CN14.19 CP5.8 RP2.6 U13.65
MY0: CN14.1 CP1.2 U13.36
MY1: CN14.2 CP1.4 U13.37
MY2: CN14.3 CP1.6 U13.38
MY3: CN14.4 CP1.8 U13.39
MY4: CN14.5 CP2.2 U13.40
MY5: CN14.6 CP2.4 U13.41
MY6: CN14.7 CP2.6 U13.42
MY7: CN14.8 CP2.8 U13.43
MY8: CN14.9 CP3.2 U13.44
MY9: CN14.10 CP3.4 U13.45
MY10: CN14.11 CP3.6 U13.46
MY11: CN14.12 CP3.8 U13.51
MY12: CN14.13 CP4.2 U13.52
MY13: CN14.14 CP4.4 U13.53
MY14: CN14.15 CP4.6 U13.54
MY15: CN14.16 CP4.8 U13.55
MY16: CN14.17 CP6.2 U13.56
MY17: CN14.18 CP6.4 U13.57
N12E_SCL: R398.1 U19.C9
N12E_SDA: R391.1 U19.C8
NBSWON#: CN4.3 R274.1 R276.1 R532.1 SW1.2 U13.125
NV_PLLVDD: C40.2 C56.2 L2.1 U19.L6
OBSDAT_A0: R567.2 TP120.1
OBSDAT_A1: R563.2 TP126.1
OBSDAT_A2: R152.2 TP41.1
OBSDAT_A3: R561.2 TP121.1
OBSDAT_B0: R148.2 TP39.1
OBSDAT_B1: R141.2 TP37.1
OBSDAT_B2: R110.2 TP31.1
OBSDAT_B3: R132.2 TP34.1
OBSDAT_C0: R516.1 TP100.1
OBSDAT_C1: R550.1 TP114.1
OBSDAT_C2: R587.1 TP129.1
OBSDAT_C3: R539.1 TP105.1
OBSDAT_D0: R504.1 TP99.1
OBSDAT_D1: R103.1 TP30.1
OBSDAT_D2: R502.1 TP96.1
OBSDAT_D3: R511.1 TP97.1
OBSFN_B0: R491.1 TP95.1
OBSFN_B1: R487.1 TP92.1
OBSFN_C0: R544.1 R545.1 TP110.1
OBSFN_C1: R546.1 R547.1 TP113.1
OBSFN_D0: R557.1 R558.1 TP122.1
OBSFN_D1: R552.1 R553.1 TP117.1
ODD_DA#: R94.1 RP7.1 U24.F17
ODD_EN: Q21.5 R177.1 R194.1 R195.2
ODD_EN_Q: Q20.2 Q21.2 Q21.3 R182.2
ODD_POWER: R195.1 U13.19
ODD_PRSNT#: C167.1 CN6.8 R137.1 R229.1
PCBEEP: C305.1 U15.12
PCBEEP_EC: D14.2 U13.34
PCH_ACPRESENT: R168.1 R174.1 R200.2 U24.E6
PCH_APWROK: R231.2 R234.2 TP59.1 U24.AB7
PCH_AZ_CODEC_BITCLK: C308.2 C425.2 R498.1 U15.6
PCH_AZ_CODEC_RST#: D15.1 R506.1 R694.1 U15.11
PCH_AZ_CODEC_SDIN0: R345.1 U24.L22
PCH_AZ_CODEC_SDOUT: R505.1 U15.5
PCH_AZ_CODEC_SYNC: R92.1 U15.10
PCH_BATLOW#: R160.1 U24.K7
PCH_BLON: R31.1 U24.K36
PCH_BLON_EC: R28.1 U13.119
PCH_BLON_R: Q8.5 R28.2 R31.2 R32.2
PCH_BRIGHT: CN2.27 U24.N36
PCH_DRQ#0: TP102.1 U24.D21
PCH_DRQ#1: TP35.1 U24.G20
PCH_HOOK1: R274.2 TP66.1
PCH_HOOK7: R485.2 TP89.1
PCH_INVRMEN: R171.2 U24.G10
PCH_JTAG_TCK: R615.1 TP149.1
PCH_JTAG_TCK_R: R574.1 R615.2 U24.AB3
PCH_JTAG_TDI: R609.1 TP137.1
PCH_JTAG_TDI_R: R609.2 R633.2 R634.1 U24.AE2
PCH_JTAG_TDO: R612.1 R640.1 R642.2 TP144.1
PCH_JTAG_TDO_R: R612.2 U24.AD3
PCH_JTAG_TMS: R641.1 TP154.1
PCH_JTAG_TMS_R: R219.2 R635.1 R641.2 U24.AD1
PCH_ODD_EN: R194.2 R518.1
PCH_ODD_EN_R: R517.1 R518.2 U24.C16
PCH_PECI: R593.1 U24.AY1
PCH_PWRBTN#: R580.1 R604.2 U24.K1
PCH_PWROK: R154.1 R163.2 R193.2 U24.F10
PCH_RI#: R585.1 U24.N4
PCH_RSMRST#: R218.2 R606.1 R625.2 U24.J2
PCH_SLP_A#: R583.1 U24.F3
PCH_SLP_LAN#: R189.1 TP55.1 U24.G5
PCH_SLP_S3#: R582.1 U24.H1
PCH_SLP_S4#: R548.1 U24.C6
PCH_SLP_S5#: R212.1 U24.Y7
PCH_SLP_SUS#: R588.1 U24.F1
PCH_SLP_WLAN#: TP51.1 U24.D2
PCH_SPI_CLK: R648.1 TP178.1 U24.AJ11
PCH_SPI_CLK_EC: R645.1 U13.105
PCH_SPI_CS0#: R660.1 TP177.1 U24.AJ7
PCH_SPI_IO2: R663.1 U24.AJ4
PCH_SPI_IO3: R649.2 U24.AJ2
PCH_SPI_SI: R647.1 TP179.1 U24.AH1
PCH_SPI_SI_EC: R341.1 R646.1 U13.102
PCH_SPI_SO: R658.1 TP180.1 U24.AH3
PCH_SPI_SO_EC: R291.1 R659.1 U13.103
PCH_SUSCLK: R213.1 R222.1 U24.Y6
PCH_SUSPWRACK: R581.2 R584.1 R605.1 U24.J4
PCH_SYNCH: R623.1 U24.AY3
PCH_TEMP_ALERT#: R172.2 R513.2 U24.H6 U26.1
PCH_THRMTRIP#: R570.1 R594.1 U24.AV1
PCH_VCC_1_1_20: R144.2 U24.L17
PCH_VCC_1_1_21: R525.2 U24.R18
PCI_PIRQA#: R106.2 U24.H20
PCI_PIRQB#: R121.2 U24.L20
PCI_PIRQC#: R109.2 U24.K17
PCI_PIRQD#: R111.2 U24.M20
PCI_PLTRST#: U24.Y11 U28.1 U28.2
PCI_PME#: TP49.1 U24.AD10
PCIE_CLKREQ_WLAN#: Q56.4 R611.1 R679.2
PCIE_CLKREQ_WLAN#_R: CN10.7 Q56.3 R679.1 R688.1
PCIE_IREF: R499.2 U24.BE30
PCIE_LAN_WAKE#: Q17.3 Q56.1 R118.1 R579.1 R689.2 U24.K3
PCIE_LAN_WAKE#_R: Q17.1 R118.2 R125.1 U7.21
PCIE_RCOMP: R503.1 U24.BD29
PCIE_REQ_LAN#_R: Q18.1 R130.1 R133.2 U7.12
PCIE_RX3+_WLAN: CN10.25 U24.AY33
PCIE_RX3-_WLAN: CN10.23 U24.AW33
PCIE_RX4+_LAN: C157.2 U24.AR33
PCIE_RX4-_LAN: C156.2 U24.AT33
PCIE_TX3+: C424.1 U24.BC34
PCIE_TX3+_WLAN: C424.2 CN10.33
PCIE_TX3-: C423.1 U24.BE34
PCIE_TX3-_WLAN: C423.2 CN10.31
PCIE_TX4+: C422.1 U24.BC36
PCIE_TX4+_LAN: C422.2 U7.13
PCIE_TX4-: C421.1 U24.BE36
PCIE_TX4-_LAN: C421.2 U7.14
PCIE_WAKE#_R: CN10.1 Q56.6 R680.1 R689.1
PCLK_TPM: R467.1 U11.21
PD#: D13.2 D15.2 R346.2 R348.2 U15.47
PEG_RCOMP: R107.2 U27.E23
PEG_RX0: C103.1 U27.L29
PEG_RX0#_C: C104.2 U19.AB9
PEG_RX0_C: C103.2 U19.AC9
PEG_RX1: C92.1 U27.L28
PEG_RX1#_C: C93.2 U19.AC10
PEG_RX1_C: C92.2 U19.AB10
PEG_RX2: C109.1 U27.L31
PEG_RX2#_C: C110.2 U19.AC11
PEG_RX2_C: C109.2 U19.AD11
PEG_RX3: C91.1 U27.K30
PEG_RX3#_C: C90.2 U19.AB12
PEG_RX3_C: C91.2 U19.AC12
PEG_RX4: C107.1 U27.L33
PEG_RX4#_C: C108.2 U19.AC13
PEG_RX4_C: C107.2 U19.AB13
PEG_RX5: C89.1 U27.K32
PEG_RX5#_C: C88.2 U19.AC14
PEG_RX5_C: C89.2 U19.AD14
PEG_RX6: C106.1 U27.L35
PEG_RX6#_C: C105.2 U19.AB15
PEG_RX6_C: C106.2 U19.AC15
PEG_RX7: C86.1 U27.K34
PEG_RX7#_C: C87.2 U19.AC16
PEG_RX7_C: C86.2 U19.AB16
PEG_RX#0: C104.1 U27.M29
PEG_RX#1: C93.1 U27.K28
PEG_RX#2: C110.1 U27.M31
PEG_RX#3: C90.1 U27.L30
PEG_RX#4: C108.1 U27.M33
PEG_RX#5: C88.1 U27.L32
PEG_RX#6: C105.1 U27.M35
PEG_RX#7: C87.1 U27.L34
PEG_TX0: C392.1 U19.AG6
PEG_TX1: C395.1 U19.AF7
PEG_TX2: C397.1 U19.AE9
PEG_TX3: C399.1 U19.AG9
PEG_TX4: C401.1 U19.AF10
PEG_TX5: C402.1 U19.AE12
PEG_TX6: C405.1 U19.AG12
PEG_TX7: C411.1 U19.AF13
PEG_TX#0: C393.2 U19.AG7
PEG_TX#1: C394.1 U19.AE7
PEG_TX#2: C396.1 U19.AF9
